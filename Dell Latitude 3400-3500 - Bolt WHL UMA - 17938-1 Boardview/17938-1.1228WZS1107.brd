# Allegro board 17938-1.1228WZS1107.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQ3: length 52.2
  L4 w0.089: v1(99.58,79.24) 100,78.82 100,77.89 100.56,77.33 100.56,72.11
  L4 w0.203: v1(111.45,49.46) 111.18,49.73 111.18,50.79 107.47,54.5 107.18,54.5 106.61,53.93 106.33,53.93 106.04,54.21 106.04,54.5 106.61,55.07 106.61,55.36 106.32,55.65 106.03,55.65 105.46,55.08 105.18,55.08 104.89,55.36 104.89,55.65 105.46,56.22 105.46,56.51 105.17,56.8 104.88,56.8 104.31,56.23 104.03,56.23 103.74,56.51 103.74,56.8 104.31,57.37 104.31,57.66 104.02,57.95 103.74,57.95 103.16,57.38 102.88,57.38 102.59,57.66 102.59,57.95 103.16,58.52 103.16,58.81 102.84,59.13 102.55,59.13 102.35,58.94 102.05,58.94 101.77,59.22 101.77,59.5 101.97,59.71 101.97,59.99 100.86,61.11 100.86,71.64 100.56,71.94 100.56,72.11
  BOTTOM w0.076: CPU1.AR34 98.65,85.39 98.65,84.44 98.86,84.06 98.86,81.54 98.88,81.52 99.11,80.91 99.11,80.9
  BOTTOM w0.089: 99.11,80.9 99.11,79.58 99.42,79.27 99.55,79.27 v1(99.58,79.24)
  BOTTOM w0.216: v1(111.45,49.46) 111.5,49.51 111.5,50.33 111.53,50.35 DM2.21
M_B_DQ4: length 50.6
  L4 w0.089: 97.44,73.41 97.44,75.03 96.95,75.52 96.95,76.1 96.88,76.18 96.88,80.54 96.78,80.63 96.78,81.57 v1(97.23,82.02)
  L4 w0.203: 97.44,73.41 95.83,71.81 95.83,52.56 98.27,50.12 98.33,50.12 98.96,49.48 98.98,49.48 100.13,48.34 106.18,48.34 106.83,47.68 v1(106.83,46.53)
  BOTTOM w0.076: v1(97.23,82.02) 97.5,82.63 97.5,83.11 97.42,83.33 97.27,83.52 97.17,83.62 97.14,83.66 97.09,83.9 CPU1.AN37
  BOTTOM w0.216: v1(106.83,46.53) 106.83,45.87 107.28,43.91 DM2.4
M_B_DQ5: length 51.1
  L4 w0.089: v1(97.31,78.21) 97.32,78.21 98.09,77.44 98.09,72.76
  L4 w0.203: v1(107.43,48.52) 107.27,48.67 107.15,48.67 106.4,49.41 106.4,49.67 106.21,49.87 105.75,49.87 105.55,49.66 105.55,49.48 105.35,49.28 104.94,49.28 104.74,49.48 104.74,49.66 104.54,49.87 104.13,49.87 103.93,49.66 103.93,49.48 103.72,49.28 103.32,49.28 103.11,49.48 103.11,49.66 102.91,49.87 102.5,49.87 102.3,49.66 102.3,49.48 102.1,49.28 101.69,49.28 101.49,49.48 101.49,49.66 101.28,49.87 100.88,49.87 98.2,52.55 97.28,52.55 96.99,52.84 96.86,53.51 96.86,71.53 98.09,72.76
  BOTTOM w0.076: CPU1.AN36 97.09,84.58 96.82,84.1 96.82,83.81 96.88,83.75 96.88,83.71 96.97,83.59 97.07,83.49 97.3,83.17 97.34,83.08 97.34,82.69 96.79,82.14 96.79,81.87 96.79,80.41 96.87,80.33 96.87,80.33 96.89,80.31 96.89,79.42 96.92,79.4 96.92,78.37 97.08,78.21 v1(97.31,78.21)
  BOTTOM w0.216: v1(107.43,48.52) 107.43,48.52 107.9,48.52 108.03,48.64 DM2.7
M_B_DQ6: length 52.2
  L4 w0.089: v1(99.59,77.9) 100.26,77.23 100.26,71.99
  L4 w0.203: v1(111.46,48.17) 110.98,48.17 110.72,48.42 110.72,50.6 108.14,53.18 106,53.18 105.22,53.97 104.93,53.97 104.47,53.5 104.18,53.5 103.89,53.79 103.89,54.08 104.35,54.54 104.35,54.83 104.07,55.12 103.78,55.12 103.32,54.65 103.03,54.65 102.74,54.94 102.74,55.23 103.2,55.69 103.2,55.98 102.92,56.27 102.63,56.27 102.17,55.8 101.88,55.8 101.59,56.09 101.59,56.38 102.05,56.84 102.05,57.13 101.1,58.09 101.1,60.19 100.4,60.89 100.4,71.64 100.26,71.79 100.26,71.99
  BOTTOM w0.076: v2(98.85,79.27) 98.87,79.3 98.87,80.92 98.72,81.46 98.7,81.49 98.7,83.41 98.69,83.42 98.64,83.96 98.64,84.12 98.39,84.58 CPU1.AR36
  BOTTOM w0.089: v1(99.59,77.9) 99.59,77.9 99.59,78 99.45,78.14 99.43,78.14 99.2,78.37 99.2,78.38 99.14,78.44 99.14,78.45 98.85,78.74 v2(98.85,79.27)
  BOTTOM w0.216: DM2.17 110.53,49.94 110.46,49.87 110.46,48.29 110.58,48.17 v1(111.46,48.17)
M_B_DQ7: length 52.7
  L4 w0.089: v1(99.51,77.27) 99.9,76.89 99.9,76.07 99.85,76.02 99.85,71.77
  L4 w0.203: v1(110.08,47.94) 110.17,48.04 110.17,50.51 107.95,52.72 103.41,52.72 102.97,53.16 102.97,53.45 103.14,53.61 103.14,53.9 102.85,54.19 102.56,54.19 102.4,54.02 102.11,54.02 101.82,54.31 101.82,54.6 101.99,54.76 101.99,55.05 101.7,55.34 101.41,55.34 101.25,55.17 100.96,55.17 100.64,55.5 100.64,56.34 100.43,56.55 99.99,56.55 99.79,56.75 99.79,57.16 99.99,57.36 100.43,57.36 100.64,57.56 100.64,60 99.94,60.7 99.94,71.62 99.85,71.71 99.85,71.77
  BOTTOM w0.076: CPU1.AR37 98.52,83.36 98.53,83.34 98.53,81.43 98.57,81.39 98.71,80.85 98.71,79.71 98.5,79.5 98.5,77.71 98.81,77.4
  BOTTOM w0.089: 98.81,77.4 99.44,77.4 99.52,77.32 99.52,77.27 v1(99.51,77.27)
  BOTTOM w0.216: v1(110.08,47.94) 110.27,47.75 110.59,47.75 110.87,47.46 110.87,47.15 111.28,46.75 DM2.20
M_B_DQ8: length 48.7
  L4 w0.089: 100.87,72.42 100.87,77.27 100.17,77.97 100.17,79.94 99.78,80.34 99.49,80.34 99.24,80.59 99.24,82.21 v1(99.59,82.72)
  L4 w0.203: v1(111.97,47.54) 111.94,47.57 111.94,49.67 111.64,49.97 111.64,51.36 101.58,61.42 101.58,71.71 100.87,72.42
  BOTTOM w0.076: CPU1.AU35 99.86,84.74 99.86,84.57 99.83,84.38 99.83,84.23 99.97,83.43 99.98,83.4 99.98,83.23 v1(99.59,82.72)
  BOTTOM w0.216: v1(111.97,47.54) 112.78,46.73 112.78,44.85 112.28,44.34 DM2.24
M_B_DQ9: length 49
  L4 w0.089: 101.16,72.78 101.16,76.65 101.22,76.71 101.22,77.17 100.35,78.04 100.35,80.04 v1(99.66,80.74)
  L4 w0.203: 101.16,72.78 102.03,71.91 102.03,61.61 112.09,51.55 112.09,50.09 112.35,49.84 112.35,48.16 v1(112.68,47.83)
  BOTTOM w0.076: CPU1.AU34 99.6,85.93 99.35,85.4 99.24,84.31 99.04,83.63 99.03,83.6 99.03,81.6 v1(99.66,80.74)
  BOTTOM w0.216: DM2.28 113.28,47.15 112.91,47.51 112.91,47.6 v1(112.68,47.83)
M_B_DQ10: length 50.5
  L4 w0.089: 106.55,71.74 103.16,75.13 103.16,82.09 102.67,82.57 v1(101.51,82.57)
  L4 w0.203: v1(115.91,48.36) 116.09,48.36 116.52,48.78 116.52,55.7 109.94,62.28 109.65,62.28 109.25,61.88 108.97,61.88 108.68,62.17 108.68,62.46 109.07,62.85 109.07,63.14 108.79,63.43 108.5,63.43 108.1,63.03 107.82,63.03 107.53,63.32 107.53,63.61 107.92,64 107.92,64.29 106.55,65.66 106.55,71.74
  BOTTOM w0.076: CPU1.AW35 101.21,84.98 101.21,84.36 101.24,84.32 101.28,84.24 101.29,84.22 101.29,84.21 101.32,84.15 101.32,83.89 101.32,83.86 101.19,83.38 101.19,83.38 101.18,83.37 101.18,83.35 101.17,83.31 101.17,83.06 101.3,82.93 v1(101.51,82.57)
  BOTTOM w0.216: DM2.41 116.53,49.76 116.53,49.75 116.53,48.75 116.25,48.46 116.22,48.46 116.14,48.39 115.94,48.39 v1(115.91,48.36)
M_B_DQ11: length 48.5
  L4 w0.089: v1(99.64,82.08) 100.87,80.86 100.87,78.18 101.76,77.29 101.76,73.35
  L4 w0.203: v1(113.43,49.52) 113.43,51.01 113.01,51.43 113.01,51.93 110.49,54.44 110.49,54.73 110.79,55.03 110.79,55.32 110.5,55.6 110.21,55.6 109.92,55.3 109.63,55.3 109.34,55.59 109.34,55.88 109.64,56.18 109.64,56.47 109.35,56.75 109.07,56.75 108.77,56.45 108.48,56.45 108.19,56.74 108.19,57.03 108.49,57.33 108.49,57.61 108.2,57.9 107.92,57.9 107.62,57.6 107.33,57.6 107.04,57.89 107.04,58.18 107.34,58.48 107.34,58.76 103.23,62.87 103.23,71.88 101.76,73.35
  BOTTOM w0.076: CPU1.AW34 100.17,85.94 99.96,85.73 100,84.89 100.02,84.78 100.02,84.77 100.02,84.54 100,84.37 100,84.24 100.13,83.47 100.14,83.47 100.14,83.41 100.14,83.21 100.14,83.18 100.12,83.15 99.9,82.34
  BOTTOM w0.165: v1(113.43,49.52) 113.43,49.65 113.53,49.75 DM2.29
  BOTTOM w0.216: 99.9,82.34 v1(99.64,82.08)
M_B_DQ12: length 48.9
  L4 w0.089: v1(99.59,83.37) 99.92,82.94 100.79,81.33 101.37,80.74 101.64,80.74 102.37,80.02 102.37,74.27 104.45,72.19
  L4 w0.203: 104.45,72.19 105.18,71.46 105.18,63.68 113.68,55.17 113.68,54.88 113.38,54.59 113.38,54.3 113.67,54.01 113.96,54.01 114.26,54.31 114.55,54.31 115.06,53.79 115.06,49.85 115.13,49.78 115.13,49.2 v1(114.99,49.06)
  BOTTOM w0.216: v1(114.99,49.06) 114.99,48.1 115.08,48 115.08,47.04 115.78,44.64 DM2.38 ; CPU1.AU37 99.61,83.98 99.61,83.68 v1(99.59,83.37)
M_B_DQ13: length 48.3
  L4 w0.089: 101.56,72.95 101.5,73 101.5,77.14 100.53,78.11 100.53,80.53 v1(99.67,81.38)
  L4 w0.203: v1(112.88,48.52) 112.88,50.8 112.55,51.13 112.55,51.74 105.98,58.31 105.98,58.59 106.27,58.89 106.27,59.18 105.99,59.46 105.7,59.46 105.4,59.17 105.12,59.17 104.83,59.46 104.83,59.74 105.12,60.04 105.12,60.33 104.84,60.61 104.55,60.61 104.26,60.32 103.97,60.32 103.68,60.61 103.68,60.89 103.97,61.19 103.97,61.47 103.69,61.76 103.4,61.76 103.11,61.47 102.82,61.47 102.49,61.79 102.49,72.01 101.56,72.95
  BOTTOM w0.076: v1(99.67,81.38) 99.19,82.02 99.19,83.58 99.35,84.07 99.35,84.09 99.37,84.16 99.38,84.17 99.38,84.18 99.6,84.58 CPU1.AU36
  BOTTOM w0.216: v1(112.88,48.52) 112.6,48.52 112.44,48.67 112.44,49.94 112.53,50.02 112.53,51.1
M_B_DQ14: length 49.4
  L4 w0.089: v1(101.51,81.88) 102.8,80.6 102.8,74.88 105.59,72.09
  L4 w0.203: 105.59,72.09 106.09,71.58 106.09,64.11 108.9,61.3 109.19,61.01 109.48,61.01 109.83,61.37 110.12,61.37 110.41,61.08 110.41,60.79 110.05,60.44 110.05,60.15 110.34,59.86 110.63,59.86 110.98,60.22 111.27,60.22 111.56,59.93 111.56,59.64 111.2,59.29 111.2,59 111.49,58.71 111.78,58.71 112.13,59.07 112.42,59.07 112.71,58.78 112.71,58.49 112.35,58.14 112.35,57.85 112.64,57.56 112.93,57.56 113.28,57.92 113.57,57.92 113.86,57.63 113.86,57.34 113.5,56.99 113.5,56.7 113.79,56.41 114.08,56.41 114.43,56.77 114.72,56.77 116.03,55.46 v1(116.03,49.61)
  BOTTOM w0.076: v1(101.51,81.88) 101.01,82.6 101.01,83.35 101.16,83.91 101.16,84.06 101.13,84.16 100.9,84.58 CPU1.AW36
  BOTTOM w0.216: DM2.37 115.53,50.19 116.03,49.68 v1(116.03,49.61)
M_B_DQ15: length 49.5
  L4 w0.089: v1(101.5,81.18) 101.82,81.18 102.62,80.38 102.62,74.52 105.63,71.51
  L4 w0.203: 105.63,71.51 105.63,63.92 114.09,55.47 114.38,55.47 114.71,55.81 115,55.81 115.29,55.52 115.29,55.23 114.95,54.89 114.95,54.61 115.53,54.02 115.53,48.93 115.32,48.71 115.32,48.16 115.59,47.89 115.77,47.89 115.79,47.87 115.99,47.87 v1(116.41,47.45)
  BOTTOM w0.076: v1(101.5,81.18) 100.84,82.19 100.84,83.36 CPU1.AW37
  BOTTOM w0.216: DM2.42 116.78,46.96 116.45,47.28 116.45,47.41 v1(116.41,47.45)
M_B_DQ16: length 92.5
  L2SGND w0.089: 97.57,82.36 97.41,82.53 96.56,82.53 96.2,82.89 96.07,82.89 94.47,84.5 94.47,87.59 94.67,87.8 94.67,88.26 94.73,88.32 94.73,88.79 v1(95.24,89.3)
  L2SGND w0.114: 97.57,82.36 97.84,82.09 97.84,73.81 108.3,63.35 140.57,63.35 151.31,52.62 151.31,51.74 152.55,50.5 152.71,50.5 152.95,50.74 153.11,50.74 153.27,50.57 153.27,50.41 153.03,50.18 153.03,50.01 153.2,49.85 153.36,49.85 153.59,50.09 153.76,50.09 153.92,49.93 153.92,49.77 153.68,49.53 153.68,49.37 153.87,49.18 153.87,48.69 v1(154.76,47.8)
  BOTTOM w0.089: v1(95.24,89.3) 94.87,88.93 CPU1.AJ29
  BOTTOM w0.216: v1(154.76,47.8) 154.93,47.8 156.03,48.9 DM2.191
M_B_DQ17: length 92.4
  L2SGND w0.089: v1(95.24,88.67) 95.24,88.58 94.85,88.19 94.85,87.72 94.64,87.52 94.64,85.62 96.84,83.43 97.08,83.43 98.02,82.49 98.02,82.43 98.07,82.38
  L2SGND w0.114: 98.07,82.38 98.07,74.11 108.48,63.7 140.72,63.7 151.65,52.76 151.65,52.03 151.89,51.79 152.05,51.79 152.26,51.99 152.42,51.99 152.58,51.83 152.58,51.67 152.38,51.46 152.38,51.3 152.54,51.14 152.7,51.14 152.91,51.34 153.07,51.34 153.23,51.18 153.23,51.18 155.28,49.13 v1(155.28,46.47)
  BOTTOM w0.089: CPU1.AJ30 94.85,88.28 v1(95.24,88.67)
  BOTTOM w0.216: v1(155.28,46.47) 155.34,46.47 155.79,46.02 155.79,42.92 DM2.190
M_B_DQ18: length 92.9
  L2SGND w0.089: v1(97.04,86.71) 97.04,86.04 98.59,84.49 99.54,84.49 100.7,83.32 100.7,83.01
  L2SGND w0.114: 100.7,83.01 100.7,75.52 109.45,66.78 142.66,66.78 142.86,66.58 142.86,66.4 142.64,66.19 142.64,66.01 142.79,65.86 142.96,65.86 143.19,66.09 143.35,66.09 143.74,65.7 143.74,64.91 144.14,64.52 144.92,64.52 150.49,58.95 150.49,58.95 150.52,58.91 150.52,58.13 151.04,57.61 151.83,57.61 152,57.44 152,57.44 152.09,57.35 152.09,56.98 152,56.89 152,56.69 153.19,55.5 153.5,55.5 159,50 159,47.86 159.16,47.7 159.48,47.7 v1(159.52,47.73)
  BOTTOM w0.216: v1(159.52,47.73) 159.31,47.53 159.31,47.21 159.44,47.09 159.9,47.09 160.03,47.21 DM2.207 ; CPU1.AM32 97.04,86.72 97.04,86.71 v1(97.04,86.71)
M_B_DQ19: length 93.5
  L2SGND w0.089: 100.28,83.24 100.28,83.49 99.46,84.31 98.52,84.31 96.64,86.19 96.64,86.97 v1(97.04,87.36)
  L2SGND w0.114: 100.28,83.24 100.36,83.16 100.36,75.38 109.3,66.43 141.73,66.43 153.03,55.14 153.19,55.14 153.21,55.15 153.37,55.15 153.53,54.99 153.53,54.82 153.52,54.81 153.52,54.65 153.68,54.49 153.84,54.49 153.85,54.5 154.01,54.5 154.18,54.34 154.18,54.18 154.16,54.17 154.16,54 154.33,53.84 154.49,53.84 154.5,53.85 154.66,53.85 154.82,53.69 154.82,53.53 154.81,53.52 154.81,53.36 154.97,53.2 155.13,53.2 155.15,53.21 155.31,53.21 155.47,53.05 155.47,52.88 155.46,52.87 155.46,52.71 155.62,52.55 155.78,52.55 155.79,52.56 155.95,52.56 156.12,52.4 156.12,52.24 156.1,52.23 156.1,52.06 156.27,51.9 156.43,51.9 156.44,51.91 156.6,51.91 158.66,49.86 158.66,46.57 158.9,46.33 159.64,46.33 159.77,46.46 v1(159.77,46.6)
  BOTTOM w0.089: v1(97.04,87.36) 96.99,87.4 96.98,87.44 CPU1.AM31
  BOTTOM w0.216: v1(159.77,46.6) 160.06,46.6 160.28,46.38 DM2.208
M_B_DQ20: length 93.6
  L2SGND w0.089: v1(97.06,88.03) 97.44,87.65 97.44,85.89 98.67,84.66 99.61,84.66 101.04,83.24 101.04,83.08
  L2SGND w0.114: 101.04,83.08 101.04,78.27 101.12,78.18 101.12,76.58 101.23,76.47 101.41,76.47 101.53,76.35 101.53,76.12 101.41,76.01 101.23,76.01 101.12,75.89 101.12,75.61 109.59,67.14 142.78,67.14 144.29,65.63 144.29,65.44 144.08,65.23 144.08,65.05 144.25,64.89 144.39,64.89 144.62,65.12 144.8,65.12 151.13,58.79 151.13,58.63 150.89,58.39 150.89,58.25 151.08,58.06 151.21,58.06 151.45,58.31 151.62,58.31 152.71,57.21 152.71,57.05 152.53,56.87 152.53,56.66 152.66,56.52 152.82,56.52 153.03,56.73 153.19,56.73 153.36,56.57 153.36,56.41 153.17,56.22 153.17,56.03 153.32,55.89 153.48,55.89 153.68,56.08 153.84,56.08 155.07,54.85 155.07,54.58 155.07,54.58 155.07,54.42 155.23,54.25 155.39,54.25 155.4,54.26 155.56,54.26 155.72,54.09 155.72,53.93 155.72,53.93 155.72,53.77 155.88,53.61 156.04,53.61 156.04,53.61 156.21,53.61 156.37,53.45 156.37,53.29 156.36,53.28 156.36,53.12 156.53,52.96 156.69,52.96 156.69,52.96 156.85,52.96 157.01,52.8 157.01,52.64 157.01,52.64 157.01,52.48 157.17,52.31 157.33,52.31 157.34,52.32 157.5,52.32 157.66,52.15 157.66,51.99 157.66,51.99 157.66,51.83 157.82,51.67 157.98,51.67 157.98,51.67 158.15,51.67 158.31,51.51 158.31,51.35 158.3,51.34 158.3,51.18 158.47,51.02 158.63,51.02 158.63,51.02 158.79,51.02 158.95,50.86 158.95,50.7 158.95,50.7 158.95,50.54 159.11,50.37 159.27,50.37 159.28,50.38 159.44,50.38 159.96,49.85 159.96,49.12 159.82,48.97 159.55,48.97 v1(159.52,49)
  BOTTOM w0.089: v1(97.06,88.03) CPU1.AM30
  BOTTOM w0.216: v1(159.52,49) 159.15,49 159.03,49.13 DM2.203
M_B_DQ21: length 94.1
  L2SGND w0.089: 100.08,83.16 100.08,83.44 99.39,84.13 98.31,84.13 97.34,85.1 96.44,85.1 96.08,85.46 96.08,85.8 96.08,85.8 96.08,86 96.34,86.26 96.34,86.34 96.47,86.46 96.47,87.04 96.57,87.15 96.57,88.18 v1(97.06,88.67)
  L2SGND w0.114: 100.08,83.16 100.08,81.56 100.09,81.55 100.09,75.17 109.16,66.09 141.59,66.09 156.42,51.26 156.77,51.26 158.31,49.72 158.31,46.01 159.07,45.25 v1(159.77,45.25)
  BOTTOM w0.089: v1(97.06,88.67) CPU1.AM29
  BOTTOM w0.216: DM2.204 159.28,44.79 159.74,45.25 v1(159.77,45.25)
M_B_DQ22: length 90.7
  L2SGND w0.089: v1(95.25,88.02) 95.25,87.87 95.02,87.65 94.82,87.45 94.82,85.7 96.9,83.62 97.16,83.62 98.22,82.55
  L2SGND w0.114: 98.22,82.55 98.22,82.52 98.28,82.47 98.28,74.39 108.6,64.07 140.83,64.07 155.67,49.23 155.71,48.97 155.74,48.72 156.1,47.16 156.27,46.79 156.44,46.39 156.53,46.19 156.64,45.96 156.79,45.52 157.01,45.29 v1(157.26,45.03)
  BOTTOM w0.076: CPU1.AJ31 v1(95.25,88.02)
  BOTTOM w0.216: v1(157.26,45.03) 156.78,44.54 DM2.194
M_B_DQ23: length 91
  L2SGND w0.089: v1(95.22,87.28) 95,87.06 95,85.77 96.97,83.8 97.25,83.8 98.43,82.62 98.43,82.6
  L2SGND w0.114: v1(156.54,49.03) 156.35,49.23 156.34,49.23 156.09,49.48 156.09,49.49 141.17,64.41 140.97,64.41 140.78,64.61 140.52,64.61 140.32,64.41 140.06,64.41 139.86,64.61 139.6,64.61 139.41,64.41 139.15,64.41 138.95,64.61 138.69,64.61 138.49,64.41 138.23,64.41 138.03,64.61 137.77,64.61 137.58,64.41 137.32,64.41 137.12,64.61 136.86,64.61 136.66,64.41 136.4,64.41 136.21,64.61 135.95,64.61 135.75,64.41 135.49,64.41 135.29,64.61 135.03,64.61 134.83,64.41 134.57,64.41 134.38,64.61 134.12,64.61 133.92,64.41 133.66,64.41 133.46,64.61 133.2,64.61 133.01,64.41 132.74,64.41 132.55,64.61 132.29,64.61 132.09,64.41 131.83,64.41 131.63,64.61 131.37,64.61 131.18,64.41 130.92,64.41 130.72,64.61 130.46,64.61 130.26,64.41 130,64.41 129.8,64.61 129.54,64.61 129.35,64.41 129.09,64.41 128.89,64.61 128.63,64.61 128.43,64.41 128.17,64.41 127.98,64.61 127.72,64.61 127.52,64.41 127.26,64.41 127.06,64.61 126.8,64.61 126.6,64.41 126.34,64.41 126.15,64.61 125.89,64.61 125.69,64.41 125.43,64.41 125.23,64.61 124.97,64.61 124.78,64.41 124.52,64.41 124.32,64.61 124.06,64.61 123.86,64.41 123.6,64.41 123.4,64.61 123.14,64.61 122.95,64.41 122.69,64.41 122.49,64.61 122.23,64.61 122.03,64.41 121.77,64.41 121.58,64.61 121.31,64.61 121.12,64.41 120.86,64.41 120.66,64.61 120.4,64.61 120.2,64.41 119.94,64.41 119.75,64.61 119.49,64.61 119.29,64.41 119.03,64.41 118.83,64.61 118.57,64.61 118.37,64.41 118.11,64.41 117.92,64.61 117.66,64.61 117.46,64.41 117.2,64.41 117,64.61 116.74,64.61 116.55,64.41 116.29,64.41 116.09,64.61 115.83,64.61 115.63,64.41 115.37,64.41 115.17,64.61 114.91,64.61 114.72,64.41 114.46,64.41 114.26,64.61 114,64.61 113.8,64.41 108.74,64.41 98.5,74.65 98.5,82.53 98.43,82.6
  BOTTOM w0.089: v1(95.22,87.28) 95.22,86.96 95.13,86.87 94.9,86.87 CPU1.AJ32
  BOTTOM w0.216: DM2.195 157.03,49.47 156.58,49.03 v1(156.54,49.03)
M_B_DQ24: length 92.2
  L2SGND w0.089: 102.26,84.08 102.07,84.27 101.06,84.27 98.93,86.4 v1(98.93,87.3)
  L2SGND w0.114: v1(161.34,47.45) 161.38,47.49 161.85,47.49 161.96,47.6 161.96,49.93 159.56,52.33 156.81,55.08 156.81,55.48 151.26,61.03 150.86,61.03 149.91,61.98 149.91,62.38 143.78,68.51 110.21,68.51 104.83,73.89 104.02,73.89 102.77,75.14 102.77,83.57 102.26,84.08
  BOTTOM w0.089: v1(98.93,87.3) 98.89,87.33 98.81,87.4 98.79,87.45 CPU1.AR31
  BOTTOM w0.216: v1(161.34,47.45) 161.64,47.45 162.03,47.83 DM2.215
M_B_DQ25: length 91.5
  L2SGND w0.089: v1(98.51,86.44) 98.51,85.58 98.89,85.2 99.86,85.2 100.96,84.09 101.89,84.09 102,83.99
  L2SGND w0.114: 102,83.99 102.47,83.52 102.47,75.15 103.93,73.69 104.52,73.69 110.04,68.17 143.24,68.17 144.07,67.33 144.24,67.33 144.27,67.37 144.44,67.37 144.6,67.21 144.6,67.05 144.56,67.01 144.56,66.85 144.72,66.68 144.88,66.68 144.92,66.72 145.08,66.72 145.24,66.56 145.24,66.4 145.21,66.36 145.21,66.2 145.37,66.04 145.53,66.04 145.57,66.08 145.73,66.08 145.89,65.91 145.89,65.75 145.85,65.71 145.85,65.55 146.01,65.39 146.18,65.39 146.21,65.43 146.38,65.43 146.54,65.27 146.54,65.11 146.5,65.07 146.5,64.91 146.66,64.74 146.82,64.74 146.86,64.78 147.02,64.78 147.18,64.62 147.18,64.46 147.15,64.42 147.15,64.26 147.31,64.1 147.47,64.1 147.51,64.14 147.67,64.14 147.83,63.97 147.83,63.81 147.79,63.77 147.79,63.61 147.96,63.45 148.12,63.45 148.15,63.49 148.32,63.49 148.48,63.33 148.48,63.17 148.44,63.13 148.44,62.97 148.6,62.8 148.76,62.8 148.8,62.84 148.96,62.84 149.12,62.68 149.12,62.52 149.09,62.48 149.09,62.32 151.62,59.79 151.78,59.79 151.82,59.82 151.98,59.82 152.14,59.66 152.14,59.5 152.1,59.46 152.1,59.3 152.27,59.14 152.43,59.14 152.47,59.18 152.63,59.18 152.79,59.02 152.79,58.85 152.75,58.82 152.75,58.65 152.91,58.49 153.07,58.49 153.11,58.53 153.27,58.53 153.44,58.37 153.44,58.21 153.4,58.17 153.4,58.01 153.56,57.85 153.72,57.85 153.76,57.88 153.92,57.88 154.08,57.72 154.08,57.56 154.04,57.52 154.04,57.36 154.21,57.2 154.37,57.2 154.41,57.24 154.57,57.24 154.73,57.08 154.73,56.91 154.69,56.88 154.69,56.71 160.99,50.41 160.99,49.14 v1(161.35,48.78)
  BOTTOM w0.216: DM2.211 161,51.07 161,49.12 161.33,48.78 v1(161.35,48.78) ; CPU1.AR32 v1(98.51,86.44)
M_B_DQ26: length 95.1
  L2SGND w0.089: 106.22,80.83 106.22,81.51 105.84,81.9 104.93,83.81 104.54,84.2 103.57,84.55 103.51,84.57 102.15,85.93 102.15,85.95 101.81,86.29 101.81,86.64 101.22,87.23 101.22,87.52 v1(100.71,88.03)
  L2SGND w0.114: v1(166.09,47.46) 166.41,47.46 166.53,47.59 166.53,48.98 166.51,49 166.51,49.61 166.26,49.87 165.99,49.87 144.84,71.03 111.45,71.03 106.6,75.88 106.6,78.3 106.48,78.41 106.23,78.41 106.12,78.53 106.12,78.75 106.23,78.87 106.48,78.87 106.6,78.98 106.6,79.21 106.48,79.33 106.23,79.33 106.12,79.44 106.12,79.67 106.23,79.78 106.48,79.78 106.6,79.9 106.6,80.45 106.22,80.83
  BOTTOM w0.089: v1(100.71,88.03) CPU1.AV30
  BOTTOM w0.216: DM2.228 165.28,47.04 165.7,47.46 v1(166.09,47.46)
M_B_DQ27: length 94.7
  L2SGND w0.089: 104.65,79.25 104.44,83.55 104.26,83.72 103.1,84.15 102.41,84.84 101.62,84.84 100.32,86.15 100.32,86.9 100.33,86.9 100.33,87.74 100.31,87.76 100.31,88.27 v1(100.71,88.67)
  L2SGND w0.114: v1(163.96,47.1) 163.96,46.76 164.11,46.62 164.37,46.62 164.5,46.75 164.5,49.91 144.41,70 111.03,70 105.51,75.51 105.51,76.73 104.65,77.6 104.65,79.25
  BOTTOM w0.089: v1(100.71,88.67) CPU1.AV29
  BOTTOM w0.216: v1(163.96,47.1) 164.53,47.66 DM2.225
M_B_DQ28: length 93.4
  L2SGND w0.089: v1(98.88,88.04) 98.88,88.04 98.5,87.66 98.5,87 98.11,86.61 98.11,85.73 98.81,85.02 99.78,85.02 100.89,83.91 101.76,83.91 101.84,83.83
  L2SGND w0.114: 101.84,83.83 102.26,83.42 102.26,75.07 103.85,73.48 104.24,73.48 109.9,67.83 143.07,67.83 156.05,54.84 156.08,54.84 160.65,50.27 160.65,48.38 160.72,47.48 160.81,46.39 161.13,45.79 v1(161.27,45.75)
  BOTTOM w0.089: CPU1.AR30 98.87,88.04 v1(98.88,88.04)
  BOTTOM w0.216: DM2.216 162.28,43.94 162.26,43.95 162.25,44.79 162.25,44.99 161.5,45.75 v1(161.27,45.75)
M_B_DQ29: length 93.4
  L2SGND w0.089: 102.02,83.37 101.7,83.69 100.86,83.69 100.85,83.7 99.7,84.84 98.74,84.84 97.93,85.65 97.93,86.75 98.31,87.13 98.31,87.47 98.31,87.81 98.37,87.87 98.37,88.19 98.86,88.68 v1(98.89,88.68)
  L2SGND w0.114: 102.02,83.37 102.02,75.02 103.77,73.28 103.94,73.28 109.74,67.48 142.93,67.48 160.31,50.1 160.31,48.37 160.49,46.11 160.77,44.83 v1(161.25,44.36)
  BOTTOM w0.089: CPU1.AR29 98.83,88.7 98.87,88.7 v1(98.89,88.68)
  BOTTOM w0.216: DM2.212 161.28,43.92 161.25,43.95 v1(161.25,44.36)
M_B_DQ30: length 92.5
  L2SGND w0.089: 105.01,77.86 104.86,78.02 104.84,79.26 104.61,83.63 104.35,83.89 103.38,84.23 103.2,84.3 102.48,85.02 101.7,85.02 100.72,86 v1(100.72,86.73)
  L2SGND w0.114: v1(163.81,44.97) 164.63,44.97 164.84,45.18 164.84,50.05 144.55,70.34 111.17,70.34 105.77,75.74 105.77,76.77 105.01,77.52 105.01,77.86
  BOTTOM w0.216: v1(100.72,86.73) 100.5,86.73 CPU1.AV32 ; DM2.224 164.28,44.75 164.07,44.96 163.82,44.96 v1(163.81,44.97)
M_B_DQ31: length 92.9
  L2SGND w0.089: 105.29,77.6 105.29,77.86 105.03,78.11 105.03,78.35 105.03,82.41 104.98,83.29 104.78,83.71 104.44,84.05 103.57,84.36 103.44,84.4 103.41,84.41 101.97,85.86 101.97,85.88 101.63,86.22 101.63,86.46 v1(100.73,87.37)
  L2SGND w0.114: 105.29,77.6 106,76.89 106,76 111.31,70.68 144.69,70.68 165.18,50.19 165.18,46.99 165.31,46.87 165.52,46.87 165.65,46.99 165.65,48.67 165.78,48.79 v1(166.1,48.79)
  BOTTOM w0.089: v1(100.73,87.37) 100.72,87.37 100.25,87.61 CPU1.AV31
  BOTTOM w0.216: v1(166.1,48.79) 165.83,48.79 165.53,49.1 DM2.229
M_B_DQ32: length 50.6
  L4 w0.089: v1(103.73,77.14) 103.74,77.14 105.19,75.69
  L4 w0.203: v1(118.6,47.45) 118.91,47.45 119.06,47.6 119.06,48.98 119.04,49.01 119.04,49.43 118.6,49.87 118.6,57.95 111.3,65.25 111.3,65.54 111.57,65.81 111.57,66.09 109.51,68.15 108.75,68.15 108.57,68.33 108.57,72.32 105.19,75.69
  BOTTOM w0.076: CPU1.BA35 102.22,85.19 102.29,84.98 102.29,84.97 102.38,84.73 102.38,84.54 102.34,84.43 102.34,84.42 102.34,84.42 102.34,84.2 102.37,84.08 102.43,83.72 102.46,83.45 102.47,83.3 102.47,82.02 102.54,81.31 102.54,81.25 102.62,80.38 102.62,78.48
  BOTTOM w0.089: 102.62,78.48 102.62,78.02 102.77,77.88
  BOTTOM w0.216: DM2.50 118.78,44.9 118.57,45.11 118.57,47.43 v1(118.6,47.45) ; v1(103.73,77.14) 103.51,77.14 102.77,77.88
M_B_DQ33: length 51.7
  L4 w0.089: 107.12,71.67 104.04,74.75 v1(104.04,74.83)
  L4 w0.203: v1(117.69,47.45) 117.03,48.1 117.03,56.2 108.31,64.93 108.31,65.22 108.69,65.6 108.69,65.89 108.4,66.17 108.11,66.17 107.73,65.79 107.45,65.79 107.12,66.12 107.12,71.67
  BOTTOM w0.076: CPU1.BA34 101.8,85.29 101.8,84.34 101.74,84.24 101.7,84.16 101.7,83.83 101.96,83.36 101.97,83.28 101.97,82 102.03,81.41 102.06,80.16 102.06,77.89 101.84,77.68
  BOTTOM w0.216: v1(117.69,47.45) 117.8,47.34 117.8,46.87 117.78,46.84 DM2.46 ; 101.84,77.68 101.84,76.32 102.7,75.46 102.74,75.46 103.37,74.83 v1(104.04,74.83)
M_B_DQ34: length 50.1
  L4 w0.089: 110.83,72.76 110.83,72.81 106.47,77.18 106.06,77.18 105.2,78.04 105.2,81.4 105.18,81.42 105.18,81.5 103.99,82.69 103.99,82.74 v1(103.98,82.75)
  L4 w0.203: 110.83,72.76 112.81,70.78 112.81,70.49 112.49,70.16 112.49,69.88 112.77,69.59 113.06,69.59 113.39,69.92 113.68,69.92 113.96,69.63 113.96,69.34 113.64,69.01 113.64,68.73 113.92,68.44 114.21,68.44 114.54,68.77 114.82,68.77 115.11,68.48 115.11,68.19 114.78,67.86 114.78,67.58 115.07,67.29 115.36,67.29 115.69,67.62 115.97,67.62 116.26,67.33 116.26,67.04 115.93,66.71 115.93,66.43 116.22,66.14 116.51,66.14 116.84,66.47 117.12,66.47 117.45,66.14 117.45,64.91 122,60.36 v1(122,49.61)
  BOTTOM w0.076: v1(103.98,82.75) 103.65,83.26 103.65,83.48 103.83,83.81 103.84,83.85 103.84,84.11 103.78,84.29 103.66,84.77 CPU1.BC35
  BOTTOM w0.216: DM2.63 122.03,49.68 122,49.66 v1(122,49.61)
M_B_DQ35: length 51.8
  L4 w0.089: v1(104.24,78.15) 104.24,78 109.94,72.3
  L4 w0.203: v1(120.2,48.26) 120.6,48.66 120.6,59.82 110.51,69.91 110.51,71.7 109.94,72.26 109.94,72.3
  BOTTOM w0.076: CPU1.BC34 102.68,85.94 102.48,85.73 102.46,85.71 102.46,85 102.55,84.75 102.55,84.52 102.51,84.4 102.51,84.22 102.52,84.14 102.53,84.12 102.53,84.11 102.6,83.79 102.62,83.46 102.62,83.45 102.63,83.31 102.63,82.03 102.8,80.44 102.8,79.45 103.03,78.93
  BOTTOM w0.089: v1(104.24,78.15) 103.43,78.53 103.03,78.93
  BOTTOM w0.216: v1(120.2,48.26) 120.2,46.31 120.78,45.74 DM2.58
M_B_DQ36: length 49.4
  L4 w0.076: 104.95,75.1 104.95,75.49 103.99,76.45 v1(103.73,76.45)
  L4 w0.203: 104.95,75.1 108.11,71.95 108.11,67.79 108.48,67.42 108.77,67.42 109.04,67.69 109.32,67.69 109.61,67.4 109.61,67.12 109.34,66.85 109.34,66.56 109.63,66.27 109.91,66.27 110.19,66.54 110.47,66.54 110.76,66.25 110.76,65.97 110.49,65.7 110.49,65.41 116.1,59.8 116.1,59.52 115.72,59.14 115.72,58.81 115.97,58.56 116.29,58.56 116.67,58.94 116.96,58.94 117.29,58.61 117.29,58.32 116.87,57.9 116.87,57.66 118.14,56.39 118.14,49.75 118.33,49.57 118.33,48.84 v1(118.11,48.63)
  BOTTOM w0.076: CPU1.BA37 102.26,83.53 102.3,83.37 102.3,83.29 102.3,82.01 102.38,81.3 102.38,81.25 102.42,80.83 102.42,78.08
  BOTTOM w0.089: 102.42,78.08 102.42,77.76 102.77,77.41
  BOTTOM w0.216: v1(103.73,76.45) 103.24,76.45 102.77,76.92 102.77,77.41 ; DM2.49 118.53,50.14 118.52,50.13 118.52,48.72 118.37,48.57 118.19,48.57 118.13,48.63 v1(118.11,48.63)
M_B_DQ37: length 50.3
  L4 w0.076: 104.55,75.34 v1(104.02,75.87)
  L4 w0.203: v1(117.53,49.61) 117.53,56.36 114.94,58.94 114.94,59.23 115.12,59.41 115.12,59.68 114.83,59.96 114.52,59.96 114.37,59.81 114.08,59.81 113.79,60.09 113.79,60.38 114.17,60.76 114.17,61.05 113.89,61.34 113.6,61.34 113.22,60.95 112.93,60.95 112.64,61.24 112.64,61.53 113.02,61.91 113.02,62.2 112.74,62.49 112.45,62.49 112.07,62.1 111.78,62.1 111.49,62.39 111.49,62.68 111.87,63.06 111.87,63.35 111.59,63.63 111.3,63.63 110.92,63.25 110.63,63.25 110.34,63.54 110.34,63.83 110.72,64.21 110.72,64.5 110.44,64.78 110.15,64.78 109.77,64.4 109.48,64.4 109.19,64.69 109.19,64.98 109.57,65.36 109.57,65.65 107.65,67.57 107.65,71.81 104.55,74.91 104.55,75.34
  BOTTOM w0.076: 102.31,77.36 102.31,77.63 102.24,77.69 102.24,78.15 102.25,78.15 102.25,80.35 102.21,80.92 102.21,81.3 102.14,82.01 102.14,83.29 102.13,83.34 102.12,83.41 102.08,83.49 101.92,83.79 101.91,83.79 101.87,83.87 101.87,84.11 101.89,84.16 101.92,84.19 101.92,84.21 101.95,84.27 101.97,84.3 101.97,84.31 102.12,84.58 CPU1.BA36
  BOTTOM w0.089: 102.31,77.2 102.31,77.36
  BOTTOM w0.216: 102.31,77.2 102.31,76.71 103.15,75.87 v1(104.02,75.87) ; v1(117.53,49.61) DM2.45
M_B_DQ38: length 49.4
  L4 w0.089: v1(103.9,82.08) 104.3,81.69 104.47,81.42 104.93,80 104.93,78.05 106.18,76.81 106.37,76.81 110.79,72.39
  L4 w0.203: 110.79,72.39 110.79,72.28 111.42,71.64 111.42,70.29 121.52,60.2 121.52,47.87 v1(122.13,47.26)
  BOTTOM w0.076: CPU1.BC36 103.67,84.09 103.67,83.88 103.5,83.55 103.48,83.51 103.48,83.15 103.61,82.61 103.64,82.56 v1(103.9,82.08)
  BOTTOM w0.216: v1(122.13,47.26) 122.13,47.57 121.31,48.39 121.3,48.41 121.03,48.68 121.03,48.91 121.03,48.92 DM2.59
M_B_DQ39: length 48.8
  L4 w0.089: v1(103.9,81.45) 104.23,81.12 104.66,79.66 104.66,78.07 110.43,72.3
  L4 w0.203: 110.43,72.3 110.43,72.19 110.97,71.65 110.97,70.1 121.06,60.01 121.06,48.38 120.9,48.21 120.9,48.21 v1(120.85,48.16)
  BOTTOM w0.076: v1(103.9,81.45) 103.9,81.53 103.44,81.99 103.44,82.6 103.32,83.13 103.32,83.55 103.4,83.76
  BOTTOM w0.089: CPU1.BC37 103.4,83.76
  BOTTOM w0.216: v1(120.85,48.16) 120.94,48.16 121.49,47.62 121.49,47.2 121.78,46.92 DM2.62
M_B_DQ40: length 58.9
  L4 w0.089: 113.3,73.58 112.78,74.1 111.13,74.1 107.03,78.21 107.03,78.9 v1(105.62,80.31)
  L4 w0.203: v1(124.45,48.95) 125.32,48.95 126.01,49.65 126.01,50.12 125.67,50.46 125.67,51.44 126.01,51.78 126.01,52.25 125.67,52.59 125.67,53.33 125.54,53.46 125.15,53.46 125.02,53.59 125.02,54.1 125.16,54.24 125.85,54.24 126.06,54.45 126.06,54.85 125.85,55.06 125.23,55.06 125.02,55.26 125.02,55.67 125.23,55.87 125.85,55.87 126.06,56.07 126.06,56.48 125.85,56.68 125.23,56.68 125.02,56.89 125.02,57.29 125.23,57.5 125.85,57.5 126.06,57.7 126.06,58.11 125.85,58.31 125.23,58.31 125.02,58.51 125.02,58.92 125.23,59.12 125.85,59.12 126.06,59.32 126.06,59.73 125.85,59.93 125.23,59.93 125.02,60.14 125.02,60.54 125.23,60.75 125.85,60.75 126.06,60.95 126.06,61.36 125.85,61.56 125.23,61.56 125.02,61.76 125.02,62.8 114.96,72.86 114.96,72.97 114.35,73.58 113.3,73.58
  BOTTOM w0.076: CPU1.BE35 104.73,85.19 104.83,84.93 104.83,84.93 104.89,84.75 104.89,84.52 104.86,84.43 104.86,84.19 104.89,84.08 104.94,83.66 104.94,82.26 104.94,81.82 104.94,81.68 104.92,81.66
  BOTTOM w0.089: 104.92,81.66 104.92,81.01 v1(105.62,80.31)
  BOTTOM w0.216: v1(124.45,48.95) 124.4,49 124.23,49 123.97,49.25 123.97,49.86 124.03,49.91 DM2.71
M_B_DQ41: length 59.4
  L4 w0.089: 111.14,73.08 111.01,73.2 111.01,73.2 106.48,77.73 106.48,77.88 105.98,78.39 v1(105.71,78.39)
  L4 w0.203: v1(122.82,48.55) 122.71,48.67 122.71,60.66 121.66,61.7 121.66,61.99 122.51,62.83 122.51,63.12 122.22,63.41 121.93,63.41 121.09,62.57 120.8,62.57 120.51,62.85 120.51,63.14 121.36,63.98 121.36,64.27 121.07,64.56 120.78,64.56 119.94,63.71 119.65,63.71 119.37,64 119.37,64.29 120.21,65.13 120.21,65.42 119.92,65.71 119.63,65.71 118.79,64.86 118.5,64.86 118.18,65.19 118.18,65.42 119.06,66.3 119.06,66.57 118.73,66.9 118.41,66.9 118,66.49 117.75,66.49 117.43,66.81 117.43,67.1 117.64,67.31 117.64,67.57 117.35,67.85 117.04,67.85 116.85,67.67 116.57,67.67 111.16,73.08 111.14,73.08
  BOTTOM w0.076: CPU1.BE34 104.34,85.33 104.34,84.39 104.29,84.3 104.22,84.16 104.22,83.79 104.22,83.78 104.37,83.6 104.38,83.59 104.45,83.5 104.45,82.7 104.3,81.92
  BOTTOM w0.089: v1(105.71,78.39) 105.71,78.4 105.62,78.48 105.02,78.48 104.57,78.92 104.57,80.37 104.3,80.64 104.3,81.92
  BOTTOM w0.216: DM2.67 123.03,50.18 122.98,50.13 122.98,48.7 v1(122.82,48.55)
M_B_DQ42: length 59.6
  L4 w0.089: v1(106.6,82.83) 107.09,82.83 110.04,79.88 110.04,77.62 111.43,76.23 116.28,76.23 116.41,76.1
  L4 w0.203: 116.41,76.1 130.46,62.05 130.46,51.21 130.58,51.08 130.64,51.08 131.6,50.12 131.6,47.27 131.3,46.97 v1(130.01,46.97)
  BOTTOM w0.076: CPU1.BG35 106.26,84.97 106.26,84.34 106.36,84.15 106.36,83.75 106.19,83.59 106.19,83.39
  BOTTOM w0.089: 106.19,83.39 106.19,83.24 v1(106.6,82.83)
  BOTTOM w0.216: DM2.83 127.03,49.72 127.61,49.13 128.18,48.85 129.15,48.85 129.69,48.31 v1(130.01,46.97)
M_B_DQ43: length 60
  L4 w0.089: 111.37,75.72 111.31,75.72 109.35,77.68 109.35,79.68 107.69,81.34 107.41,81.34 107.14,81.28 v1(105.63,80.96)
  L4 w0.203: 111.37,75.72 114.25,75.72 114.73,75.24 115.98,75.24 128.46,62.76 128.46,59.25 129.31,58.4 129.31,48.91 129.18,48.78 128.75,48.78 128.44,48.48 128.44,47.18 128.33,47.04 128.09,46.98 v1(127.82,47.1)
  BOTTOM w0.076: CPU1.BG34 105.2,85.94 105.17,85.9 105.17,85.9 104.99,85.72 104.99,84.96 105.06,84.75 105.06,84.52 105.02,84.4 105.02,84.22 105.11,83.98 105.11,81.83 105.12,81.81 105.13,81.51 105.22,81.37
  BOTTOM w0.089: 105.22,81.37 v1(105.63,80.96)
  BOTTOM w0.216: v1(127.82,47.1) 127.55,47.1 127.32,46.88 127.32,46.02 127.22,45.92 127.22,45.91 126.28,44.96 DM2.80
M_B_DQ44: length 57.9
  L4 w0.089: 112.21,73.76 111.22,73.76 106.85,78.13 106.85,78.42 v1(105.62,79.66)
  L4 w0.203: 112.21,73.76 112.78,73.76 113.01,73.54 113.01,73.46 113.18,73.28 113.68,73.28 124.56,62.4 124.56,61.78 124.35,61.57 124.06,61.57 123.85,61.37 123.85,60.96 124.06,60.76 124.35,60.76 124.56,60.56 124.56,60.15 124.35,59.95 124.06,59.95 123.85,59.74 123.85,59.34 124.06,59.13 124.35,59.13 124.56,58.93 124.56,58.52 124.35,58.32 124.06,58.32 123.85,58.12 123.85,57.71 124.06,57.51 124.35,57.51 124.56,57.31 124.56,56.9 124.35,56.7 124.06,56.7 123.85,56.49 123.85,56.09 124.06,55.88 124.35,55.88 124.56,55.68 124.56,55.27 124.35,55.07 124.06,55.07 123.85,54.87 123.85,54.46 124.06,54.26 124.35,54.26 124.56,54.05 124.56,53.21 124.76,53 125.01,53 125.22,52.8 125.22,52.39 125.01,52.19 124.76,52.19 124.56,51.99 124.56,51.58 124.76,51.38 125.01,51.38 125.22,51.17 125.22,50.77 125.01,50.57 124.76,50.57 123.95,49.76 123.95,48.12 124.39,47.68 v1(124.41,47.68)
  BOTTOM w0.076: CPU1.BE37 104.78,83.59 104.78,82.27 104.78,81.82 104.78,81.77 104.74,81.73 104.74,81.68 104.72,81.66
  BOTTOM w0.089: 104.72,81.66 104.72,80.85 104.96,80.61 104.96,80.32 v1(105.62,79.66)
  BOTTOM w0.216: DM2.70 123.78,45.64 124.03,45.89 124.03,45.92 124.8,46.69 124.8,47.29 v1(124.41,47.68)
M_B_DQ45: length 58.7
  L4 w0.089: 112.32,73.28 112.14,73.46 111.25,73.46 v1(105.68,79.02)
  L4 w0.203: v1(123.7,47.21) 123.4,47.52 123.4,50.83 123.6,51.03 123.9,51.03 124.1,51.24 124.1,51.64 123.9,51.85 123.6,51.85 123.4,52.05 123.4,52.46 123.6,52.66 123.9,52.66 124.1,52.86 124.1,53.27 123.9,53.47 123.6,53.47 123.4,53.68 123.4,62.88 117.3,68.98 117.01,68.98 116.6,68.57 116.32,68.57 116.03,68.86 116.03,69.14 116.44,69.55 116.44,69.84 116.15,70.13 115.86,70.13 115.45,69.72 115.17,69.72 114.88,70.01 114.88,70.29 115.29,70.7 115.29,70.99 115,71.28 114.71,71.28 114.3,70.87 114.02,70.87 113.73,71.16 113.73,71.44 114.08,71.79 114.08,71.97 113.85,72.21 113.56,72.21 113.28,71.93 112.98,71.93 112.7,72.2 112.7,72.5 112.96,72.75 112.96,72.93 112.61,73.28 112.32,73.28
  BOTTOM w0.076: CPU1.BE36 104.64,84.58 104.41,84.17 104.38,84.12 104.38,83.85 104.6,83.58 104.61,83.57 104.61,83.56 104.61,82.27 104.61,81.83 104.58,81.8 104.58,81.77 104.54,81.73 104.54,80.77 104.54,80.77 104.54,80.7
  BOTTOM w0.089: v1(105.68,79.02) 105.66,79.02 105.6,79.09 105.05,79.09 104.75,79.38 104.75,80.49 104.54,80.7
  BOTTOM w0.216: DM2.66 122.79,42.91 122.79,46.13 123.7,47.05 v1(123.7,47.21)
M_B_DQ46: length 58.8
  L4 w0.089: 114.58,75.97 111.31,75.97 109.71,77.57 109.71,79.96 107.47,82.2 v1(106.69,82.2)
  L4 w0.203: 114.58,75.97 114.87,75.69 116.18,75.69 129.92,61.95 129.92,61.49 129.71,61.29 129.12,61.29 128.91,61.08 128.91,60.68 129.12,60.47 129.71,60.47 129.92,60.27 129.92,50.22 130.41,49.73 130.41,47.85 130.22,47.67 v1(128.92,47.67)
  BOTTOM w0.076: CPU1.BG36 105.94,84.58 106.09,84.3 106.09,84.3 106.19,84.11 106.19,83.82 106.02,83.65 106.02,82.86 106.44,82.43 106.52,82.43 106.68,82.27 106.68,82.21 v1(106.69,82.2)
  BOTTOM w0.216: DM2.79 126.03,49.14 127.5,47.67 v1(128.92,47.67)
M_B_DQ47: length 57.9
  L4 w0.203: v1(128.32,45.89) 128.21,46 127.49,46 127.34,46.15 127.34,47.48 127.84,47.98 127.84,49.33 128.76,50.24 128.76,54.95 128.55,55.16 128.25,55.16 128.04,55.36 128.04,55.77 128.25,55.97 128.55,55.97 128.76,56.17 128.76,56.58 128.55,56.78 128.25,56.78 128.04,56.98 128.04,57.39 128.25,57.59 128.55,57.59 128.76,57.8 128.76,58.2 128.55,58.41 128.25,58.41 128,58.65 128,62.57 116.33,74.24 115.38,74.24 115.08,74.54 114.71,74.54 114.13,75.12 111.35,75.12 109.04,77.43 109.04,79.47 107.57,80.94 v1(107.52,80.94)
  BOTTOM w0.076: CPU1.BG37 105.84,83.89 105.84,82.47 106.45,81.86 106.55,81.63 106.61,81.5 106.64,81.48
  BOTTOM w0.216: 106.64,81.48 106.64,80.9 106.86,80.68 107.27,80.68 v1(107.52,80.94) ; v1(128.32,45.89) 128.54,45.66 128.54,45.48 127.28,44.22 DM2.84
M_B_DQ48: length 93.4
  L2SGND w0.089: 106.95,81.28 106.95,81.29 106.36,81.97 105.29,83.91 105.29,83.94 105.24,83.98 105.22,84.02 105.19,84.09 104.82,84.45 104.75,84.5 104.74,84.5 104.71,84.52 104.55,84.57 104.46,84.61 103.59,85 102.54,86.04 v1(102.54,86.72)
  L2SGND w0.114: v1(166.09,45.56) 166.18,45.56 166.5,45.24 166.5,44.98 166.63,44.85 167.09,44.85 167.22,44.98 167.22,49.93 152.8,64.35 152.54,64.35 145.18,71.71 111.95,71.71 107.06,76.61 107.06,81.17 106.95,81.28
  BOTTOM w0.089: CPU1.BA32 102.32,86.74 102.52,86.74 v1(102.54,86.72)
  BOTTOM w0.216: DM2.232 166.28,44.2 166.42,44.35 166.42,44.36 166.58,44.51 166.58,45.08 v1(166.09,45.56)
M_B_DQ49: length 94.3
  L2SGND w0.089: v1(102.53,87.4) 102.94,86.99 102.94,85.89 103.65,85.18 103.71,85.16 103.71,85.15 104.82,84.66 105.97,83.92 106.78,83.92 107.11,83.59 107.11,82.37 108.05,81.43
  L2SGND w0.114: v1(168.09,48.48) 168.59,48.48 168.71,48.6 168.71,49.05 168.59,49.18 167.8,49.18 167.56,49.41 167.56,50.11 167.32,50.35 167.32,50.51 167.36,50.55 167.36,50.71 167.2,50.87 167.04,50.87 167,50.83 166.84,50.83 166.67,51 166.67,51.16 166.71,51.2 166.71,51.36 166.55,51.52 166.39,51.52 166.35,51.48 166.19,51.48 166.03,51.64 166.03,51.8 166.07,51.84 166.07,52 165.9,52.17 165.74,52.17 165.7,52.13 165.54,52.13 165.38,52.29 165.38,52.45 165.42,52.49 165.42,52.65 165.26,52.81 165.1,52.81 165.06,52.77 164.9,52.77 164.73,52.94 164.73,53.1 164.77,53.14 164.77,53.3 164.61,53.46 164.45,53.46 164.41,53.42 164.25,53.42 164.09,53.58 164.09,53.74 164.13,53.78 164.13,53.94 163.96,54.11 163.8,54.11 163.76,54.07 163.6,54.07 163.44,54.23 163.44,54.39 163.48,54.43 163.48,54.59 163.32,54.75 163.16,54.75 163.12,54.71 162.96,54.71 162.79,54.88 162.79,55.04 162.83,55.08 162.83,55.24 162.67,55.4 162.51,55.4 162.47,55.36 162.31,55.36 162.15,55.52 162.15,55.68 162.19,55.72 162.19,55.88 162.02,56.05 161.86,56.05 161.82,56.01 161.66,56.01 161.5,56.17 161.5,56.33 161.54,56.37 161.54,56.53 159.95,58.12 159.54,58.12 152.96,64.7 152.69,64.7 145.33,72.05 112.1,72.05 108.05,76.1 108.05,81.43
  BOTTOM w0.089: CPU1.BA31 v1(102.53,87.4)
  BOTTOM w0.216: v1(168.09,48.48) 167.93,48.48 167.54,48.86 167.54,49.41 167.52,49.44 167.52,50.03 167.53,50.04 DM2.237
M_B_DQ50: length 95.6
  L2SGND w0.089: v1(104.33,87.36) 104.8,86.88 104.8,86.58 106.31,85.08 107.16,85.08 108.23,84.01 108.23,82.84 108.46,82.61
  L2SGND w0.114: v1(170.92,47.23) 171.6,47.23 171.73,47.36 171.73,49.61 146.79,74.54 136.33,74.54 136.22,74.43 136.22,74.34 136.11,74.23 135.88,74.23 135.76,74.34 135.76,74.43 135.65,74.54 135.42,74.54 135.31,74.43 135.31,74.34 135.19,74.23 134.96,74.23 134.85,74.34 134.85,74.43 134.73,74.54 134.5,74.54 134.39,74.43 134.39,74.34 134.28,74.23 134.05,74.23 133.93,74.34 133.93,74.43 133.82,74.54 133.48,74.54 133.16,74.23 117.73,74.23 117.31,74.64 113.17,74.64 109.25,78.56 109.25,81.81 108.55,82.51 108.55,82.53 108.46,82.61
  BOTTOM w0.089: CPU1.BD31 104.28,87.44 104.29,87.39 v1(104.33,87.36)
  BOTTOM w0.216: DM2.245 169.53,49.99 169.5,49.96 169.5,48.09 170.35,47.23 v1(170.92,47.23)
M_B_DQ51: length 95.9
  L2SGND w0.089: v1(104.32,86.68) 104.46,86.68 106.23,84.9 107.09,84.9 108.03,83.96 108.03,82.76 108.34,82.44
  L2SGND w0.114: v1(170.87,48.66) 170.93,48.66 171.38,49.1 171.38,49.47 146.97,73.88 146.58,73.88 146.46,74 146.46,74.09 146.35,74.2 146.12,74.2 146.01,74.09 146.01,74 145.89,73.88 145.66,73.88 145.55,74 145.55,74.09 145.44,74.2 145.21,74.2 145.09,74.09 145.09,74 144.98,73.88 144.75,73.88 144.64,74 144.64,74.09 144.52,74.2 144.29,74.2 144.18,74.09 144.18,74 144.06,73.88 143.84,73.88 143.72,74 143.72,74.09 143.61,74.2 143.38,74.2 143.26,74.09 143.26,74 143.15,73.88 142.92,73.88 142.81,74 142.81,74.09 142.69,74.2 142.46,74.2 142.35,74.09 142.35,74 142.23,73.88 142.01,73.88 141.89,74 141.89,74.09 141.78,74.2 141.55,74.2 141.43,74.09 141.43,74 141.32,73.88 141.09,73.88 140.98,74 140.98,74.09 140.86,74.2 140.63,74.2 140.52,74.09 140.52,74 140.41,73.88 140.18,73.88 140.06,74 140.06,74.09 139.95,74.2 139.72,74.2 139.61,74.09 139.61,74 139.49,73.88 139.26,73.88 139.15,74 139.15,74.09 139.03,74.2 138.81,74.2 138.69,74.09 138.69,74 138.58,73.88 138.35,73.88 138.23,74 138.23,74.09 138.12,74.2 137.89,74.2 137.78,74.09 137.78,74 137.66,73.88 137.43,73.88 137.32,74 137.32,74.09 137.21,74.2 136.98,74.2 136.86,74.09 136.86,74 136.75,73.88 116.99,73.88 116.87,74 116.87,74.18 116.76,74.3 116.53,74.3 116.42,74.18 116.42,74 116.3,73.88 116.07,73.88 115.96,74 115.96,74.18 115.85,74.3 115.62,74.3 115.5,74.18 115.5,74 115.39,73.88 115.16,73.88 115.05,74 115.05,74.18 114.93,74.3 114.7,74.3 114.59,74.18 114.59,74 114.47,73.88 114.25,73.88 114.13,74 114.13,74.18 114.02,74.3 113.79,74.3 113.67,74.18 113.67,74 113.56,73.88 113.22,73.88 109.05,78.05 109.05,81.72 108.34,82.43 108.34,82.44
  BOTTOM w0.089: v1(104.32,86.68) 104.32,86.68 104.31,86.67 104.21,86.67 CPU1.BD32
  BOTTOM w0.216: v1(170.87,48.66) 170.86,48.66 170.44,49.08 170.44,49.57 170.53,49.66 DM2.249
M_B_DQ52: length 94.7
  L2SGND w0.089: 106.42,80.93 106.42,81.56 106.15,81.83 105.11,83.85 105.11,83.87 105.1,83.87 105.08,83.92 105.04,83.98 104.71,84.31 104.66,84.34 104.64,84.35 104.64,84.35 104.49,84.41 104.23,84.5 103.51,84.82 102.32,86.01 102.32,86.03 102.06,86.29 102.06,87.87 102.22,88.03 v1(102.53,88.03)
  L2SGND w0.114: 106.42,80.93 106.85,80.5 106.85,76.13 111.62,71.37 145.04,71.37 152.4,64.01 152.65,64.01 166.88,49.79 166.88,46.69 166.75,46.56 166.34,46.56 v1(166.07,46.83)
  BOTTOM w0.089: CPU1.BA30 102.25,88.19 102.53,88.03 v1(102.53,88.03)
  BOTTOM w0.216: DM2.236 167.28,43.92 167.32,43.97 167.32,43.98 167.48,44.14 167.48,45.82 166.58,46.72 166.22,46.72 166.11,46.83 v1(166.07,46.83)
M_B_DQ53: length 96.3
  L2SGND w0.089: 105.36,84.83 103.97,85.26 103.92,85.26 103.88,85.28 103.81,85.3 103.53,85.59 103.53,86.68 102.93,87.28 102.93,88.27 v1(102.53,88.67)
  L2SGND w0.114: 105.36,84.83 106.07,84.13 106.89,84.13 107.34,83.67 107.34,82.43 108.26,81.52 108.26,76.39 112.25,72.4 146.35,72.4 153.83,64.92 153.83,64.31 159.68,58.46 160.09,58.46 169.38,49.18 169.38,48.41 168.17,47.19 v1(168.08,47.19)
  BOTTOM w0.089: v1(102.53,88.67) CPU1.BA29
  BOTTOM w0.216: DM2.233 166.53,49.89 166.6,49.81 166.6,48.37 167.84,47.14 168.02,47.14 v1(168.08,47.19)
M_B_DQ54: length 97.1
  L2SGND w0.089: v1(104.35,88.67) 104.75,88.27 104.75,87.89 105.8,86.84 105.8,86.53 106.19,86.13 106.21,86.13
  L2SGND w0.114: 106.21,86.13 106.91,86.13 109.5,83.54 109.5,82.48 109.78,82.2 109.78,79.02 113.46,75.34 117.84,75.34 120.66,74.91 129.17,74.91 130.15,75.23 147.08,75.23 172.41,49.89 172.41,49.61 172.41,45.58 172.3,45.46 171.9,45.46 171.78,45.35 171.78,45.12 171.9,45 172.3,45 172.41,44.89 172.41,44.55 172.2,44.34 v1(170.8,44.34)
  BOTTOM w0.089: v1(104.35,88.67) CPU1.BD29
  BOTTOM w0.216: DM2.250 170.78,44.31 v1(170.8,44.34)
M_B_DQ55: length 96.7
  L2SGND w0.089: v1(104.35,88.03) 104.73,87.66 104.73,87.36 105.03,87.06 105.03,86.6 106.38,85.26 107.5,85.26
  L2SGND w0.114: 107.5,85.26 108.45,84.3 108.45,82.91 109.46,81.91 109.46,78.84 113.31,74.98 117.55,74.98 117.97,74.57 130.09,74.57 130.22,74.7 130.22,74.77 130.33,74.89 130.56,74.89 130.68,74.77 130.68,74.68 130.79,74.57 131.02,74.57 131.13,74.68 131.13,74.77 131.25,74.89 131.48,74.89 131.59,74.77 131.59,74.68 131.7,74.57 131.93,74.57 132.05,74.68 132.05,74.77 132.16,74.89 132.39,74.89 132.5,74.77 132.5,74.68 132.62,74.57 133.02,74.57 133.33,74.89 146.94,74.89 172.07,49.75 172.07,46.41 171.36,45.7 v1(170.82,45.7)
  BOTTOM w0.089: v1(104.35,88.03) CPU1.BD30
  BOTTOM w0.216: v1(170.82,45.7) 170.69,45.7 169.78,44.79 DM2.246
M_B_DQ56: length 71.4
  L4 w0.089: 115.65,77.42 111.46,77.42 110.94,77.94 110.94,80.38 108.21,83.11 108.21,83.97 107.27,84.91 107.27,85.84 106.6,86.51 106.6,86.92 v1(106.19,87.33)
  L4 w0.203: v1(150.8,48.9) 150.76,48.9 150.32,49.34 150.32,49.61 147.93,52 143.52,52 143.1,52.41 142.82,52.41 142.69,52.29 142.4,52.29 142.11,52.57 142.11,52.86 142.24,52.99 142.24,53.28 141.95,53.56 141.67,53.56 141.54,53.44 141.25,53.44 140.96,53.72 140.96,54.01 141.09,54.14 141.09,54.43 140.8,54.71 140.52,54.71 140.39,54.59 140.1,54.59 139.81,54.87 139.81,55.16 139.94,55.29 139.94,55.58 139.66,55.86 139.37,55.86 139.24,55.73 138.95,55.73 138.66,56.02 138.66,56.31 138.79,56.44 138.79,56.73 138.51,57.01 138.22,57.01 138.09,56.88 137.8,56.88 137.52,57.17 137.52,57.46 137.64,57.59 137.64,57.87 137.36,58.16 137.07,58.16 136.94,58.03 136.65,58.03 136.37,58.32 136.37,58.61 136.49,58.74 136.49,59.02 136.21,59.31 135.92,59.31 135.79,59.18 135.5,59.18 135.22,59.47 135.22,59.76 135.34,59.89 135.34,60.17 118.1,77.42 115.65,77.42
  BOTTOM w0.089: CPU1.BG31 106.17,87.4 v1(106.19,87.33)
  BOTTOM w0.216: DM2.173 151.53,50.3 151.48,50.26 151.48,49.52 150.86,48.9 v1(150.8,48.9)
M_B_DQ57: length 71.4
  L4 w0.089: 116.75,77.05 111.44,77.05 110.72,77.77 110.72,80.29 108.03,82.98 108.03,83.89 107.09,84.83 107.09,85.77 106.2,86.65 v1(106.2,86.69)
  L4 w0.203: 116.75,77.05 117.44,77.05 118.2,76.29 118.58,76.29 132.34,62.53 132.34,61.67 132.74,61.26 132.74,60.98 132.63,60.86 132.63,60.57 132.91,60.28 133.2,60.28 133.32,60.4 133.61,60.4 133.89,60.12 133.89,59.83 133.77,59.71 133.77,59.42 134.06,59.13 134.35,59.13 134.47,59.25 134.76,59.25 135.04,58.97 135.04,58.68 134.92,58.56 134.92,58.27 135.21,57.98 135.5,57.98 135.62,58.1 135.91,58.1 136.19,57.82 136.19,57.53 136.07,57.41 136.07,57.12 136.36,56.83 136.65,56.83 136.77,56.95 137.06,56.95 137.34,56.67 137.34,56.38 137.22,56.26 137.22,55.97 137.51,55.68 137.8,55.68 137.92,55.8 138.21,55.8 138.49,55.52 138.49,55.23 138.42,55.16 138.42,54.87 138.71,54.59 139,54.59 139.07,54.65 139.36,54.65 142.47,51.54 147.64,51.54 149.86,49.32 149.86,49.15 150.74,48.27 v1(150.83,48.27)
  BOTTOM w0.089: CPU1.BG32 106.11,86.79 106.2,86.71 v1(106.2,86.69)
  BOTTOM w0.216: v1(150.83,48.27) 150.75,48.27 150.31,48.7 150.31,49.91 150.53,50.12 DM2.169
M_B_DQ58: length 71.1
  L4 w0.089: v1(108.02,86.72) 108.02,85.05 109.48,83.59 109.48,82.81 111.74,80.54 111.74,79.78 112.73,78.79
  L4 w0.203: v1(153.35,46.97) 153.7,47.32 153.7,49.37 148.95,54.12 144.14,54.12 127.05,71.21 127.05,72.16 120.42,78.79 112.73,78.79
  BOTTOM w0.089: CPU1.BK32 107.88,86.82 107.98,86.72 v1(108.02,86.72)
  BOTTOM w0.216: DM2.183 154.03,49.77 153.7,49.45 153.7,47.33 v1(153.35,46.97)
M_B_DQ59: length 72.1
  L4 w0.089: 112.79,79.08 111.92,79.96 111.92,80.62 109.65,82.88 109.65,83.67 108.23,85.09 108.23,86.18 108.42,86.37 108.42,86.94 v1(107.99,87.36)
  L4 w0.203: 112.79,79.08 120.78,79.08 127.51,72.35 138.48,60.43 144.33,54.58 149.14,54.58 154.16,49.56 154.16,47.17 153.99,46.18 153.74,45.47 153.31,45.03 v1(153.26,45.03)
  BOTTOM w0.089: CPU1.BK31 107.72,87.63 v1(107.99,87.36)
  BOTTOM w0.216: DM2.182 153.78,44.58 153.32,45.03 v1(153.26,45.03)
M_B_DQ60: length 72.5
  L4 w0.089: 114.54,76.46 114.51,76.43 111.53,76.43 110.24,77.73 110.24,80.11 107.58,82.78 107.58,83.81 105.62,85.77 105.62,87.58 105.72,87.68 105.72,88.86 v1(106.14,89.29)
  L4 w0.203: v1(150.73,45.52) 150.1,45.52 147.73,47.89 147.73,49.13 146.6,50.26 141.64,50.26 131.42,60.48 131.42,62.16 118.14,75.43 117.49,75.43 116.46,76.46 114.54,76.46
  BOTTOM w0.089: v1(106.14,89.29) 106.08,89.29 CPU1.BG29
  BOTTOM w0.216: v1(150.73,45.52) 150.75,45.49 150.75,43.58 150.78,43.56 DM2.170
M_B_DQ61: length 72.4
  L4 w0.089: v1(106.16,88.53) 106.16,88.52 106.16,87.87 105.79,87.5 105.79,85.84 107.85,83.79 107.85,82.91 110.52,80.24 110.52,77.73 111.48,76.76 116.69,76.76
  L4 w0.203: v1(150.8,46.92) 150.68,47.04 149.61,47.04 148.25,48.4 148.25,49.3 146.69,50.86 142.49,50.86 140.31,53.04 139.51,53.04 131.88,60.67 131.88,62.34 118.33,75.89 117.56,75.89 116.69,76.76
  BOTTOM w0.089: CPU1.BG30 105.97,88.53 v1(106.16,88.53)
  BOTTOM w0.216: DM2.174 151.78,45.94 v1(150.8,46.92)
M_B_DQ62: length 72.4
  L4 w0.089: 113.05,79.47 112.09,80.42 112.09,80.69 109.83,82.95 109.83,83.74 108.48,85.09 108.48,86.18 108.6,86.29 108.6,87.42 v1(108,88.02)
  L4 w0.203: v1(154.71,49.08) 154.71,49.65 149.33,55.04 145.47,55.04 144.84,55.67 144.55,55.67 144.36,55.48 144.08,55.48 143.79,55.77 143.79,56.06 143.98,56.25 143.98,56.53 143.69,56.82 143.4,56.82 143.21,56.63 142.93,56.63 142.64,56.92 142.64,57.21 142.83,57.4 142.83,57.68 142.54,57.97 142.25,57.97 142.06,57.78 141.78,57.78 141.49,58.07 141.49,58.36 141.68,58.55 141.68,58.83 141.39,59.12 141.1,59.12 140.91,58.93 140.63,58.93 140.34,59.22 140.34,59.51 140.53,59.7 140.53,59.98 140.24,60.27 139.95,60.27 139.77,60.08 139.48,60.08 139.19,60.37 139.19,60.66 139.38,60.84 139.38,61.13 121.04,79.47 113.05,79.47
  BOTTOM w0.089: CPU1.BK30 107.73,88.28 v1(108,88.02)
  BOTTOM w0.216: DM2.187 155.03,49.39 v1(154.71,49.08)
M_B_DQ63: length 73.7
  L4 w0.089: v1(108,88.67) 108,88.6 108.51,88.09 108.51,87.75 108.8,87.46 108.8,86.14 108.66,86 108.66,85.16 110.01,83.81 110.01,83.03 113.13,79.91
  L4 w0.203: v1(155.28,45.2) 155.33,45.2 155.77,45.64 155.77,46.7 155.3,47.17 155.3,49.71 149.52,55.49 145.68,55.49 121.34,79.83 113.2,79.83 113.13,79.91
  BOTTOM w0.089: v1(108,88.67) CPU1.BK29
  BOTTOM w0.216: v1(155.28,45.2) 155.13,45.2 154.78,44.85 DM2.186
M_B_DQS_DN0: length 51.2
  L4 w0.089: 98.5,71.56 98.5,71.58 98.57,71.61 98.88,72.36 98.88,79.44 97.94,80.38 97.58,80.38 v1(97.31,80.11)
  L4 w0.165: v1(108.54,48.97) 109.07,49.5 109.07,49.81 107.71,51.17 102.74,51.17 102.16,51.75 101.93,51.75 101.6,51.43 101.16,51.43 100.66,51.93 100.66,52.37 100.98,52.7 100.98,52.93 100.63,53.28 100.4,53.28 100.08,52.96 99.63,52.96 99.13,53.46 99.13,53.9 99.45,54.22 99.45,54.46 98.2,55.71 98.2,70.91 98.5,71.21 98.5,71.56
  BOTTOM w0.076: CPU1.AP35 97.73,85.11 97.67,85.19 97.62,85.2 97.57,85.17 97.5,85.11 97.48,85.06 97.48,84.86 97.52,84.76 97.52,84.51 97.48,84.41 97.48,84.21 97.52,84.12 97.52,83.82 97.68,83.62 97.69,83.59 97.85,83.17 97.85,82.44 97.77,81.6 97.77,81.59 97.77,80.57 v1(97.31,80.11)
  BOTTOM w0.216: v1(108.54,48.97) 108.71,48.97 109.03,49.28 DM2.11
M_B_DQS_DN1: length 49.1
  L4 w0.089: v1(101.57,79.66) 102.13,79.09 102.13,78.12 102.13,78.11 102.13,74.01 102.67,73.47 102.77,73.47 102.84,73.4
  L4 w0.165: v1(113.98,47.42) 113.98,47.43 114.36,47.8 114.36,47.8 114.64,48.08 114.64,48.76 114.15,49.25 114.15,52.34 111.89,54.6 111.89,55.77 104.33,63.33 104.33,71.91 102.84,73.4
  BOTTOM w0.076: CPU1.AV34 100.38,85.59 100.57,85.4 100.6,85.32 100.63,85.24 100.65,85.2 100.67,85.14 100.68,85.09 100.68,84.86 100.65,84.72 100.65,84.55 100.68,84.44 100.68,84.19 100.66,84.09 100.65,84.05 100.65,83.93 100.68,83.44 100.68,83.44 100.68,81.74 101.13,80.13 101.3,79.95 101.31,79.94 v1(101.57,79.66)
  BOTTOM w0.216: v1(113.98,47.42) 114.15,47.42 114.28,47.3 DM2.32
