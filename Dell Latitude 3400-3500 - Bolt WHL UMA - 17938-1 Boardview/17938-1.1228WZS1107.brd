# Allegro board 17938-1.1228WZS1107.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB1_SBU2: length 36.3
  TOP w0.127: 15.52,112.69 15.52,113.07 16.25,113.8 16.25,117.96 17.64,119.35 17.64,120.89 16.5,122.03 ED7307.1 16.23,122.09 v1(15.79,121.65) ; 15.52,112.69 15.52,110.93 15.73,110.72 16.44,110.72 R7330.2 16.56,110.57 16.84,110.29 20.52,110.29 21.24,109.58 21.24,109.25 21.4,109.09 U7101.26 ; 15.52,112.69 AFTP7102.1
  L4 w0.102: JUSB1.B8 6.33,122.09 6.44,121.99 6.54,121.95 6.59,121.93 7.02,121.87
  L4 w0.114: v1(15.79,121.65) 15.55,121.41 14.58,121.41 14.1,120.93 12.53,120.93 11.84,121.62 11.84,122.56 9.45,124.95 8.4,124.95 7.7,124.24 7.7,122.51 7.02,121.87
USB1_SSRX_C_N1: length 2
  TOP w0.127: U7101.31 19.53,107.19 19.42,107.31 18.95,107.31 18.48,107.77 C7169.1
USB1_SSRX_C_N2: length 2.6
  TOP w0.127: C7167.1 17.95,103.44 18.74,103.44 19.13,103.83 19.39,103.83 19.54,103.99 U7101.39
USB1_SSRX_C_P1: length 2.1
  TOP w0.127: C7168.1 18.37,108.33 18.77,107.93 18.77,107.82 19.05,107.55 19.5,107.55 19.54,107.59 U7101.30
USB1_SSRX_C_P2: length 2.6
  TOP w0.127: C7170.1 17.99,103.2 18.84,103.2 19.23,103.59 U7101.40
USB1_SSRX_CMC_N1: length 12.7
  TOP w0.127: C7169.2 17.33,107.77 R7187.1 16.75,108.34 15.6,108.34 14.41,109.54 14.41,114.38 ; v1(15.51,115.47) 14.86,115.47 14.41,115.01 14.41,114.38 ; 14.41,114.38 v2(14.25,114.38)
  BOTTOM w0.127: v1(15.51,115.47) 15.29,115.55 14.62,115.55 14.36,115.81 R7120.1
USB1_SSRX_CMC_N2: length 31.3
  TOP w0.127: 12.2,114.3 12.2,115.2 13.71,116.72 13.71,117.98 14.48,118.75 14.48,123.55 14.76,123.83 14.76,124.55 14.94,124.73 15.1,124.73 15.27,124.56 v1(15.5,124.33) ; 12.2,114.3 v2(12.35,114.3) ; 12.2,114.3 12.2,108.38 14.36,106.21 14.36,104.77 15.76,103.38 16.26,103.38 R7185.1 C7167.2
  BOTTOM w0.127: R7123.1 13.79,127.66 14.05,127.91 14.3,127.91 14.49,127.73 14.49,126.49 14.82,126.16 14.82,125.35 14.99,125.18 14.99,124.6 15.26,124.33 v1(15.5,124.33)
USB1_SSRX_CMC_P1: length 12.6
  TOP w0.127: C7168.2 17.66,108.33 R7186.1 16.94,108.59 15.7,108.59 14.65,109.64 14.65,111.56 ; 14.65,111.56 14.65,114.91 14.96,115.23 15.12,115.23 15.22,115.13 15.22,114.96 15.35,114.83 v1(15.51,114.83) ; 14.65,111.56 v2(14.81,111.56)
  BOTTOM w0.127: v1(15.51,114.83) 15.34,114.78 15.12,114.78 14.99,114.91 14.99,115.17 14.85,115.31 14.57,115.31 14.32,115.05 R7119.1
USB1_SSRX_CMC_P2: length 31.4
  TOP w0.127: v1(15.54,124.97) 14.84,124.97 14.52,124.65 14.52,123.93 14.24,123.65 14.24,119.46 ; 14.24,119.46 14.24,118.85 13.47,118.08 13.47,116.82 11.95,115.3 11.95,108.28 14.12,106.11 14.12,104.67 15.66,103.14 16.32,103.14 R7188.1 C7170.2 ; 14.24,119.46 v2(14.1,119.46)
  BOTTOM w0.127: v1(15.54,124.97) 15.06,125.45 15.06,126.26 14.74,126.59 14.74,127.83 14.4,128.16 14.09,128.16 13.82,128.42 R7122.1
USB1_SSRX_CON_N1: length 13.1
  TOP w0.127: JUSB1.B10 6.08,121.72 7.8,121.72 9.68,119.84 9.68,118.38 9.06,117.76 9.06,116.16 9.19,116.03 9.44,116.03 v1(9.59,116.18)
  BOTTOM w0.127: R7120.2 13.07,115.81 12.95,115.69 ED7301.4 ED7301.7 10.08,115.69 v1(9.59,116.18)
USB1_SSRX_CON_N2: length 7.4
  BOTTOM w0.127: R7123.2 12.7,127.66 12.4,127.96 12.38,127.96 12.38,127.96 12.12,127.96 11.96,127.81 ED7302.2 ED7302.9 10.63,127.81 10.37,128.06 9.8,128.06 9.23,127.49 9.23,126.04 8.81,125.62 8.41,125.62 8.24,125.45 JUSB1.A10
USB1_SSRX_CON_P1: length 13.3
  TOP w0.127: JUSB1.B11 6.08,121.48 7.7,121.48 9.44,119.74 9.44,118.48 8.82,117.86 8.82,116.06 9.09,115.79 9.35,115.79 v1(9.59,115.55)
  BOTTOM w0.127: 10.19,115.45 10.73,115.45 10.99,115.19 ED7301.6 ED7301.5 12.95,115.19 13.1,115.05 R7119.2 ; 10.19,115.45 9.98,115.45 9.88,115.55 v1(9.59,115.55) ; 10.19,115.45 v2(10.19,115.32)
USB1_SSRX_CON_P2: length 7.2
  BOTTOM w0.127: JUSB1.A11 8.24,125.95 8.33,125.86 8.71,125.86 8.99,126.14 8.99,127.59 9.7,128.31 ED7302.10 ED7302.1 11.98,128.31 12.08,128.2 12.46,128.2 12.68,128.42 R7122.2
USB1_SSTX_C_N1: length 2.2
  TOP w0.127: U7101.34 19.62,105.99 19.57,106.04 18.95,106.04 18.5,106.49 18.35,106.49 C7163.2
USB1_SSTX_C_N2: length 2.1
  TOP w0.127: C7162.2 18.42,105.21 18.88,105.21 18.97,105.11 19.47,105.11 19.54,105.19 U7101.36
USB1_SSTX_C_P1: length 2.3
  TOP w0.127: U7101.33 19.54,106.39 19.43,106.28 19.05,106.28 18.6,106.73 18.47,106.73 C7164.2
USB1_SSTX_C_P2: length 2.1
  TOP w0.127: C7161.2 18.41,104.97 18.78,104.97 18.87,104.87 19.47,104.87 19.54,104.79 U7101.37
USB1_SSTX_CMC_N1: length 16.3
  TOP w0.127: 13.58,111.91 13.58,108.54 15.85,106.27 C7163.1 ; 13.58,111.91 v2(13.41,111.91) ; 13.58,111.91 13.58,115.1 14.77,116.29 14.77,116.79 15.21,117.23 v1(15.52,117.48)
  BOTTOM w0.127: R7117.1 14.01,117.37 14.28,117.1 15.01,117.1 15.08,117.12 v1(15.52,117.48)
USB1_SSTX_CMC_N2: length 26.3
  TOP w0.127: C7162.1 16.97,105.23 16.3,105.23 12.97,108.55 12.97,115.07 14.36,116.45 14.36,117.69 15.21,118.54 15.21,119.48 ; v1(16.08,122.89) 15.98,123.17 15.85,123.3 15.34,123.3 15.21,123.17 15.21,119.48 ; 15.21,119.48 v2(15.37,119.48)
  BOTTOM w0.127: R7125.1 13.52,124.83 13.8,124.54 13.8,124.29 14.81,123.28 15.89,123.28 16.03,123.14 v1(16.08,122.89)
USB1_SSTX_CMC_P1: length 16.3
  TOP w0.127: 14.26,108.21 13.83,108.64 13.83,115 15.01,116.19 15.01,116.69 15.21,116.89 15.39,116.89 v1(15.51,116.76) ; 14.26,108.21 v2(14.38,108.33) ; 14.26,108.21 15.95,106.52 16.49,106.52 16.61,106.64 16.61,107.2 16.7,107.28 17.01,107.28 C7164.1
  BOTTOM w0.127: v1(15.51,116.76) 15.25,116.5 15.07,116.5 14.99,116.59 14.99,116.74 14.87,116.86 14.28,116.86 14.04,116.61 R7115.1
USB1_SSTX_CMC_P2: length 26.3
  TOP w0.127: 15.47,123.54 v2(15.47,123.7) ; 15.47,123.54 15.24,123.54 14.97,123.27 14.97,118.64 14.12,117.79 14.12,116.56 12.73,115.17 12.73,108.45 16.2,104.99 16.93,104.99 C7161.1 ; 15.47,123.54 15.92,123.54 v1(16.08,123.7)
  BOTTOM w0.127: v1(16.08,123.7) 15.9,123.52 14.91,123.52 14.04,124.39 14.04,124.6 14.28,124.83 R7124.1
USB1_SSTX_CON_N1: length 9
  BOTTOM w0.127: R7117.2 12.93,117.19 ED7301.1 ED7301.10 10.52,117.19 9.9,117.82 9.9,119.43 9.2,120.13 9.2,121.27 8.78,121.69 8.5,121.69 8.24,121.95 JUSB1.A3
USB1_SSTX_CON_N2: length 9.7
  TOP w0.127: JUSB1.B3 6.08,125.68 7.28,125.68 7.75,126.15 8.51,126.15 8.71,126.35 9.52,126.35 v1(9.7,126.18)
  BOTTOM w0.127: 12.7,126.56 13.52,126.56 13.75,126.34 13.75,126.16 13.52,125.93 R7125.2 ; 12.7,126.56 12.19,126.56 11.93,126.31 ED7302.5 ED7302.6 10.64,126.31 10.38,126.56 10.09,126.56 v1(9.7,126.18) ; 12.7,126.56 v2(12.7,126.42)
USB1_SSTX_CON_P1: length 8.9
  BOTTOM w0.127: JUSB1.A2 8.68,121.45 8.96,121.17 8.96,120.03 9.66,119.33 9.66,117.72 10.42,116.95 10.67,116.95 10.93,116.69 ED7301.9 ED7301.2 13.03,116.69 R7115.2
USB1_SSTX_CON_P2: length 9.7
  TOP w0.127: JUSB1.B2 6.08,125.92 7.18,125.92 7.65,126.39 8.41,126.39 8.61,126.59 9.48,126.59 v1(9.7,126.81)
  BOTTOM w0.127: R7124.2 14.28,125.92 14.11,126.09 14.11,126.32 13.62,126.81 ED7302.4 ED7302.7 9.7,126.81 v1(9.7,126.81)
USB1_USB20_N: length 121.1
  TOP w0.127: R7134.1 33.08,115.74 33.08,115.93 v1(33.08,115.92) 32.64,116.36 U7102.2
  L3 w0.114: v1(62.89,117.7) 63.24,117.7 63.33,117.79 63.33,118.04 63.45,118.16 63.78,118.16 68.66,123.04 104.05,123.04 104.74,122.35 113.38,122.35 113.71,122.01 121.27,114.46 121.27,111.82 120.25,110.8 119.61,110.8 119.03,111.38 119.03,111.59 118.9,111.72 118.54,111.72 v1(118.52,111.7)
  BOTTOM w0.076: 116.4,108.58 116.33,108.51 116.33,108.46 116.02,108.15 116.02,105.74 CPU1.CD3
  BOTTOM w0.127: v1(62.89,117.7) 62.89,117.83 62.73,118 58.13,118 58.05,118.07 ; 58.05,118.07 57.81,118.31 57.03,118.31 56.57,117.86 56.57,115.3 56.09,114.82 56.09,113.8 56.09,113.45 55.23,112.59 52.12,112.59 51.53,113.18 47.55,113.18 46.14,111.77 46.14,110.88 45.58,110.32 42.77,110.32 41.28,111.81 39.97,111.81 38.18,113.6 37.29,113.6 35.45,115.45 34.59,115.45 33.48,116.55 32.83,116.55 32.69,116.4 32.69,116.21 32.98,115.92 v1(33.08,115.92) ; 58.05,118.07 v2(57.94,117.96) ; 116.4,108.58 117.77,109.95 117.77,111.44 118.04,111.7 v1(118.52,111.7)
USB1_USB20_N_R: length 10.8
  TOP w0.127: v1(32.22,112.38) 32.12,112.48 32.12,113.11 ; R7131.1 30.63,119.15 v1(30.95,119.47) ; 32.12,113.11 v2(32.26,113.11) ; 32.12,113.11 32.12,113.92 R7134.2
  L4 w0.114: v1(32.22,112.38) 31.99,112.61 31.99,118.13 31.73,118.39 31.07,118.39 30.95,118.52 v1(30.95,119.47)
USB1_USB20_P: length 121.4
  TOP w0.127: R7133.1 32.22,115.67 32.3,115.67 v1(32.45,115.82) 32.24,116.03 U7102.1
  L3 w0.114: v1(118.52,111.07) 119.02,111.07 119.52,110.57 120.34,110.57 121.49,111.72 121.49,114.55 113.94,122.11 113.47,122.58 104.84,122.58 104.15,123.27 68.56,123.27 63.69,118.39 v1(62.94,118.39)
  BOTTOM w0.076: 116.57,108.41 116.56,108.4 116.52,108.4 116.19,108.08 116.19,106.01 116.39,105.82 116.39,105.51 CPU1.CD4
  BOTTOM w0.127: v1(118.52,111.07) 118.14,111.07 118.01,110.94 118.01,109.85 116.57,108.41 ; v1(62.94,118.39) 62.79,118.24 61.39,118.24 ; 61.39,118.24 v2(61.39,118.39) ; 61.39,118.24 58.23,118.24 57.91,118.56 56.93,118.56 56.33,117.96 56.33,115.4 55.85,114.92 55.85,113.55 55.13,112.83 52.22,112.83 51.63,113.42 47.45,113.42 45.9,111.87 45.9,110.99 45.48,110.56 42.87,110.56 41.38,112.05 40.07,112.05 38.28,113.84 37.39,113.84 35.58,115.66 35.54,115.69 34.69,115.69 33.58,116.79 32.73,116.79 32.45,116.5 v1(32.45,115.82)
USB1_USB20_P_R: length 11.6
  TOP w0.127: R7133.2 31.88,113.88 31.88,112.68 v1(31.59,112.38) ; R7132.1 30.7,116.69 v1(31.01,117) 31.24,116.77 31.24,116.47 v2(31.41,116.3)
  L4 w0.114: v1(31.01,117) 30.81,117.2 30.81,118.03 30.94,118.16 31.63,118.16 31.76,118.04 31.76,112.69 31.59,112.52 v1(31.59,112.38)
USB2_ID: length 26.6
  L4 w0.102: v1(134.02,106.53) 130.09,110.45 127.35,110.45 124.51,107.62 123.55,107.62 123.12,107.19 123.12,107.08 121.62,105.57 121.62,103.41 120.24,102.04 119.73,102.04 118.94,101.25 118.12,101.25 117.28,102.09 v1(117.28,102.29)
  BOTTOM w0.089: v1(117.28,102.29) 117.28,102.28 117.26,102.27 117.22,102.15 CPU1.CE8
  BOTTOM w0.102: v1(134.02,106.53) 134.63,107.14 134.63,107.67 134.76,107.79 RN1602.2
USB2_USB20_N: length 146.1
  TOP w0.127: AFTP6607.1 206.51,40.99 v1(206.5,41)
  L4 w0.114: v1(206.5,41) 206.31,41 206.05,41.26 206.05,41.51 205.84,41.71 205.84,43.61 206.74,44.5 206.74,44.9 207.17,45.32 207.17,47.63 208.08,48.54 208.08,48.99 207.77,49.31 207.77,51.62 206.73,52.66 204.78,52.66 203.64,53.8 202.24,53.8 200.78,55.26 195.29,55.26 194.57,55.98 191.4,55.98 189.54,54.12 174.83,54.12 167.89,61.06 167.89,61.95 163.45,66.39 163.45,67.04 158.83,71.67 158.83,73.59 153.1,79.32 153.1,84.05 152.71,84.45 152.71,85.12 149.58,88.24 149,88.24 139.79,97.45 139.79,102.29 135.19,106.89 135.19,111.88 134.78,112.3 122.46,112.3 119.69,109.53 119.38,109.53 119.26,109.4 119.26,109.01 119.05,108.81 118.65,108.81 118.52,108.93 v1(118.52,109.12)
  BOTTOM w0.076: CPU1.CE1 116.59,106.88 116.59,107.73 116.78,107.92 116.82,107.92 116.84,107.93
  BOTTOM w0.127: 116.84,107.93 118.21,109.31 118.33,109.31 v1(118.52,109.12) ; EL6602.4 206.5,41 v1(206.5,41)
USB2_USB20_N_CMC: length 8.8
  BOTTOM w0.127: 199.65,39.86 199.65,39.19 199.8,39.04 IOBD1.8 ; 199.65,39.86 199.65,40.21 200.22,40.78 200.22,41.67 200.73,42.18 200.91,42.18 ED6601.3 201.39,42.21 202.39,42.21 203.1,41.5 204.06,41.5 204.56,41 EL6602.3 ; 199.65,39.86 v2(199.8,39.86)
USB2_USB20_P: length 146.4
  TOP w0.127: AFTP6608.1 v1(206.53,41.63)
  L4 w0.114: v1(118.52,109.76) 119.6,109.76 122.37,112.52 134.87,112.52 135.42,111.97 135.42,106.98 140.02,102.38 140.02,97.54 149.1,88.47 149.68,88.47 152.93,85.21 152.93,84.55 153.33,84.15 153.33,79.41 159.06,73.69 159.06,71.76 163.68,67.14 163.68,66.48 168.12,62.05 168.12,61.16 174.92,54.35 189.44,54.35 191.3,56.21 194.66,56.21 195.38,55.49 200.88,55.49 202.34,54.02 203.74,54.02 204.88,52.88 206.83,52.88 207.99,51.72 207.99,49.4 208.31,49.09 208.31,48.45 207.39,47.53 207.39,45.23 206.97,44.8 206.97,44.41 206.07,43.51 206.07,41.81 206.25,41.63 v1(206.53,41.63)
  BOTTOM w0.076: CPU1.CE2 116.41,106.4 116.41,107.81 116.65,108.04 116.65,108.09 116.67,108.1
  BOTTOM w0.127: v1(206.53,41.63) 206.49,41.68 EL6602.1 ; v1(118.52,109.76) 118.42,109.76 118.21,109.55 118.11,109.55 116.67,108.1
USB2_USB20_P_CMC: length 8.9
  BOTTOM w0.127: 200.19,41.99 199.97,41.77 199.97,40.88 199.41,40.31 199.41,39.26 199.41,39.26 199.41,39.23 199.3,39.12 IOBD1.9 ; 200.19,41.99 v2(200.06,42.13) ; 200.19,41.99 200.65,42.45 202.49,42.45 202.91,42.03 203.5,42.03 ED6601.4 204.16,41.95 204.43,41.68 EL6602.2
USB2_VBUSSENSE: length 26.1
  L4 w0.089: 120.11,101.19 119.99,101.06 117.87,101.06 116.82,102.11 116.82,103.09 v1(116.42,103.49)
  L4 w0.102: v1(133.66,105.41) 133.66,105.83 133.22,106.27 130.58,106.27 130.05,105.74 127.69,105.74 123.52,106.25 123.08,106.25 122.05,105.22 122.05,103 120.24,101.19 120.11,101.19
  BOTTOM w0.102: v1(133.66,105.41) 133.99,105.41 v2(134.27,105.69) 134.27,106.15 135.13,107.01 RN1602.1 ; CPU1.CC6 v1(116.42,103.49)
USB3_CHAR_2544_N: length 4.6
  TOP w0.127: U3601.11 21.52,49.99 21.01,49.48 20.88,49.48 ; v1(20.28,48.38) 20.27,48.38 20.25,48.36 20,48.36 19.85,48.51 19.85,49.29 20.04,49.48 20.88,49.48 ; 20.88,49.48 v2(20.88,49.3)
  BOTTOM w0.127: R3615.1 20.5,48.38 v1(20.28,48.38)
USB3_CHAR_2544_P: length 4.9
  TOP w0.127: U3601.10 21.02,49.83 20.91,49.72 19.94,49.72 19.61,49.39 19.61,48.92 ; 19.61,48.92 19.61,48.41 v1(20.27,47.74) ; 19.61,48.92 v2(19.46,48.92)
  BOTTOM w0.127: R3614.1 20.65,47.74 v1(20.27,47.74)
USB3_CHAR_N: length 4.7
  BOTTOM w0.127: EL3501.4 19.85,50.65 20.45,50.65 ; 20.45,50.65 v2(20.45,50.5) ; 20.45,50.65 20.98,50.65 21.21,50.42 21.97,50.42 22.32,50.08 22.32,49.33 R3615.2
USB3_CHAR_P: length 6.9
  BOTTOM w0.127: 21.69,50.66 22.07,50.66 22.56,50.18 22.56,49.23 22.3,48.98 22.3,48.59 R3616.2 ; 21.69,50.66 21.31,50.66 21.08,50.89 19.16,50.89 18.86,50.59 EL3501.1 ; 21.69,50.66 v2(21.69,50.83)
USB3_NONPS_N: length 9.4
  TOP w0.114: R3611.2 22.7,54.04 v1(22.1,54.04)
  L4 w0.114: v1(22.1,54.04) 22.01,54.13 21.6,54.13 20.83,53.37 20.83,49.99 20.7,49.85 20.43,49.59 20.43,49.59 20.17,49.33 20.17,49.11 20.27,49.01 v1(20.29,49.01)
  BOTTOM w0.127: v1(22.1,54.04) 21.84,53.81 21.69,53.7 21.68,53.7 v2(21.66,53.7) ; v1(20.29,49.01) 20.99,49.72 R3617.1
USB3_NONPS_P: length 14
  TOP w0.127: R3610.2 22.32,56.44 v1(22.12,56.64)
  L4 w0.114: v1(22.12,56.64) 22.1,56.62 22.1,54.96 20.6,53.46 20.6,50.08 20.34,49.81 19.83,49.31 19.83,47.52 v1(20.28,47.08)
  BOTTOM w0.127: v1(20.28,47.08) 20.45,47.25 R3616.1 ; v2(22.29,57.56) 22.12,57.39 v1(22.12,56.64)
USB3_USB20_2544_N: length 3.4
  TOP w0.127: R3613.1 21.58,55.16 21.08,55.16 20.96,55.04 20.87,54.71 20.87,54.34 21.03,54.18 ; 21.03,54.18 v2(21.14,54.28) ; 21.03,54.18 21.38,53.84 21.38,53.61 21.52,53.46 U3601.2
USB3_USB20_2544_P: length 3.8
  TOP w0.127: 20.98,55.4 21.72,55.4 R3612.1 ; 20.98,55.4 v2(20.88,55.5) ; 20.98,55.4 20.84,55.26 20.75,55.16 20.63,54.75 20.63,54.24 21.13,53.74 21.13,53.65 21.02,53.53 U3601.3
USB3_USB20_CON_N: length 17.3
  TOP w0.127: USB1.2 13.14,55.96 12.29,55.11 12.29,54.18 12.44,54.03 12.44,53.56 12.86,53.14 13.39,53.14 14.08,52.45 14.08,51.58 14.5,51.15 14.5,50.72 14.5,50.68 14.5,48.38 14.91,47.97 15.61,47.97 v1(15.83,47.74) 16.44,47.74 AFTP3502.1
  BOTTOM w0.127: EL3501.3 19.55,48.98 19.31,48.74 19.31,48.04 ED3502.1 18.89,47.99 18.41,47.52 16.37,47.52 16.35,47.53 16.35,47.53 16.26,47.62 16.26,47.63 16.14,47.74 v1(15.83,47.74)
USB3_USB20_CON_P: length 15.3
  TOP w0.127: AFTP3503.1 16.49,49.1 v1(15.83,48.45) 15.63,48.65 15.45,48.65 15.32,48.53 15.32,48.34 15.19,48.21 15.01,48.21 14.74,48.48 14.74,50.58 14.74,50.58 14.74,50.7 14.74,51.25 14.32,51.68 14.32,52.55 13.49,53.38 12.96,53.38 12.68,53.66 12.68,53.82 12.78,53.93 13.01,53.93 13.14,54.05 USB1.3
  BOTTOM w0.127: EL3501.2 18.86,49.01 19,48.87 19,48.57 18.92,48.49 18.77,48.49 18.65,48.36 18.65,48.09 18.31,47.76 17.05,47.76 ED3502.6 16.4,47.99 15.95,48.45 v1(15.83,48.45)
USB3_USB20_N: length 167.3
  TOP w0.127: v1(23.42,54.75) 23.1,55.07 22.99,55.07 R3611.1
  L3 w0.114: v1(120.49,112.74) 120.29,112.54 120.07,112.54 119.94,112.66 119.94,115.24 113.65,121.53 113.18,122 104.57,122 103.88,122.7 68.94,122.7 57.13,110.88 57.13,109.6 53.55,106.02 53.55,104.46 52.77,103.69 52.35,103.69 51.58,102.92 51.58,102.5 50.02,100.94 49.26,100.94 46.24,97.92 46.24,93.04 47,92.28 47,91.54 46.85,91.4 42.55,91.4 41.84,90.68 41.84,82.81 42.68,81.97 42.68,80.67 43.63,79.72 43.63,77.2 41.89,75.46 41.14,75.46 40.44,74.76 39.71,74.76 37.55,72.59 35.46,72.59 34.94,72.07 33.63,72.07 30.84,69.28 29.02,69.28 25.94,66.2 25.94,63.55 25.66,63.27 24.32,63.27 21.92,60.88 21.92,60.18 21.18,59.44 21.18,57.97 21.45,57.7 21.45,56.34 22.26,55.53 22.92,55.53 23.42,55.03 v1(23.42,54.75)
  BOTTOM w0.076: CPU1.CE3 116.82,105.59 116.93,105.86 116.93,106.07 116.91,106.15 116.91,106.43 116.94,106.51 116.94,106.81 116.85,106.89 116.84,107.39 116.84,107.39 116.84,107.47 116.84,107.54 118.01,108.72 118.67,108.72 119.22,109.27 119.22,109.51 119.19,109.54 119.19,109.56
  BOTTOM w0.127: v2(119.03,110.06) 119.19,110.06 ; 119.19,110.06 119.19,112.05 119.71,112.57 120.32,112.57 v1(120.49,112.74) ; 119.19,110.06 119.19,109.56
USB3_USB20_P: length 166.9
  TOP w0.127: R3610.1 22.86,55.47 23.6,55.47 v1(23.69,55.56)
  L3 w0.114: v1(23.69,55.56) 23.6,55.47 23.29,55.47 23.02,55.75 22.36,55.75 21.68,56.43 21.68,57.8 21.41,58.07 21.41,59.35 22.15,60.08 22.15,60.78 24.42,63.04 25.75,63.04 26.16,63.46 26.16,66.1 29.11,69.05 30.93,69.05 33.73,71.84 35.03,71.84 35.56,72.37 37.65,72.37 39.81,74.53 40.53,74.53 41.24,75.23 41.98,75.23 43.86,77.1 43.86,79.81 42.9,80.76 42.9,82.07 42.07,82.91 42.07,90.58 42.65,91.17 46.95,91.17 47.23,91.45 47.23,92.37 46.47,93.13 46.47,97.83 49.36,100.71 50.12,100.71 51.81,102.4 51.81,102.82 52.45,103.46 52.87,103.46 53.77,104.37 53.77,105.93 57.36,109.51 57.36,110.79 69.03,122.47 103.78,122.47 104.47,121.78 113.08,121.78 113.42,121.44 119.71,115.15 119.71,112.57 119.97,112.31 120.31,112.31 v1(120.53,112.09)
  BOTTOM w0.076: CPU1.CE4 116.96,105.21 116.96,105.47 117.11,105.82 117.11,106.11 117.1,106.14 117.08,106.18 117.08,106.4 117.1,106.44 117.11,106.47 117.11,106.88 117.03,106.96 117.02,107.47 118.09,108.54 118.74,108.54 119.4,109.2 119.4,109.51 119.43,109.54 119.43,109.56
  BOTTOM w0.127: 119.43,111.2 119.43,111.95 119.81,112.33 120.29,112.33 v1(120.53,112.09) ; 119.43,111.2 119.43,109.56 ; 119.43,111.2 v2(119.56,111.2)
USB3_USB30_RX_CON_N: length 8.2
  BOTTOM w0.114: ED3501.10 ED3501.1
  BOTTOM w0.127: EL3503.3 18.6,52.57 ED3501.10 ; USB1.5 11.64,52.01 12.64,53 14.35,53 15.01,52.35 16,52.35 16.22,52.57 ED3501.1
USB3_USB30_RX_CON_P: length 7.7
  BOTTOM w0.114: ED3501.9 ED3501.2
  BOTTOM w0.127: ED3501.2 16.36,53.05 16.13,52.81 16.12,52.81 15.9,52.59 15.11,52.59 14.45,53.25 12.04,53.25 USB1.6 ; ED3501.9 18.54,53.05 EL3503.4
USB3_USB30_TX_CMC_N: length 3.3
  BOTTOM w0.127: C3521.2 21.14,56.15 21.14,55.16 20.25,54.27 19.89,54.27 EL3502.1
USB3_USB30_TX_CMC_P: length 2.9
  BOTTOM w0.127: EL3502.2 19.87,54.51 20.15,54.51 20.9,55.26 20.9,56.14 C3520.2
USB3_USB30_TX_CON_N: length 10
  BOTTOM w0.114: ED3501.7 ED3501.4
  BOTTOM w0.127: ED3501.4 16.07,54.09 15.9,54.25 15.15,54.25 14.37,55.03 14.37,57.28 13.81,57.84 11.83,57.84 USB1.8 ; EL3502.3 18.6,54.09 ED3501.7
USB3_USB30_TX_CON_P: length 10.8
  BOTTOM w0.114: ED3501.6 ED3501.5
  BOTTOM w0.127: EL3502.4 18.49,54.57 ED3501.6 ; ED3501.5 16.08,54.57 16,54.49 15.25,54.49 14.61,55.13 14.61,57.38 13.91,58.08 12.72,58.08 11.64,59.16 USB1.9
USB3_USB31_RX_N: length 160
  L3 w0.114: v1(115.54,103.59) 115.74,103.78 115.74,104.37 116.04,104.67 116.04,114.31 116.49,114.76 116.49,116.38 112.65,120.22 112.32,120.56 103.97,120.56 103.28,121.25 69.56,121.25 58.68,110.37 58.68,109.03 56.06,106.41 56.06,103.71 55.53,103.17 55.53,101.28 53.71,99.47 49.96,99.47 48.52,98.02 48.52,88.92 48.82,88.62 48.82,87.02 48.12,86.32 48.12,81.09 47.6,80.58 47.6,78.33 40.26,70.99 35.91,70.99 35.37,70.45 34.14,70.45 31.27,67.58 29.59,67.58 27.54,65.53 27.54,61.62 25.3,59.38 25.3,58.53 24.21,57.44 23.78,57.44 23.65,57.31 23.65,57.18 v1(23.87,56.96)
  BOTTOM w0.127: EL3503.1 19.9,52.71 20.24,52.71 20.78,53.25 20.78,53.89 23.85,56.96 v1(23.87,56.96) ; v1(115.54,103.59) 115.65,103.75 115.61,103.93 115.32,104.12 115.14,104.08 CPU1.CB5
USB3_USB31_RX_P: length 160.4
  L3 w0.114: v1(115.54,102.95) 115.97,103.37 115.97,104.28 116.27,104.58 116.27,114.22 116.72,114.66 116.72,116.48 112.88,120.31 112.41,120.78 104.06,120.78 103.37,121.48 69.46,121.48 58.45,110.46 58.45,109.12 55.83,106.5 55.83,103.8 55.3,103.27 55.3,101.38 53.62,99.7 49.87,99.7 48.29,98.12 48.29,88.83 48.59,88.52 48.59,87.12 47.89,86.41 47.89,81.18 47.37,80.67 47.37,78.43 40.17,71.22 35.81,71.22 35.27,70.68 34.05,70.68 31.18,67.81 29.49,67.81 27.31,65.63 27.31,61.71 25.07,59.48 25.07,58.63 24.12,57.67 23.68,57.67 23.42,57.41 23.42,57.25 v1(23.22,57.05)
  BOTTOM w0.127: v1(23.22,57.05) 23.29,56.98 23.29,56.74 20.53,53.99 20.53,53.35 20.14,52.95 19.91,52.95 EL3503.2 ; CPU1.CB6 v1(115.54,102.95)
USB3_USB31_TX_N: length 158.8
  L3 w0.114: v1(22.6,58.23) 22.62,58.23 22.81,58.43 22.81,60.81 24.67,62.66 26.09,62.66 26.62,63.2 26.62,65.91 29.28,68.57 31.02,68.57 33.8,71.35 35.08,71.35 35.64,71.91 39.23,71.91 41.58,74.25 42.33,74.25 46.61,78.53 46.61,80.84 47.24,81.46 47.24,86.74 47.96,87.47 47.96,88.19 47.68,88.47 47.68,92.81 46.85,93.64 46.85,97.54 49.64,100.33 50.9,100.33 54.09,103.52 54.59,103.52 55.15,104.08 55.15,106.68 55.43,106.96 55.78,107.32 57.45,108.98 57.84,109.37 57.84,110.73 69.19,122.09 103.62,122.09 104.32,121.39 112.8,121.39 113.27,120.92 118.11,116.08 118.11,113.51 117.66,113.06 117.03,113.06 v1(116.81,112.83)
  BOTTOM w0.076: CPU1.CA4 114.52,105.15 114.52,105.3 114.52,105.47 114.55,105.55 114.66,105.79 114.67,105.8 114.67,106.1 114.64,106.18 114.64,106.4 114.66,106.45 114.67,106.48 114.67,106.9 114.48,107.1 114.48,107.39 114.87,107.78 114.87,108.72 115.61,109.47 115.61,110.01 115.65,110.04 115.65,110.06
  BOTTOM w0.127: 115.65,110.06 115.65,112.38 116.09,112.83 v1(116.81,112.83) ; C3521.1 21.1,57.63 21.1,58.14 21.78,58.81 22.43,58.81 22.7,58.54 22.7,58.33 22.6,58.23 v1(22.6,58.23)
USB3_USB31_TX_P: length 158.4
  L3 w0.114: v1(116.81,113.46) 116.99,113.29 117.56,113.29 117.88,113.61 117.88,115.98 113.04,120.83 112.7,121.17 104.22,121.17 103.53,121.86 69.29,121.86 58.07,110.64 58.07,109.28 55.94,107.16 55.65,106.87 55.38,106.59 55.38,103.98 54.68,103.29 54.18,103.29 50.99,100.1 49.74,100.1 47.08,97.45 47.08,93.73 47.91,92.91 47.91,88.56 48.19,88.28 48.19,87.37 47.47,86.65 47.47,81.37 46.84,80.74 46.84,78.44 42.43,74.02 41.67,74.02 39.33,71.68 35.73,71.68 35.17,71.12 33.89,71.12 31.12,68.34 29.38,68.34 26.85,65.82 26.85,63.1 26.18,62.43 24.76,62.43 23.04,60.71 23.04,58.42 v1(23.24,58.22)
  BOTTOM w0.076: CPU1.CA3 114.29,105.41 114.39,105.63 114.47,105.8 114.49,105.86 114.49,106.07 114.47,106.15 114.47,106.43 114.49,106.51 114.49,106.83 114.3,107.02 114.3,107.46 114.69,107.85 114.69,108.79 115.44,109.54 115.44,110.01 115.41,110.04 115.41,110.06
  BOTTOM w0.127: C3520.1 20.86,57.58 20.86,58.24 21.68,59.06 22.53,59.06 23.24,58.34 v1(23.24,58.22) ; 115.41,110.06 115.41,112.48 115.99,113.07 116.45,113.07 116.81,113.42 v1(116.81,113.46)
USB4_USB20_CON_N: length 36.8
  TOP w0.127: AFTP3505.1 17.4,45.8 v1(15.45,45.8)
  L3 w0.114: USB2.2 13.14,31.19 13.27,31.07 13.69,31.07 14.11,31.49 14.11,37.69 12.23,39.57 9.22,39.57 8.51,40.29 8.51,44.22 9.56,45.26 11.36,45.26 12.42,46.33 13.18,46.33 v1(13.37,46.52)
  BOTTOM w0.114: 16.36,46.57 17.03,46.57
  BOTTOM w0.127: 16.36,46.57 16.19,46.39 16.19,46.23 15.76,45.8 v1(15.45,45.8) 15.05,45.39 14.69,45.39 13.83,46.26 13.64,46.26 v1(13.37,46.52) ; 17.03,46.57 17.55,46.57 18.27,45.84 19.01,45.84 ED3502.3 19.27,46.09 19.52,45.84 20.4,45.84 20.82,46.26 21.15,46.26 EL3506.2
USB4_USB20_CON_P: length 35.8
  TOP w0.127: AFTP3506.1 16.36,45.45 16.26,45.56 15.86,45.56 v1(15.46,45.15)
  L3 w0.114: v1(13.34,45.89) 13.13,46.1 12.52,46.1 11.45,45.04 9.66,45.04 8.74,44.12 8.74,40.38 9.32,39.8 12.32,39.8 14.34,37.79 14.34,31.39 13.78,30.84 13.31,30.84 13.14,30.66 USB2.3
  BOTTOM w0.127: EL3506.3 21.05,46.02 20.92,46.02 20.5,45.6 18.77,45.6 18.77,45.6 18.17,45.6 17.45,46.32 17.13,46.32 16.9,46.09 ED3502.4 16.4,46.09 v1(15.46,45.15) 14.59,45.15 13.73,46.02 13.47,46.02 v1(13.34,45.89)
USB4_USB20_N: length 168
  L3 w0.114: v1(23.23,46.91) 23.09,46.91 22.85,47.15 22.85,48.79 23.79,49.73 23.79,51.91 25.91,54.03 25.91,55.3 26.79,56.18 26.79,56.86 27.74,57.81 27.74,58.67 29.59,60.53 29.59,62.07 29.59,63.34 29.59,64.66 29.76,64.82 31.13,64.82 34.77,68.46 40.44,68.46 43.68,71.7 43.68,71.83 49.63,77.78 49.63,79.51 50.74,80.61 50.74,81.28 51.31,81.85 51.31,83.71 50.65,84.37 50.65,87.95 51.29,88.59 51.29,89.19 50.35,90.13 50.35,96.83 50.88,97.36 54.95,97.36 55.45,97.36 58.93,100.84 58.93,103.66 58.3,104.29 58.3,106.06 60.72,108.48 60.72,109.75 70.39,119.42 102.52,119.42 103.53,118.4 109.35,118.4 110.08,117.67 111.98,117.67 113.9,115.75 113.9,115.31 113.76,115.17 113.63,115.17 v1(113.53,115.27)
  BOTTOM w0.076: 120.04,109.55 120.04,109.53 120.01,109.5 120.01,109.23 118.8,108.02 118.59,108.02 118.27,107.7 118.27,107.18 118.08,106.99 117.96,106.93 117.91,106.91 117.87,106.89 117.74,106.76 117.74,106.51 117.77,106.43 117.77,106.15 117.74,106.07 117.74,105.86 117.78,105.78 117.78,105.78 117.82,105.7 117.9,105.61 118.14,105.61 118.27,105.49 118.27,105.08 118.14,104.95 117.96,104.95 117.88,105.03 117.88,105.2 CPU1.CG3
  BOTTOM w0.127: 120.04,109.55 120.04,110.53 121.4,111.89 121.4,113.42 120.15,114.68 ; 120.15,114.68 119.66,115.16 113.64,115.16 v1(113.53,115.27) ; 120.15,114.68 v2(120.25,114.78) ; v1(23.23,46.91) 23.23,46.85 23.1,46.72 23.09,46.72 23.07,46.7 23.05,46.7 22.8,46.45 EL3506.1
USB4_USB20_P: length 168.5
  L3 w0.114: v1(113.82,114.71) 113.82,114.91 114.13,115.22 114.13,115.84 112.07,117.9 110.18,117.9 109.45,118.63 103.63,118.63 102.61,119.65 70.29,119.65 60.49,109.84 60.49,108.57 58.07,106.16 58.07,104.2 58.7,103.56 58.7,100.93 55.36,97.59 55.04,97.59 50.78,97.59 50.12,96.92 50.12,90.03 51.06,89.09 51.06,88.68 50.42,88.05 50.42,84.28 51.08,83.62 51.08,81.94 50.51,81.37 50.51,80.7 49.41,79.6 49.41,77.87 43.45,71.92 43.45,71.8 40.35,68.69 34.68,68.69 31.03,65.05 29.66,65.05 29.37,64.76 29.37,63.34 29.37,62.07 29.37,60.62 27.51,58.77 27.51,57.9 26.56,56.96 26.56,56.27 25.68,55.39 25.68,54.13 23.56,52.01 23.56,49.82 22.62,48.88 22.62,46.89 23.23,46.28 v1(23.23,46.26)
  BOTTOM w0.076: 119.8,109.55 119.8,109.53 119.83,109.5 119.83,109.3 118.73,108.2 118.51,108.2 118.09,107.78 118.09,107.26 117.98,107.14 117.88,107.1 117.87,107.09 117.77,107.04 117.56,106.84 117.56,106.48 117.59,106.4 117.59,106.18 117.57,106.12 117.56,106.11 117.56,105.83 117.58,105.79 117.62,105.7 117.66,105.62 117.66,105 CPU1.CG4
  BOTTOM w0.127: v2(114.79,114.78) 114.79,114.92 ; 114.79,114.92 114.04,114.92 v1(113.82,114.71) ; 114.79,114.92 119.56,114.92 121.16,113.32 121.16,111.99 119.8,110.63 119.8,109.55 ; v1(23.23,46.26) 22.74,45.76 EL3506.4
USB4_USB30_RX_C_N: length 7
  TOP w0.127: R7155.1 21.85,99.94 21.85,99.66 22.12,99.39 23.99,99.39 24.44,98.95 26.52,98.95 26.83,99.26 27.01,99.26 27.28,98.99 C7106.2
USB4_USB30_RX_C_P: length 6.6
  TOP w0.127: C7105.2 27.28,99.77 27.01,99.5 26.73,99.5 26.42,99.19 24.54,99.19 24.09,99.64 22.22,99.64 22.09,99.76 22.09,99.94 R7156.1
USB4_USB30_RX_C_R_N: length 1.9
  TOP w0.127: R7155.2 21.88,101.4 21.88,102.26 21.8,102.34 U7101.4
USB4_USB30_RX_C_R_P: length 1.9
  TOP w0.127: R7156.2 22.12,101.35 22.12,102.26 22.2,102.34 U7101.5
USB4_USB30_RX_CON_N: length 23.9
  BOTTOM w0.127: USB2.5 12.17,27.73 13.03,28.59 13.74,28.59 15.01,29.86 15.01,38.04 15.24,38.28 15.24,42.21 15.73,42.7 16.14,42.7 16.26,42.82 ED3503.1 ED3503.10 18.68,42.82 19.17,43.3 20.28,43.3 20.98,42.6 EL3505.3
USB4_USB30_RX_CON_P: length 24.8
  BOTTOM w0.127: EL3505.4 20.67,43.25 20.38,43.55 19.07,43.55 18.82,43.3 ED3503.9 ED3503.2 17.01,43.3 16.77,43.06 16.16,43.06 16.04,42.94 15.63,42.94 15,42.31 15,38.38 14.77,38.14 14.77,29.96 13.63,28.83 12.93,28.83 11.93,27.84 11.59,27.84 11.46,27.97 11.46,28.82 USB2.6
USB4_USB30_RX_N: length 114.2
  TOP w0.127: C7106.1 29.05,99.53 29.27,99.53 29.72,99.07 39.3,99.07 40.83,97.54 47.4,97.54 48.42,96.53 48.42,96.21 50.37,94.26 50.9,94.26 v1(51.01,94.16)
  L3 w0.114: v1(51.01,94.16) 51.73,94.16 53.41,95.84 55.67,95.84 60.33,100.5 60.33,106.37 61.94,107.98 61.94,109.08 71.06,118.2 102,118.2 103.02,117.18 108.74,117.18 110.09,115.83 110.62,115.83 112,114.45 112,113.04 112.65,112.4 112.65,107.44 112.78,107.32 112.78,104.08 112.78,104.08 112.78,103.89 113.04,103.63 113.61,103.63 v1(113.65,103.6)
  BOTTOM w0.127: CPU1.BW6 v1(113.65,103.6)
USB4_USB30_RX_P: length 114.6
  TOP w0.127: v1(51.01,94.79) 50.95,94.73 50.95,94.73 50.72,94.5 50.47,94.5 48.66,96.32 48.66,96.63 47.5,97.79 40.93,97.79 39.4,99.32 29.82,99.32 29.37,99.77 C7105.1
  L3 w0.114: v1(113.52,104.32) 113.52,104.07 113.31,103.86 113.13,103.86 113.01,103.98 113.01,107.41 112.88,107.54 112.88,112.49 112.23,113.14 112.23,114.54 110.85,115.93 110.72,116.06 110.19,116.06 108.84,117.41 103.11,117.41 102.1,118.43 70.97,118.43 61.71,109.18 61.71,108.07 60.1,106.46 60.1,100.6 55.57,96.06 53.32,96.06 51.64,94.39 51.41,94.39 v1(51.01,94.79)
  BOTTOM w0.127: v1(113.52,104.32) 113.21,104.32 113.08,104.19 113.08,104.02 CPU1.BW5
USB4_USB30_TX_C_N: length 2.2
  TOP w0.127: R7153.1 25.9,100.83 26.89,100.83 27.16,100.56 C7104.2
USB4_USB30_TX_C_P: length 2.2
  TOP w0.127: C7103.2 27.28,101.35 27,101.07 25.94,101.07 R7154.1
USB4_USB30_TX_C_R_N: length 3.6
  TOP w0.127: R7153.2 24.48,100.85 23.42,100.85 23.08,101.2 23.08,102.26 23,102.34 U7101.7
USB4_USB30_TX_C_R_P: length 3.2
  TOP w0.127: R7154.2 24.49,101.09 23.52,101.09 23.32,101.3 23.32,102.26 23.4,102.34 U7101.8
USB4_USB30_TX_CMC_N: length 1.1
  BOTTOM w0.127: EL3504.1 20.72,44.41 21.11,44.41 C3523.2
USB4_USB30_TX_CMC_P: length 1.1
  BOTTOM w0.127: C3522.2 21.14,44.65 20.72,44.65 EL3504.2
USB4_USB30_TX_CON_N: length 19.8
  BOTTOM w0.127: EL3504.3 19.27,44.4 18.74,44.4 18.67,44.34 ED3503.7 ED3503.4 16.96,44.34 16.83,44.47 15.46,44.47 14.46,43.46 14.46,41.38 13.21,40.13 13.21,39.1 14.26,38.05 14.26,33.74 13.78,33.26 12.84,33.26 12.36,33.74 12,33.74 11.85,33.58 USB2.8
USB4_USB30_TX_CON_P: length 19.9
  BOTTOM w0.127: USB2.9 11.64,34.8 12.33,34.11 12.94,33.5 13.68,33.5 14.02,33.84 14.02,37.95 12.97,39 12.97,40.23 14.21,41.48 14.21,43.56 15.36,44.71 16.87,44.71 16.98,44.82 ED3503.5 ED3503.6 18.61,44.82 18.79,44.64 19.26,44.64 EL3504.4
USB4_USB30_TX_N: length 112.1
  TOP w0.127: v1(51,95.9) 50.03,95.9 47.63,98.29 41.14,98.29 39.54,99.89 30.05,99.89 29.38,100.56 C7104.1
  L3 w0.114: v1(113.54,112.46) 112.69,113.31 112.69,114.73 110.42,117 109.87,117 109.07,117.79 103.27,117.79 102.26,118.81 70.7,118.81 61.33,109.44 61.33,108.23 58.92,105.82 58.92,104.59 59.59,103.91 59.59,100.62 55.44,96.47 52.6,96.47 52.03,95.9 v1(51,95.9)
  BOTTOM w0.076: 113.01,108.79 113.01,108.77 112.98,108.74 112.98,108.29 113.37,107.89 113.37,106.37 113.11,106.12 CPU1.BW2
  BOTTOM w0.127: v1(113.54,112.46) 113.4,112.6 113.13,112.6 113.01,112.47 113.01,108.79
USB4_USB30_TX_P: length 112.4
  TOP w0.127: v1(51,96.55) 50.59,96.14 50.13,96.14 47.73,98.53 41.24,98.53 39.64,100.13 30.15,100.13 29.48,100.8 29.11,100.8 28.98,100.93 28.98,101.22 28.86,101.35 C7103.1
  L3 w0.114: v1(113.57,113.1) 113.23,113.1 112.92,113.41 112.92,114.83 110.52,117.23 109.96,117.23 109.17,118.02 103.37,118.02 102.35,119.04 70.61,119.04 61.1,109.53 61.1,109.34 61.1,108.33 58.69,105.91 58.69,104.49 59.36,103.82 59.36,100.72 55.34,96.7 52.5,96.7 51.93,96.13 51.42,96.13 v1(51,96.55)
  BOTTOM w0.076: CPU1.BW1 113.19,106.69 113.19,107.82 112.8,108.21 112.8,108.74 112.77,108.77 112.77,108.79
  BOTTOM w0.127: 112.77,108.79 112.77,112.57 113.03,112.84 113.31,112.84 v1(113.57,113.1)
USB4_USB31_RX_N: length 170
  L3 w0.114: v1(114.53,102.93) 115.13,103.6 115.13,103.77 115.36,104 115.36,104.5 115.6,104.74 115.6,114.58 115.93,114.91 115.93,116.28 112.03,120.18 103.81,120.18 103.12,120.87 69.72,120.87 59.06,110.21 59.06,108.87 56.46,106.27 56.46,103.57 55.91,103.02 55.91,101.11 53.81,99.01 50.05,99.01 48.9,97.86 48.9,89.08 49.2,88.77 49.2,86.86 48.51,86.17 48.51,80.74 47.98,80.22 47.98,78.18 42.14,72.33 42.14,72.21 42.03,72.1 39.86,69.93 34.16,69.93 30.55,66.32 28.97,66.32 27.99,65.34 27.99,61.22 25.8,59.02 25.8,57.92 24.87,56.99 24.87,56.31 24.46,55.9 24.46,54.64 22.24,52.42 22.24,50.44 21.36,49.56 21.36,45.19 22.62,43.93 22.62,42.7 22.99,42.33 23.07,42.27 v1(23.31,42.13)
  BOTTOM w0.127: CPU1.BY7 v1(114.53,102.93) ; v1(23.31,42.13) 22.83,42.54 EL3505.1
USB4_USB31_RX_P: length 169
  L3 w0.114: v1(23.32,43.04) 23.44,42.92 23.44,42.74 23.27,42.56 23.08,42.56 22.85,42.79 22.85,44.03 21.59,45.29 21.59,49.47 22.47,50.35 22.47,52.32 24.69,54.54 24.69,55.8 25.1,56.21 25.1,56.9 26.02,57.82 26.02,58.93 28.22,61.13 28.22,65.25 29.07,66.09 30.65,66.09 34.25,69.7 39.95,69.7 42.46,72.21 42.46,72.33 48.21,78.08 48.21,80.12 48.74,80.65 48.74,86.08 49.43,86.77 49.43,88.87 49.13,89.17 49.13,97.77 50.14,98.78 53.9,98.78 56.14,101.01 56.14,102.92 56.69,103.47 56.69,106.17 59.29,108.77 59.29,110.11 69.81,120.64 103.02,120.64 103.72,119.95 111.94,119.95 115.7,116.19 115.7,115.01 115.37,114.68 115.37,104.83 115.13,104.59 115.13,104.1 114.9,103.86 114.9,103.72 114.77,103.59 v1(114.53,103.59)
  BOTTOM w0.127: CPU1.BY6 114.14,103.51 114.28,103.62 v1(114.53,103.59) ; EL3505.2 22.68,43.25 22.83,43.4 23.1,43.4 23.32,43.17 v1(23.32,43.04)
USB4_USB31_TX_N: length 164.5
  L3 w0.114: v1(114.9,113.2) 114.81,113.29 114.58,113.52 114.48,113.62 114.48,113.65 114.48,113.65 114.48,114.14 114.91,114.57 114.91,116.05 112.45,118.51 112.32,118.64 110.36,118.64 109.76,119.24 103.88,119.24 102.87,120.26 70.04,120.26 59.88,110.1 59.88,108.83 57.46,106.41 57.46,103.89 58.07,103.28 58.07,101.16 55.11,98.2 50.47,98.2 49.51,97.24 49.51,89.33 49.81,89.03 49.81,84.02 50.32,83.52 50.32,82.08 49.71,81.47 49.71,80.77 48.67,79.73 48.67,78 42.84,72.17 42.84,72.05 40.09,69.3 34.4,69.3 30.75,65.66 29.31,65.66 28.68,65.03 28.68,60.8 26.68,58.8 26.68,57.93 25.93,57.19 25.93,56.5 25.07,55.64 25.07,54.39 22.85,52.16 22.85,50.08 21.99,49.22 21.99,45.51 v1(23.23,44.27)
  BOTTOM w0.076: 113.55,108.51 113.55,108.49 113.58,108.46 113.58,106.86 113.53,106.81 113.53,106.3 113.37,106.14 113.37,105.54 CPU1.BY4
  BOTTOM w0.127: C3523.1 22.46,44.27 v1(23.23,44.27) ; 113.55,108.51 113.55,111.08 114.05,111.59 114.05,112.42 114.05,112.72 114.36,113.03 114.73,113.03 v1(114.9,113.2)
USB4_USB31_TX_P: length 164.4
  L3 w0.114: v1(23.23,44.92) 22.9,44.92 22.22,45.61 22.22,49.12 23.08,49.99 23.08,52.07 25.3,54.29 25.3,55.55 26.16,56.41 26.16,57.09 26.91,57.84 26.91,58.7 28.91,60.7 28.91,64.94 29.4,65.43 30.85,65.43 34.49,69.07 40.19,69.07 43.07,71.96 43.07,72.08 48.9,77.91 48.9,79.63 49.94,80.67 49.94,81.38 50.55,81.98 50.55,83.61 50.04,84.12 50.04,89.12 49.74,89.43 49.74,97.14 50.56,97.97 55.2,97.97 58.3,101.06 58.3,103.38 57.69,103.99 57.69,106.31 60.11,108.73 60.11,110 70.13,120.03 102.77,120.03 103.79,119.01 109.67,119.01 110.26,118.41 112.22,118.41 114.68,115.95 114.68,114.67 114.25,114.23 114.25,112.99 114.07,112.82 114.07,112.18 114.2,112.05 114.41,112.05 v1(114.89,112.53)
  BOTTOM w0.076: CPU1.BY3 113.55,105.98 113.55,106.07 113.71,106.23 113.71,106.74 113.76,106.78 113.76,108.46 113.79,108.49 113.79,108.51
  BOTTOM w0.127: C3522.1 22.31,44.78 22.59,44.51 22.82,44.51 v1(23.23,44.92) ; 113.79,108.51 113.79,110.98 114.29,111.49 114.29,112.62 114.46,112.79 114.64,112.79 v1(114.89,112.53)
USB30_PS_VCC: length 45.6
  TOP w0.305: 10.95,44.86 10.32,44.22 10.32,43.54 10.93,42.93 10.93,42.62 12.79,40.75 14.29,40.75 15.42,41.89 17.48,41.89
  TOP w0.635: USB1.1 13.98,59.15 ; USB1.1 13.14,58.31 ; USB1.1 13.14,59.99
  L2SGND w0.508: USB1.1 13.14,58.7 15.17,56.67 15.17,53.44 15.83,52.78 15.83,49.49 v1(15.74,49.39)
  L3 w0.508: v3(9.25,46.31) 11.53,46.31 13.94,48.71 13.94,49.86 14.33,50.24 14.34,50.24 14.71,50.61 14.71,52.02 14.54,52.18 14.54,56.95 13.14,58.36 USB1.1
  BOTTOM w0.305: v1(15.45,46.43) 15.49,46.46 15.71,46.46 16.13,46.88 16.13,46.89 16.28,47.04 ED3502.5
  BOTTOM w0.508: 14.36,59.02 13.27,59.02 USB1.1
  BOTTOM w0.635: 13.14,59.99 USB1.1 13.98,59.15
  vias: v2(16.57,52.15) v2(17.82,40.62) v2(22.34,49.24)
USB_ADT: length 362.4
  TOP w0.305: v1(194.54,41) 194.54,41.1 196.29,42.84 198.74,42.84 199.63,43.74 201.91,43.74 202.43,43.22 202.43,42.9 203.03,42.29 203.46,42.29 v2(205.01,40.74) 205.01,39.2 205.25,38.97 v1(205.25,37.02)
  L3 w0.305: v1(205.25,37.02) 205.25,36.48 205.68,36.05 207.89,36.05 209.41,37.57 213.08,37.57 213.77,36.88 213.79,36.88 213.99,36.68 214.89,36.68 214.97,36.76 216.08,36.76 217.58,35.25 217.58,34.96 v1(217.66,34.88)
  L3 w0.381: v1(61.24,140.79) 61.24,136.41 55.44,130.61 55.44,130.52 53.96,129.04 48.01,129.04 44.81,125.83 43.13,125.83 42.64,125.34 39.18,125.34 38.89,125.05 v1(38.89,124.96)
  L4 w0.381: v1(61.24,140.79) 62.66,140.79 71.62,149.75 96.05,149.75 97.56,148.24 104.63,148.24 106.05,149.65 120.43,149.65 122.43,147.65 127.4,147.65 131.07,151.32 164.15,151.32 167.97,147.5 167.97,107.79 166.76,106.58 163.1,106.58 159.48,102.96 159.48,98.52 168.33,89.66 168.33,82.07 177.4,72.99 178.75,72.99 180.52,71.22 180.78,71.22 180.78,71.22 181.69,71.22 183.33,69.58 186.34,69.58 186.93,69.4 187.62,69.1 188.19,68.71 188.75,68.15 188.75,68.15 188.86,68 188.94,67.9 189.05,67.78 189.16,67.68 189.35,67.51 189.55,67.3 208.78,67.3 209.46,67.98 218.74,67.98 219.89,69.14 222.34,69.14 225.56,65.93 225.56,47.22 225.83,46.94 225.83,38.1 225.15,37.42 223.29,37.42 220.75,34.88 v1(217.66,34.88)
  BOTTOM w0.305: v1(194.54,41) 194.54,40.64 194.25,40.35 PD4408.2 193.79,40.53 PD4407.A 192.34,41.98 192.34,43.08 192.35,43.09 192.35,43.53 192.16,43.73 PD4409.A
USB_EN#: length 246.1
  TOP w0.089: AFTP6614.1 197.31,40 v1(197.74,39.57) ; R2434.2 18.77,69.66 18.95,69.65 19.58,69.03 19.58,68.76 19.92,68.42 19.92,67.83 20.27,67.47 21.23,67.47 v1(21.6,67.1) 21.93,67.44 22.9,67.44 23.16,67.69 U2401.13
  L3 w0.089: v1(197.74,39.57) 196.98,40.34 192.08,40.34 191.35,39.61 189.41,39.61 186.1,36.3 183.59,36.3 182.22,37.67 172.45,37.67 171.83,38.29 160.61,38.29 155.5,33.17 150.14,33.17 145.34,37.98 126.5,37.98 124.34,40.14 121.02,40.14 120.37,40.79 120.37,41.46 119.74,42.09 110.1,42.09 108.57,40.57 107.2,40.57 106.74,40.1 106.74,39.23 106.32,38.81 105.51,38.81 104.49,37.79 103.76,37.79 103.06,37.09 102.15,37.09 100.57,35.52 100.03,35.52 100.03,35.51 93.44,35.51 93.12,35.19 91.84,35.19 91.12,34.47 79.67,34.47 79.26,34.88 79.26,34.98 79,35.24 78.39,35.24 73.68,30.53 42.24,30.53 41.41,29.7 34.42,29.7 34.32,29.6 32.74,29.6 32.39,29.94 30.58,29.94 30.21,29.57 30.21,29.29 29.93,29.01 27.55,29.01 26.93,29.64 24.41,29.64 22.07,31.98 22.07,37.32 22.79,38.03 22.79,38.46 v1(23.07,38.74) 22.78,39.02 22.78,40.91 21.42,42.27 21.42,43.31 19.44,45.29 19.44,45.62 19.44,49.37 20.25,50.18 20.25,52.12 20.47,52.33 20.47,52.35 20.5,52.39 20.5,55.73 20.35,55.88 20.35,57.24 20.08,57.51 20.08,59.53 19.97,59.63 19.97,60.5 19.97,60.51 19.97,60.65 19.95,60.67 19.95,61.52 19.97,61.54 19.97,63.81 21.6,65.44 v1(21.6,67.1)
  BOTTOM w0.089: IOBD1.12 197.8,39.51 v1(197.74,39.57) ; U3502.4 20.04,40.73 20.19,40.89 20.26,40.89 20.28,40.91 21.11,40.91 21.8,40.23 21.8,39.53 22.59,38.74 v1(23.07,38.74)
USB_OC0#: length 237
  TOP w0.089: v1(28.35,50.95) 28.2,51.11 27.51,51.11 27.21,50.8 27.21,50.09 v2(26.88,49.76) 26.27,49.76 25.85,50.17 25.16,50.17 24.73,49.74 R3607.2 24.73,49.37 22.58,47.23 22.58,44.71 R3512.1
  L3 w0.089: v1(134.01,107.21) 133.91,107.21 133.45,106.76 133.45,106.33 133.81,105.97 134.62,105.97 155.35,85.24 155.35,81.33 166.09,70.59 v1(166.09,70.49) ; v1(28.35,50.95) 28.36,50.96 28.36,51.39 30.87,53.91 30.87,53.99 30.87,57.1 31.14,57.37 31.41,57.37 31.42,57.38 32.56,57.38 32.77,57.17 v1(33.03,57.17)
  L4 w0.089: v1(120.16,103.18) 120.7,103.72 120.7,104.92 122.94,107.15 122.94,107.29 123.53,107.88 124.39,107.88 127.16,110.65 130.17,110.65 133.61,107.21 v1(134.01,107.21)
  BOTTOM w0.089: v1(134.01,107.21) 134.39,107.6 134.39,107.99 134.95,108.55 RN1601.5 ; v1(120.16,103.18) 120.16,103.18 120.12,103.12 119.88,103.12 CPU1.CK6 ; v1(33.03,57.17) 33.3,57.17 34.5,55.98 40.72,55.98 40.76,56.02 42.14,56.17 54.87,56.17 56.82,58.12 90.1,58.12 95.02,63.04 108.64,63.04 112.12,59.56 146.97,59.56 147.2,59.34 149.29,59.34 149.66,59.71 153.92,59.71 157.47,63.26 160.09,63.26 163.6,66.77 163.6,67.46 166.09,69.95 v1(166.09,70.49)
USB_OC1#: length 159.3
  TOP w0.089: v1(134.39,103.43) 134.39,103.94 135.18,104.73 135.18,105.79 134.6,106.38 134.6,107.6 134.33,107.86 v1(133.95,107.86)
  L3 w0.089: v1(134.39,103.43) 134.39,102.49 134.63,102.25 134.63,102.12 137.39,99.37 138.33,99.37 149.15,88.55 149.66,88.55 152.94,85.27 152.94,84.28 153.99,83.22 153.99,80.85 162.11,72.74 162.11,72.11 167.62,66.59 167.62,65.74 174.92,58.44 176.3,58.44 177.69,57.06 178.67,57.06 180.39,57.06 180.6,56.85 180.9,56.55 190.45,56.55 192.63,58.73 203.44,58.73 203.78,58.38 203.81,58.38 203.85,58.34 204.44,58.34 205.24,57.54 206.58,57.54 206.65,57.61 208.01,57.61 208.02,57.6 208.26,57.6 210.9,54.96 210.9,51.81 211.08,51.64 211.08,51.06 210.83,50.82 210.02,50.82 209.69,50.48 208.98,50.48 v1(208.98,50.48)
  L4 w0.089: v1(120.15,103.82) 120.15,105.71 120.58,106.14 120.58,106.81 120.77,107 120.77,107.1 120.83,107.15 120.83,107.44 120.85,107.46 120.85,107.67 120.98,107.8 122.69,107.8 125.72,110.83 130.98,110.83 v1(133.95,107.86) ; v1(208.98,50.48) 208.97,50.48 208.96,50.48 208.63,50.48 208.49,50.34 208.49,49.46 208.77,49.18 208.77,48.44 208.16,47.83 208.16,43.89 207.35,43.09 207.35,42.66 206.96,42.27 206.96,41.48 206.93,41.45 206.93,40.77 206.63,40.46 205.07,40.46 203.16,42.37 201.51,42.37 199.75,40.62 v1(198.38,40.62)
  BOTTOM w0.089: CPU1.CK5 120.05,103.92 v1(120.15,103.82) ; v1(133.95,107.86) 134.67,108.58 134.67,108.99 134.82,109.14 RN1601.6 ; v1(198.38,40.62) 198.3,40.54 198.3,40.42 198.3,40.41 v2(198.3,39.89) IOBD1.11
USB_OC1#_R: length 9.2
  TOP w0.102: v1(19.82,40.02) 22.23,42.43 R3512.2
  BOTTOM w0.089: 18.64,40.08 19.75,40.08 v1(19.82,40.02)
  BOTTOM w0.102: U3502.3 16.83,41.19 17.3,41.66 v2(17.84,41.66) 18.52,40.98 18.52,40.21 18.64,40.08
USB_OC2#: length 25.8
  L4 w0.102: v1(120.18,102.55) 119.89,102.84 119.89,102.88 119.74,103.03 119.74,105.74 118.93,106.55 118.93,107.56 119.39,108.03 122.23,108.03 125.23,111.03 131.5,111.03 v1(133.99,108.54)
  BOTTOM w0.102: v1(120.18,102.55) 120.18,102.5 CPU1.CK8 ; v1(133.99,108.54) 134.45,108.99 134.45,109.4 134.68,109.64 RN1601.7
USB_OC3#: length 26.1
  L4 w0.102: v1(119.18,102.21) 118.74,102.64 118.74,104.1 118.75,104.11 118.75,104.45 118.74,104.46 118.74,107.67 119.48,108.41 122,108.41 124.82,111.23 131.97,111.23 v1(134.01,109.18)
  BOTTOM w0.102: CPU1.CK9 119.23,101.62 119.16,102.05 119.16,102.19 v1(119.18,102.21) ; RN1601.8 134.88,110.22 134.01,109.36 v1(134.01,109.18)
USB_POWERSHARE_VBUS_EN: length 50.4
  TOP w0.102: U2401.71 38.09,62.49 37.9,62.31 v1(37.9,61.85) ; v1(15.81,55.58) v2(17.53,55.58) 18.19,55.58 18.72,55.04 18.72,54.38 19.78,53.32 U3601.5
  L3 w0.102: v1(12.98,66.27) 12.98,65.74 12.5,65.26 12.5,64.85 12.83,64.52 13.01,64.52 13.28,64.78 13.9,64.78 14.43,64.25 14.43,63.43 14.07,63.07 14.07,59.96 14.38,59.65 14.38,58.29 15.37,57.3 15.37,55.83 15.62,55.58 v1(15.81,55.58)
  BOTTOM w0.102: v1(12.98,66.27) 12.98,66.8 13.71,67.53 15.48,67.53 16.45,66.56 17.82,66.56 18.1,66.85 20.73,66.85 21.42,67.54 21.78,67.54 22.06,67.25 25,67.25 25.6,66.65 25.99,66.65 27.65,65 31.17,65 31.22,64.94 32.09,64.07 33.76,64.07 35.99,61.85 v1(37.9,61.85)
USB_PWR_SHR_EN_L#: length 40.8
  TOP w0.102: U2401.118 29.16,74.53 29.59,74.96 29.8,74.96 v1(29.82,74.98) ; v1(15.8,54.94) 16.44,54.94 v2(16.49,54.89) 16.8,54.58 R3601.1 ; v1(18.83,70.17) 18.84,70.17 19.3,70.62 19.3,70.98 18.93,71.35 18.07,71.35 17.74,71.02 17.74,70.96 17.51,70.73 R3618.1
  L3 w0.102: v1(15.8,54.94) 16.26,55.4 16.26,56.75 15.86,57.14 15.81,57.14 14.58,58.37 14.58,59.74 14.42,59.91 14.42,63.13 14.72,63.43 14.72,65.59 16.16,67.03 16.22,67.03 16.85,67.66 17.19,67.66 17.73,68.2 17.73,69.12 18.77,70.17 v1(18.83,70.17) 18.43,70.56 18.43,70.98 18.69,71.24 18.83,71.24 20.35,72.75 20.35,74.24 20.29,74.3 20.29,74.66 20.94,75.31 22.34,75.31 22.63,75.6 24.66,75.6 24.67,75.59 25.2,75.59 25.21,75.6 28.1,75.6 28.13,75.56 28.44,75.56 28.45,75.55 29.11,75.55 29.66,75.01 29.72,75.01 29.75,74.98 v1(29.82,74.98)
USBC1_CC1_CONN: length 52
  TOP w0.305: C7208.1 43.26,112.09 42.83,111.66 U7201.6
  TOP w0.381: v1(9.68,122.43) 9.72,122.39 AFTP7303.1 9.72,120.96 10.29,120.4 ED7315.2 ; C7208.1 43.63,111.9 44.79,111.9 v1(44.88,111.81)
  L4 w0.381: v1(13.37,119.38) 12.53,119.38 11.59,120.32 10.24,120.32 9.78,120.78 9.78,122.33 v1(9.68,122.43)
  BOTTOM w0.152: JUSB1.A5 8.09,122.95 8.33,123.19 9.3,123.19 9.68,122.81 v1(9.68,122.43)
  BOTTOM w0.381: v1(44.88,111.81) 44.71,111.81 42.68,113.84 40.18,113.84 39.69,114.33 39.69,115.27 39.35,115.61 39.35,115.61 36.95,118.01 35.56,118.01 34.55,119.02 32.46,119.02 31.93,118.49 30.64,118.49 30.22,118.91 30.22,119.24 28.83,120.63 27.62,120.63 26.73,119.74 25.08,119.74 24.18,120.64 18.66,120.64 16.72,118.7 14.04,118.7 v1(13.37,119.38)
USBC1_CC2_CONN: length 54.9
  TOP w0.305: v1(43.87,111.31) 43.97,111.21 43.97,110.58 43.7,110.31 43.23,110.31 42.89,110.66 U7201.4
  TOP w0.381: AFTP7304.1 12.68,117 v1(12.68,118.45) 12.76,118.53 ED7315.1 11.95,120.4 11.19,119.64 10.37,119.64 v1(10.32,119.59) ; C7209.1 44.5,110.81 44.01,111.31 v1(43.87,111.31)
  L3 w0.102: 6.68,121.67 6.34,122 6.22,122.27 6.22,122.51 6.29,122.65 6.29,123.03 6.22,123.1 JUSB1.B5
  L3 w0.381: 6.68,121.67 7.8,121.67 9.88,119.59 v1(10.32,119.59)
  BOTTOM w0.381: v1(12.68,118.45) 12.96,118.18 16.93,118.18 18.63,119.87 23.21,119.87 23.75,119.33 24.77,119.33 24.87,119.23 26.94,119.23 27.81,120.09 28.58,120.09 29.71,118.96 29.71,118.7 30.68,117.73 35.12,117.73 37.03,115.83 38.12,115.83 39.18,114.76 39.18,114.12 39.97,113.34 42.34,113.34 43.87,111.8 v1(43.87,111.31)
USBCOMP: length 11.7
  TOP w0.305: R1603.1 122.51,105.62 122.51,107.34 v1(122.51,107.34)
  L3 w0.305: v1(116.43,104.16) 116.43,104.32 116.57,104.45 116.57,104.8 118.42,106.65 118.42,107.47 118.85,107.9 122.05,107.9 122.51,107.44 122.51,107.35 v1(122.51,107.34)
  BOTTOM w0.305: CPU1.CC5 v1(116.43,104.16)
V_SM_VREF_CNTA: length 143.7
  L3 w0.254: 36.25,62.13 36.25,59.99 34.11,57.85 33.96,57.85 33.63,57.52 33.63,57.06 33.07,56.49 33,56.49 31.58,55.07 31.58,53.65 29.04,51.11 29.04,50.62 29.05,50.6 29.05,50.04 28.74,49.72 28.74,49.71 27.31,48.28 27.31,44.95 27.31,44.32 29.32,42.3 51.73,42.3 53.29,40.74 72.57,40.74 v1(73.38,41.55)
  L3 w0.305: v1(56.55,89.49) 56.55,88.45 56.24,88.14 56.24,76.71 44.2,64.68 43.54,64.68 42.24,63.38 42.24,63.09 42.13,62.98 42.13,62.52 41.51,61.9 40.74,61.9 40.36,62.29 38.55,62.29 38.46,62.38 36.5,62.38 36.25,62.13
  BOTTOM w0.203: CPU1.F36 80.79,84.42 80.48,84.11 80.48,83.8 79.64,82.96 79.55,82.96 79.5,82.91 77.27,82.91 76.63,82.27
  BOTTOM w0.254: 76.63,82.27 76.63,82.24 73.98,79.58 73.94,79.58 73.41,79.05 65.41,79.05 62.92,81.54 62.92,86.91 60.34,89.49 v2(57.89,89.49) v1(56.55,89.49)
V_SM_VREF_CNTB: length 217.3
  TOP w0.254: v1(78.24,41.66) 78.84,42.27 88.75,42.27 89.44,42.95 95.85,42.95 96.13,43.23 97.6,43.23 98.63,44.26 98.63,44.95 100.77,47.09 100.98,47.09 100.99,47.1 102.26,47.1 102.27,47.09 102.58,47.09 104.77,44.91
  TOP w0.305: 104.77,44.91 105.38,44.91 107.17,43.12 109.72,43.12 112.5,40.34 119.71,40.34 119.79,40.42 119.85,40.42 122.28,42.85 137.54,42.85 138.18,42.22 144.32,42.22 144.68,42.57 C1323.1 144.71,42.78 145.27,42.75 R1305.2
  L3 w0.254: v1(60.17,90.95) 57.03,87.81 57.03,76.39 42.92,62.28 42.92,62.2 41.83,61.11 41.09,61.11 40.89,60.92 38.76,60.92 34.47,56.63 34.47,55.45 29.81,50.79 29.81,49.72 29.5,49.4 29.5,49.4 28.07,47.97 28.07,44.63 29.64,43.07 51.56,43.07 51.73,43.23 53.6,43.23 54.38,42.46 77.94,42.46 78.24,42.17 v1(78.24,41.66)
  BOTTOM w0.254: v1(60.17,90.95) 60.17,90.78 v2(61.78,89.17) 63.88,87.06 63.88,81.81 65.87,79.83 73.12,79.83 73.63,80.34 73.66,80.34 76.55,83.22 79.37,83.22 79.42,83.28 79.51,83.28 80.14,83.9 80.14,84.26 CPU1.E36
VCI_IN1#: length 2.9
  TOP w0.102: U2401.126 25.95,73 25.91,72.96 v1(25.91,72.81)
  BOTTOM w0.102: R2496.1 25.54,71.8 25.54,72.59 25.76,72.81 v1(25.91,72.81)
VCREF0: length 4.2
  TOP w0.102: v1(24.76,63.71) 24.79,63.68 24.79,63.04 24.64,62.89 U2401.25
  BOTTOM w0.102: v1(24.76,63.71) 24.76,63.67 24.62,63.53 R2448.1 C2409.1 23.11,63.53 22.93,63.7 R2424.1
VGA_DB_DET#: length 129.5
  TOP w0.089: R2059.2 198.63,62 AFTP5601.1 196.5,61.11 v1(196.5,61.08)
  L3 w0.089: v1(196.19,57.74) 192.14,57.74 190.59,56.19 180.75,56.19 180.24,56.7 178.52,56.7 176.15,56.7 v1(176.07,56.62) ; v1(166.34,40.7) 166.96,41.33 168.25,41.33 168.82,40.76 170.48,40.76 170.9,41.18 171.22,41.18 171.47,41.43 171.47,41.78 171.76,42.07 173.49,42.07 173.92,42.5 v1(173.92,42.93)
  L4 w0.089: v1(166.34,40.7) 166.52,40.88 166.52,49.58 158.84,57.27 158.68,57.27 152.7,63.24 152.7,63.7 149.81,66.6 149.81,67.54 140.69,76.66 139.84,76.66 139.53,76.97 139.53,77.33 139.67,77.47 139.67,78.46 140.33,79.12 140.33,79.26 140.66,79.59 140.66,80.27 140.81,80.41 140.81,81.41 140.03,82.19 140.03,82.79 137.55,85.26 136.95,85.26 133.12,89.09 132.32,89.09 v1(131.56,89.86)
  BOTTOM w0.089: v1(173.92,42.93) 174.68,43.69 174.68,45.41 173.96,46.13 173.64,46.13 173.28,46.48 173.28,47.39 174.77,48.88 174.77,54.65 176.1,55.97 176.1,56.59 v1(176.07,56.62) ; v1(196.19,57.74) 196.17,57.75 196,57.75 195.45,58.3 VGABD1.19 195.45,59.89 196.5,60.94 v1(196.5,61.08) ; CPU1.CR24 122.7,91.99 124.31,91.99 125.08,91.58 125.47,91.19 125.52,91.07 125.52,90.89 125.53,90.81 125.54,90.8 125.54,90.71 125.77,90.47 125.78,90.47 125.79,90.45 126.41,90.45 127.01,89.86 v1(131.56,89.86)
VR_CAP: length 2
  TOP w0.203: U2401.18 22.78,65.69 v1(22.67,65.81)
  BOTTOM w0.254: C2418.1 22.75,65.89 v1(22.67,65.81)
VR_EN: length 3.9
  BOTTOM w0.102: PU4601.40 136.47,142.42 137.01,142.96 137.47,142.96 137.76,143.25 v2(137.76,143.29) 137.42,143.63 137.42,144.1 137.93,144.6 R4002.2
VR_RDY: length 3
  BOTTOM w0.102: PR4609.2 137.16,144.11 TP4601.1 136.05,143 135.87,143 135.61,142.75 PU4601.39
VRALERT#: length 4.1
  BOTTOM w0.076: CPU1.CC36 116.16,84.48 116.16,84.3 116.24,84.15 116.25,84.14 116.26,84.11 116.26,83.84 116.05,83.63 116.05,82.77 116.63,82.19 116.63,81.55 TP1708.1
VRAM_ID1: length 21.9
  TOP w0.089: R2007.1 123.04,77.06 R2008.2 122.11,77.99 120.3,77.99 119.85,77.54 119.85,77.51 119.4,77.06 119.02,77.06 118.77,77.31 118.77,77.93 118.48,78.22 118.48,88.29 v2(118.49,88.3) 118.77,88.58 v1(118.98,88.58)
  BOTTOM w0.089: CPU1.CE27 117.11,90.68 118.54,90.68 118.93,90.3 118.93,88.65 118.95,88.63 118.95,88.61 v1(118.98,88.58)
