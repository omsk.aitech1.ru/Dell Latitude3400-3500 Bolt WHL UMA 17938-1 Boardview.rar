# Allegro board 17938-1.1228WZS1107.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
KSO7: length 78.6
  TOP w0.089: v1(32.95,62.02) 32.96,62.02 33.58,61.4 33.58,60.9 31.95,59.28 U2401.50 ; v1(63.46,34.51) 63.46,34.23 64.27,33.43 AFTP6552.1 65.05,30.71 64.93,30.58 RN2409.8
  L2SGND w0.089: v1(32.95,62.02) 32.39,61.46 32.39,60.35 30.2,58.15 30.2,55.05 30.46,54.79 30.46,53.44 28.89,51.87 28.41,51.87 27.21,50.67 27.21,48.91 26.91,48.61 26.91,45.63 30.54,42 30.54,40.36 31.09,39.81 31.1,39.8 31.31,39.58 31.31,36.58 31.78,36.12 31.78,34.35 33.36,32.77 34.61,32.77 36,31.38 37.93,31.38 37.93,31.37 41.18,31.37 41.53,31.02 53.02,31.02 53.44,31.44 60.75,31.44 62.18,32.88 62.18,33.77 62.92,34.51 v1(63.46,34.51)
  BOTTOM w0.089: KB1.19 63.12,34.88 63.46,34.53 v1(63.46,34.51)
KSO8: length 82.6
  TOP w0.089: RN2409.6 66.01,30.91 AFTP6554.1 66.53,31.43 66.53,32.56 v1(65.37,33.72) ; v1(30.72,61.68) 30.72,60.92 30.36,60.55 U2401.46
  L2SGND w0.089: v1(65.37,33.72) 65.37,32.79 62.6,30.02 54.03,30.02 53.61,29.59 43.08,29.59 42.7,29.22 38.08,29.22 37.34,29.96 35.41,29.96 34.06,31.3 31.44,31.3 29.92,32.82 29.63,32.82 28.89,33.56 28.89,36 29.08,36.19 29.08,41.45 25.48,45.04 25.48,49.19 25.79,49.5 25.79,51.64 27.22,53.07 27.22,53.57 27.28,53.7 27.82,54.25 28.18,54.25 28.75,54.82 28.75,58.85 30.72,60.83 v1(30.72,61.68)
  BOTTOM w0.089: v1(65.37,33.72) 64.72,34.37 KB1.17
KSO9: length 78.2
  TOP w0.089: R2449.2 73.05,33.76 v1(73.08,33.73) AFTP6563.1 73.7,32.31 73.7,30.7 R2450.1 ; U2401.68 37.65,61.29 37.62,61.32 v1(37.39,61.32)
  L2SGND w0.089: v1(37.39,61.32) 37.39,60.73 34.6,57.93 34.6,57.17 34.32,56.9 34.32,54.06 33.41,53.15 33.41,52.3 33.23,52.12 33.23,43.76 36.08,40.91 36.08,38.19 35.62,37.73 35.62,35.29 37.05,33.87 42.2,33.87 42.53,33.54 52.02,33.54 52.41,33.93 54.68,33.93 56.11,35.36 62.03,35.36 62.49,35.82 69.36,35.82 70.18,35 71.81,35 v1(73.08,33.73)
  BOTTOM w0.089: v1(73.08,33.73) 72.72,34.09 KB1.7
KSO10: length 82.1
  TOP w0.089: v1(74.53,33.71) 75.52,32.72 75.52,30.35 75.97,29.9 AFTP6566.1 75.42,29.54 75.16,29.8 RN2411.3 ; v1(37.87,63.14) 37.88,63.14 38.13,62.89 U2401.72
  L2SGND w0.089: v1(74.53,33.71) 72.88,35.36 70.33,35.36 69.51,36.18 62.35,36.18 61.88,35.71 55.93,35.71 54.54,34.32 52.29,34.32 51.87,33.89 42.69,33.89 42.36,34.22 37.2,34.22 35.98,35.44 35.98,37.59 36.44,38.04 36.44,41.11 33.59,43.96 33.59,51.96 33.7,52.07 33.7,52.08 33.77,52.14 33.77,53 34.68,53.92 34.68,56.75 34.95,57.02 34.95,57.32 34.95,57.78 38.5,61.33 38.5,62.52 v1(37.87,63.14)
  BOTTOM w0.089: KB1.5 74.32,35 74.1,34.78 74.1,34.13 v1(74.53,33.71)
KSO11: length 81.6
  TOP w0.089: v1(73.79,33.71) 75.01,32.49 AFTP6565.1 74.83,31.19 73.9,30.26 RN2411.4 ; v1(37,63.15) 37,63.19 37.6,63.8 38.29,63.8 38.39,63.69 U2401.74
  L2SGND w0.089: v1(73.79,33.71) 72.32,35.18 70.25,35.18 69.43,36 62.42,36 61.96,35.54 56.04,35.54 54.64,34.14 52.37,34.14 51.94,33.71 42.62,33.71 42.29,34.05 37.12,34.05 35.8,35.37 35.8,37.66 36.26,38.12 36.26,41.04 33.41,43.89 33.41,52.04 33.59,52.22 33.59,53.08 34.5,53.99 34.5,56.82 34.78,57.1 34.78,57.86 38.33,61.41 38.33,62.03 37.2,63.15 v1(37,63.15)
  BOTTOM w0.089: v1(73.79,33.71) 73.52,33.98 KB1.6
KSO12: length 83.9
  TOP w0.089: AFTP6559.1 67.87,34.19 v1(68.35,33.71) 68.94,33.12 69.56,33.12 69.85,32.84 69.85,31.39 68.55,30.1 RN2412.6 ; U2401.75 37.59,64.09 v1(36.91,64.77)
  L2SGND w0.089: v1(36.91,64.77) 36.56,65.12 35.23,65.12 34.99,64.87 34.99,62.1 35.5,61.58 35.5,60.2 33.85,58.55 33.31,58.55 32.25,57.5 32.25,56.85 33.44,55.67 33.44,54.43 32.52,53.52 32.52,52.68 31.55,51.7 31.55,47.1 31.59,47.06 31.59,45.83 31.66,45.76 31.66,44.08 35.19,40.55 35.19,38.56 34.73,38.1 34.73,34.93 36.68,32.98 41.83,32.98 42.16,32.65 52.38,32.65 52.78,33.04 56.41,33.04 57.84,34.47 62.46,34.47 62.92,34.93 67.13,34.93 v1(68.35,33.71)
  BOTTOM w0.089: v1(68.35,33.71) 68.72,34.07 KB1.12
KSO13: length 81.4
  TOP w0.089: U2401.76 38.23,64.49 v1(37.95,64.77) ; RN2410.7 70.62,30.29 72.06,31.73 AFTP6562.1 71.55,32.82 70.92,33.45 v1(70.92,33.76)
  L2SGND w0.089: v1(70.92,33.76) 69.21,35.47 62.67,35.47 62.21,35 56.34,35 54.91,33.57 52.56,33.57 52.16,33.18 42.38,33.18 42.05,33.51 36.9,33.51 35.27,35.15 35.27,37.88 35.73,38.34 35.73,40.77 32.19,44.3 32.19,45.98 32.12,46.05 32.12,47.28 32.08,47.32 32.08,51.47 32.93,52.32 32.99,52.38 32.99,52.38 33.06,52.45 33.06,53.3 33.97,54.21 33.97,56.7 33.57,57.1 33.57,57.6 33.92,57.95 34,57.95 36.04,59.98 36.04,61.86 35.72,62.18 35.72,63.45 36.08,63.8 37.04,63.8 37.95,64.71 v1(37.95,64.77)
  BOTTOM w0.089: KB1.9 71.12,33.96 v1(70.92,33.76)
KSO14: length 84.3
  TOP w0.089: RN2410.6 71.12,30.1 72.47,31.45 72.47,32.95 v1(71.64,33.77) 71.71,33.84 AFTP6564.1 ; v1(40.01,65.66) 40.01,65.35 39.55,64.89 U2401.77
  L2SGND w0.089: v1(40.01,65.66) 37.97,63.62 36.15,63.62 35.9,63.37 35.9,62.25 36.22,61.94 36.22,59.91 34.08,57.77 34,57.77 33.75,57.52 33.75,57.17 34.15,56.77 34.15,54.14 33.23,53.23 33.23,52.37 33.11,52.24 33.05,52.19 33.05,43.69 35.9,40.84 35.9,38.27 35.44,37.81 35.44,35.22 36.98,33.69 42.13,33.69 42.46,33.36 52.09,33.36 52.48,33.75 54.76,33.75 56.19,35.18 62.1,35.18 62.57,35.64 69.29,35.64 70.23,34.7 70.72,34.7 v1(71.64,33.77)
  BOTTOM w0.089: v1(71.64,33.77) 71.92,34.05 KB1.8
KSO15: length 87
  TOP w0.089: RN2410.8 70.03,30.03 71.3,31.3 71.3,32.59 v1(70.16,33.73) 69.79,34.1 AFTP6561.1 ; v1(37.21,67.92) 37.79,68.49 U2401.86
  L2SGND w0.089: v1(70.16,33.73) 68.6,35.29 62.75,35.29 62.28,34.82 57.66,34.82 56.23,33.4 52.63,33.4 52.24,33 42.31,33 41.98,33.33 36.83,33.33 35.09,35.07 35.09,37.95 35.55,38.41 35.55,40.69 32.01,44.23 32.01,45.91 31.94,45.98 31.94,47.21 31.91,47.25 31.91,51.55 32.87,52.52 32.88,52.52 32.88,53.37 33.79,54.29 33.79,55.81 32.61,57 32.61,57.35 33.39,58.13 33.93,58.13 35.86,60.06 35.86,61.73 35.54,62.05 35.54,63.52 36.07,64.04 37.03,64.04 37.51,64.52 37.51,64.94 38.12,65.54 38.12,66.37 37.49,67 37.49,67.64 v1(37.21,67.92)
  BOTTOM w0.089: KB1.10 70.32,33.89 v1(70.16,33.73)
KSO16: length 90.6
  TOP w0.089: RN2412.5 69.14,30.15 70.2,31.21 AFTP6560.1 70.74,32.35 70.18,32.91 70.18,32.92 70.12,32.98 69.57,33.68 v1(69.09,33.73) ; v1(37.05,67.31) 36.78,67.57 36.78,68.39 36.78,68.4 36.78,68.44 35.52,69.7 35.52,70.56 36.02,71.07 38.18,71.07 38.36,70.89 U2401.92
  L2SGND w0.089: v1(69.09,33.73) 67.71,35.11 62.85,35.11 62.39,34.65 57.76,34.65 56.33,33.22 52.7,33.22 52.31,32.82 42.24,32.82 41.9,33.16 36.75,33.16 34.91,35 34.91,38.03 35.37,38.49 35.37,40.62 31.84,44.15 31.84,45.84 31.77,45.91 31.77,47.13 31.73,47.17 31.73,51.63 32.7,52.6 32.7,53.45 33.61,54.36 33.61,55.74 32.43,56.92 32.43,57.42 33.38,58.38 33.93,58.38 35.68,60.13 35.68,61.66 35.37,61.97 35.37,63.59 35.99,64.22 36.96,64.22 37.33,64.59 37.33,65.83 37.27,65.89 37.27,67.08 v1(37.05,67.31)
  BOTTOM w0.089: KB1.11 69.52,34.16 v1(69.09,33.73)
L_BKLT_CTRL: length 82.2
  L3 w0.102: v1(118.9,100.15) 119.57,100.82 121.36,100.82 122.88,102.33 122.88,102.33 123.78,103.23 123.78,103.66 124.73,104.61 135.18,104.61 154.77,85.03 154.77,81.16 163.6,72.33 v1(163.6,72.14)
  BOTTOM w0.102: D5503.1 179.05,69.39 v2(179.05,69.57) 178.62,69.57 177.55,70.64 176.48,70.64 173.71,73.41 164.39,73.41 163.6,72.61 v1(163.6,72.14) ; v1(118.9,100.15) 118.88,100.22 118.82,100.24 CPU1.CH11
L_BKLT_EN: length 333.8
  TOP w0.089: R2427.2 40.25,63.69 R2435.2 40.77,63.22 v1(40.97,63.42) ; v1(211.26,55.61) 210,55.61 209.39,55 209.39,54.65 v2(209.89,54.15) R2436.1 211.56,53.65 R2438.2
  L3 w0.089: v1(104.27,43.36) 103.84,43.78 103.43,43.78 103.13,43.48 101.65,43.48 100.92,42.74 99.67,42.74 97.19,40.27 84.7,40.27 84.46,40.03 75.04,40.03 70.95,35.94 62.31,35.94 60.92,34.55 58.09,34.55 56.64,33.1 36.45,33.1 33.7,35.86 29.42,35.86 27.17,38.11 27.17,38.46 25.26,40.37 25.26,42.24 25.22,42.28 25.22,48.29 26.69,49.76 26.69,51.9 28.7,53.91 28.7,54.17 29.18,54.66 29.18,57.3 32.37,60.48 32.37,62.04 32.77,62.45 33.48,62.45 34.84,63.8 40.59,63.8 v1(40.97,63.42) ; v1(211.26,55.61) 210.65,56.22 210.63,56.22 208.75,58.09 207.88,58.09 207.11,58.86 203.97,58.86 203.63,59.2 192.43,59.2 190.25,57.02 181.09,57.02 180.58,57.53 178.87,57.53 178.87,57.53 178.14,57.53 176.25,59.41 v1(175.83,59.41) 174.62,59.41 168.32,65.71 168.32,66.66 162.6,72.38 162.6,72.91 154.47,81.04 154.47,81.54 154.47,83.54 153.47,84.53 153.47,85.43 149.85,89.05 149.34,89.05 137.7,100.69 137.7,101.55 134.94,104.31 127.4,104.31 125.6,102.51 124.86,102.51 124.5,102.15 122.95,102.15 121.02,100.22 v1(120.37,100.22)
  BOTTOM w0.089: v1(175.83,59.41) 175.62,59.2 175.62,56.63 175.48,56.49 168.86,56.49 167.28,54.91 166.42,54.91 165.08,53.57 164.5,53.57 160.7,53.57 158.03,53.57 157.2,52.74 147.15,52.74 146.72,53.17 144.72,53.17 144.27,53.62 111.6,53.62 111.58,53.6 111.57,53.6 110.76,52.78 110.38,52.78 110.34,52.74 105.07,52.74 103.36,51.03 103.36,46.7 103.81,46.25 103.81,46.22 103.82,46.22 103.82,43.81 v1(104.27,43.36) ; v1(120.37,100.22) 120.34,100.22 120.26,100.23 CPU1.CK11
L_BKLT_EN_L: length 56.2
  TOP w0.102: R2427.1 41.1,64.31 41.1,64.11 41.46,63.76 41.46,62.77 v1(41.25,62.57)
  L3 w0.102: v1(23.42,40.13) 23.42,40.84 21.82,42.44 21.82,43.47 19.84,45.46 19.84,49.2 20.68,50.04 20.68,51 20.68,51.99 20.87,52.17 20.87,52.19 20.9,52.22 20.9,55.89 20.75,56.04 20.75,57.41 20.48,57.68 20.48,59.69 20.37,59.8 20.37,60.67 20.37,60.67 20.37,60.82 20.35,60.84 20.35,61.36 20.37,61.38 20.37,63.63 21.97,65.24 21.97,65.25 22,65.27 22,66.16 22.53,66.69 22.53,67.78 v1(22.63,67.88)
  BOTTOM w0.102: v1(22.63,67.88) 22.86,67.65 25.17,67.65 25.76,67.06 26.16,67.06 27.82,65.4 31.34,65.4 32.26,64.48 33.93,64.48 35.9,62.51 40.97,62.51 41.02,62.57 v1(41.25,62.57) ; v2(23.68,40.78) v1(23.42,40.13) 22.75,39.46 D2401.2
LAN_CABLE_DETECT_R_#: length 3.3
  TOP w0.102: R3104.1 v2(48.29,87.25) 48.29,86.98 47.09,85.78 U3101.26
LAN_CLK_CPU_N: length 102.7
  TOP w0.127: v1(50.58,75.67) 50.58,76.09 50.45,76.23 50.17,76.23 49.87,75.93 49.69,75.93 47.81,77.81 47.81,80.54 47.42,80.93 47.42,81.08 47.49,81.15 U3101.16
  L4 w0.114: v1(50.58,75.67) 50.84,75.41 51.14,75.41 51.4,75.67 51.4,75.96 60.73,85.29 60.73,89.45 61.32,90.03 61.32,90.2 61.33,90.21 61.33,93.14 61.78,93.59 61.78,96.25 64.33,98.81 64.33,100.84 64.58,101.09 65.5,101.09 65.61,101.21 65.61,101.43 65.5,101.55 64.58,101.55 64.33,101.8 64.33,102.21 64.58,102.46 65.5,102.46 65.61,102.58 65.61,102.81 65.5,102.92 64.58,102.92 64.33,103.17 64.33,103.59 64.58,103.83 65.27,103.83 65.38,103.95 65.38,104.18 65.27,104.29 64.58,104.29 64.33,104.54 64.33,108.47 68.53,112.67 71.09,112.67 71.33,112.42 71.33,111.11 71.45,111 71.68,111 71.79,111.11 71.79,112.42 72.04,112.67 75.26,112.67 75.84,112.09 100.73,112.09 102.34,110.49 v1(102.65,110.49)
  BOTTOM w0.127: CPU1.BD3 103.91,105.75 104.14,105.97 104.14,107.01 103.88,107.26 103.88,108.62 103.43,109.07 103.43,109.71 v1(102.65,110.49)
LAN_CLK_CPU_P: length 102.7
  TOP w0.127: v1(50.09,75.18) 47.56,77.71 47.56,80.44 47.18,80.83 47.18,81.09 47.09,81.18 U3101.15
  L4 w0.114: v1(102.65,109.85) 100.64,111.86 75.75,111.86 75.17,112.44 72.13,112.44 72.02,112.33 72.02,111.02 71.77,110.77 71.35,110.77 71.1,111.02 71.1,112.33 70.99,112.44 68.62,112.44 64.56,108.38 64.56,104.63 64.67,104.52 65.36,104.52 65.61,104.27 65.61,103.85 65.36,103.61 64.67,103.61 64.56,103.49 64.56,103.26 64.67,103.15 65.59,103.15 65.84,102.9 65.84,102.48 65.59,102.23 64.67,102.23 64.56,102.12 64.56,101.89 64.67,101.78 65.59,101.78 65.84,101.53 65.84,101.11 65.59,100.86 64.67,100.86 64.56,100.75 64.56,98.71 62,96.16 62,93.5 61.55,93.05 61.55,90.11 61.55,90.11 61.55,89.94 60.96,89.35 60.96,85.2 51.62,75.86 51.62,75.58 51.23,75.18 v1(50.09,75.18)
  BOTTOM w0.127: v1(102.65,109.85) 102.94,109.85 103.18,109.61 103.18,108.97 103.64,108.52 103.64,107.16 103.89,106.91 103.89,106.07 103.35,105.53 CPU1.BC3
LAN_LED0: length 55.4
  TOP w0.203: R3203.1 19.59,60.55 v1(19.14,60.1) 18.48,60.1 18.07,59.68 18.07,59.11 Q3201.S ; v1(46.74,86.31) 46.69,86.26 U3101.27
  L2SGND w0.203: v1(42.25,79.38) 42.15,79.28 42.15,79.08 41.79,78.72 40.84,78.72 38.15,76.02 37.64,76 35.74,76 35.25,75.51 31.97,75.51 31.95,75.53 31.55,75.53 31.51,75.49 23.32,75.49 23.21,75.6 21.02,75.6 20.22,74.8 20.22,74.16 20.58,73.79 20.58,72.56 20.42,72.41 20.42,72.34 20.13,72.04 20.13,71.18 20.58,70.72 20.58,68.78 20.34,68.54 20.31,68.54 19.9,68.13 19.9,66.67 17.93,64.69 17.93,62.59 18.95,61.57 18.95,60.34 19.14,60.15 v1(19.14,60.1)
  L4 w0.203: v1(42.25,79.38) 42.27,79.4 42.29,79.4 42.57,79.68 42.57,81.94 43.01,82.37 43.41,82.37 44.07,83.03 44.07,84 45.57,85.5 45.93,85.5 v1(46.74,86.31)
  BOTTOM w0.203: v2(46.33,86.69) 46.71,86.31 v1(46.74,86.31)
LAN_LED0_Q: length 3.4
  TOP w0.203: v2(15.65,60.4) 15.93,60.4 16.2,60.68 R3202.1 16.58,60.66 16.6,60.65 16.66,60.65 17.72,60.65 Q3201.D 18.12,60.71 R3203.2
LAN_LED0_R: length 9.4
  TOP w0.203: v1(10.59,64.82) 12.05,64.82 15.07,61.8 15.57,61.8 v2(15.66,61.71) 15.83,61.54 R3202.2
  BOTTOM w0.203: LED2.K 9.91,66.45 10.42,65.94 10.42,65 v1(10.59,64.82)
LAN_MDI0_N: length 10.5
  TOP w0.089: v1(43.11,84.78) 43.12,84.78 43.28,84.94 43.46,84.94 43.55,84.85 43.88,84.54 U3101.2
  BOTTOM w0.089: 39.32,86.09 39.32,85.45 39.84,84.93 ED3201.9 ED3201.2 41.55,84.93 41.65,85.03 42.86,85.03 v1(43.11,84.78) ; 39.32,86.09 v2(39.16,86.09) ; 39.32,86.09 39.32,88.16 39.12,88.36 38.83,88.36 38.7,88.23 38.7,87.89 38.61,87.8 XF3202.8
LAN_MDI0_P: length 10.2
  TOP w0.089: v1(43.09,85.41) 43.3,85.41 43.77,84.94 U3101.1
  BOTTOM w0.089: 39.54,88.14 v2(39.7,88.14) ; 39.54,88.14 39.54,88.25 39.21,88.58 38.82,88.58 38.7,88.71 38.7,88.98 38.61,89.07 XF3202.7 ; 39.54,88.14 39.54,85.54 39.67,85.41 ED3201.10 ED3201.1 41.54,85.41 41.7,85.24 42.92,85.24 v1(43.09,85.41)
LAN_MDI1_N: length 9.5
  TOP w0.089: U3101.5 43.53,83.34 v1(43.31,83.11)
  BOTTOM w0.089: 42.18,83.31 41.76,83.31 41.66,83.41 ED3201.5 ED3201.6 39.93,83.41 39.71,83.19 39.71,81.12 39.2,80.61 38.78,80.61 38.7,80.52 38.7,80.27 38.61,80.18 XF3202.12 ; 42.18,83.31 42.86,83.31 42.89,83.31 43.09,83.11 v1(43.31,83.11) ; 42.18,83.31 v2(42.18,83.14)
LAN_MDI1_P: length 10
  TOP w0.089: U3101.4 43.77,83.74 43.59,83.55 43.2,83.55 v1(43.06,83.7)
  BOTTOM w0.089: XF3202.11 38.61,81.45 38.7,81.36 38.7,80.95 38.82,80.82 39.11,80.82 39.3,81.01 ; v1(43.06,83.7) 42.88,83.52 41.86,83.52 41.5,83.89 ED3201.4 ED3201.7 40.1,83.89 39.5,83.28 39.5,81.21 39.3,81.01 ; v2(39.18,81.13) 39.3,81.01
LAN_MDI2_N: length 17.8
  TOP w0.089: v2(39.05,85.2) 39.16,85.31 ; 39.16,85.31 39.04,85.42 39.04,89.48 38.65,89.88 36.54,89.88 36.19,89.53 36.19,88.72 36.32,88.59 36.65,88.59 37.13,89.07 XF3201.12 ; 39.16,85.31 39.46,85 39.78,85 39.84,84.94 ED3202.2 ED3202.9 41.9,84.94 42.03,84.81 42.03,82.64 42.57,82.09 43.33,82.09 43.77,82.54 U3101.7
LAN_MDI2_P: length 18.8
  TOP w0.089: 39.26,87.19 39.26,85.51 39.55,85.22 39.66,85.22 39.86,85.42 ED3202.1 ED3202.10 41.37,85.42 41.64,85.16 41.99,85.16 42.24,84.9 42.24,82.73 42.66,82.31 43.24,82.31 43.87,82.94 U3101.6 ; 39.26,87.19 39.26,89.57 38.74,90.1 36.45,90.1 35.97,89.62 35.97,88.63 36.23,88.37 36.62,88.37 37.19,87.8 XF3201.11 ; 39.26,87.19 v2(39.41,87.19)
LAN_MDI3_N: length 19.1
  TOP w0.089: 39.2,82.15 39.2,83.29 39.44,83.54 39.8,83.54 39.92,83.42 ED3202.5 ED3202.6 41.3,83.42 41.54,83.17 41.54,82.44 42.23,81.75 42.23,81.12 43.04,80.3 44.53,80.3 44.91,80.68 44.91,81.06 45.09,81.24 U3101.10 ; 39.2,82.15 39.2,81.6 38.99,81.39 38.99,79.78 38.57,79.36 36.24,79.36 35.98,79.62 35.98,80.56 36.22,80.79 36.45,80.79 37.11,81.45 XF3201.8 ; 39.2,82.15 v2(39.36,82.15)
LAN_MDI3_P: length 18.1
  TOP w0.089: XF3201.7 37.11,80.18 36.72,80.58 36.31,80.58 36.2,80.47 36.2,79.71 36.33,79.58 38.48,79.58 38.77,79.87 38.77,81.48 38.98,81.69 38.98,83.2 38.98,83.38 39.17,83.57 ; 39.17,83.57 39.35,83.75 39.77,83.75 39.91,83.9 ED3202.4 ED3202.7 41.32,83.9 41.76,83.46 41.76,82.53 42.45,81.84 42.45,81.21 43.13,80.52 44.44,80.52 44.69,80.77 U3101.9 ; 39.17,83.57 v2(39.04,83.69)
LAN_PCIE_RX_C_N: length 3.1
  TOP w0.127: C3107.2 48.89,80.42 48.89,82.03 48.38,82.54 U3101.18
LAN_PCIE_RX_C_P: length 2.6
  TOP w0.127: U3101.17 48.44,82.14 48.64,81.93 48.64,80.45 C3102.2
LAN_PCIE_RX_N: length 108.5
  TOP w0.127: C3107.1 49.04,79.2 48.73,78.89 48.73,78.75 48.89,78.58 49.59,78.58 50.13,79.12 50.13,80.77 50.41,81.05 50.41,84.46 50.59,84.63 50.59,86.04 50.84,86.29 51.55,86.29 v1(51.71,86.45)
  L3 w0.114: v1(110.94,103.6) 110.94,103.6 110.94,103.91 111.07,104.04 111.25,104.04 111.44,103.85 111.44,103.29 111.5,103.23 111.97,103.23 112.21,103.47 112.21,104.9 111.61,105.5 111.61,107.28 112.04,107.72 112.04,112.02 111.36,112.7 111.36,114.18 110.35,115.18 109.83,115.18 108.44,116.57 102.77,116.57 101.75,117.59 71.36,117.59 62.55,108.79 62.55,107.73 60.95,106.12 60.95,100.25 55.92,95.23 53.9,95.23 51.01,92.33 51.01,90.33 51.9,89.44 51.9,88.33 51.26,87.7 51.26,86.57 51.39,86.45 v1(51.71,86.45)
  BOTTOM w0.127: v1(110.94,103.6) 110.94,103.79 110.82,103.92 CPU1.BP5
LAN_PCIE_RX_P: length 108.9
  TOP w0.127: v1(51.46,85.83) 51.24,86.05 50.94,86.05 50.83,85.94 50.83,84.53 50.65,84.36 50.65,80.95 50.37,80.67 50.37,79.02 49.69,78.34 48.79,78.34 48.49,78.65 48.49,79.05 C3102.1
  L3 w0.114: v1(51.46,85.83) 51.03,86.26 51.03,87.79 51.67,88.43 51.67,89.35 50.78,90.24 50.78,92.43 53.81,95.45 55.82,95.45 60.72,100.35 60.72,106.22 62.32,107.82 62.32,108.88 71.26,117.82 101.84,117.82 102.86,116.8 108.54,116.8 109.93,115.41 110.45,115.41 110.58,115.28 111.59,114.27 111.59,112.8 112.27,112.11 112.27,107.62 111.84,107.19 111.84,105.6 112.44,105 112.44,103.38 112.06,103 110.99,103 v1(110.94,102.95)
  BOTTOM w0.127: v1(110.94,102.95) CPU1.BP6
LAN_PCIE_TX_N: length 112.2
  TOP w0.127: v1(44.85,78.81) 46.63,78.81 C3109.1
  L4 w0.114: v1(44.85,78.81) 45.68,78.81 48.71,81.84 49.65,81.84 53.55,85.73 53.55,92.25 53.11,92.68 53.11,96.09 58.42,101.39 58.42,106.88 58.79,107.26 58.79,110.64 67.32,119.17 72.79,119.17 73.52,119.89 106.21,119.89 110.75,115.35 110.75,114.1 110.75,113.85 110.75,113.3 110.53,113.08 v1(110.26,113.08)
  BOTTOM w0.127: v1(110.26,113.08) 110.85,113.08 111.32,113.55 111.91,113.55 112.4,113.07 112.4,107.7 111.47,106.77 111.47,106.38 111.2,106.11 110.82,106.11 CPU1.BR2
LAN_PCIE_TX_N_C: length 1.6
  TOP w0.127: C3109.2 46.69,80.49 U3101.14
LAN_PCIE_TX_P: length 112.3
  TOP w0.127: v1(44.85,79.45) 45.25,79.06 46.11,79.06 C3104.1
  L4 w0.114: v1(44.85,79.45) 45.26,79.04 45.59,79.04 48.61,82.07 49.56,82.07 53.32,85.83 53.32,92.15 53.17,92.3 52.89,92.58 52.89,96.18 58.19,101.49 58.19,106.98 58.56,107.35 58.56,110.73 67.23,119.39 72.7,119.39 73.42,120.12 106.3,120.12 110.98,115.44 110.98,114.1 110.98,113.67 110.98,113.21 110.77,113 110.77,112.71 110.51,112.45 v1(110.26,112.45)
  BOTTOM w0.127: CPU1.BR1 110.67,106.48 110.8,106.35 111.1,106.35 111.23,106.48 111.23,106.87 112.16,107.8 112.16,112.97 111.81,113.31 111.42,113.31 110.96,112.84 110.66,112.84 v1(110.26,112.45)
LAN_PCIE_TX_P_C: length 1.6
  TOP w0.127: U3101.13 46.29,81.14 46.45,80.98 46.45,80.31 C3104.2
LAN_WAKE#: length 38.5
  L3 w0.089: v1(131.22,77.55) 131.1,77.67 128.9,77.67 128.78,77.54 128.32,77.54 127.95,77.17 126.66,77.17 122.99,80.84 122.78,80.84 122.77,80.83 121.53,80.83 121.31,80.61 120.2,80.61 120.17,80.64 115.95,80.64 115.68,80.91 114.63,80.91 114.32,81.22 114.32,81.22 114.17,81.36 114.01,81.36 113.94,81.44 113.48,81.44 113.3,81.26 112.85,81.26 v1(112.25,81.87)
  BOTTOM w0.076: CPU1.BU32 111.91,86.79 111.91,85.85 111.92,85.81 111.92,85.44 111.88,85.4 111.88,84.37
  BOTTOM w0.089: v1(131.22,77.55) 131.74,78.07 132.12,78.07 132.59,78.54 133.03,78.54 133.34,78.23 133.34,78.23 133.35,78.22 133.35,78.22 133.6,77.97 133.6,77.97 134.7,76.88 137.91,76.88 138.16,77.13 138.16,77.48 137.96,77.68 137.96,78.41 v2(138.2,78.65) 138.56,79.01 138.56,79.77 R1707.2 ; v1(112.25,81.87) 112.25,81.89 112.04,82.09 112.04,83.47 111.71,83.8 111.71,84.06 111.88,84.37
LANWAKE#: length 250
  TOP w0.102: R2428.2 138.32,77.02 138.04,77.3 v1(137.73,77.3) ; U2401.35 25.95,57.96 25.86,57.86 24.98,57.86 24.88,57.96 24.88,58.38 24.19,59.07 20.85,59.07 19.84,58.06 v2(19.84,57.87) 19.55,57.57 18.31,57.57 18.1,57.78 18.1,58.33 17.12,59.31 v1(16.13,59.31)
  L4 w0.102: v1(137.73,77.3) 138.05,77.3 138.22,77.14 138.22,76.42 139.29,75.35 140.15,75.35 148.5,67 148.5,66.05 151.27,63.28 151.27,62.81 158.12,55.96 158.29,55.96 163.21,51.04 163.21,44.15 159.75,40.69 159.75,40.08 159.04,39.37 156.57,39.37 156.54,39.34 151.02,39.34 149.15,41.21 132.83,41.21 132.16,40.54 128.82,40.54 128.05,41.31 124.37,41.31 121.87,43.81 121.56,44.12 109.62,44.12 107.82,42.32 102.7,42.32 102.26,42.32 102.18,42.24 100.41,42.24 100.18,42.01 98.75,42.01 96.79,40.05 94.86,40.05 94.8,40.11 91.08,40.11 90.81,39.84 82.05,39.84 81.88,39.68 74.17,39.68 74.16,39.67 72.6,39.67 72.6,39.68 65.36,39.68 64.98,39.3 58.51,39.3 57.42,38.21 56.48,38.21 56.04,37.77 55.81,37.77 51.63,33.59 38.96,33.59 32.69,27.32 28.82,27.32 27.49,25.99 22.04,25.99 16.96,31.06 16.96,34.72 16.68,35 16.68,38.36 16.34,38.7 16.34,38.71 16.31,38.74 16.31,38.92 14.58,40.65 14.58,47.79 15,48.21 15,49.54 15.03,49.57 15.85,50.39 15.85,52.09 16.47,52.7 16.47,58.27 16.65,58.45 16.65,59.05 16.39,59.31 v1(16.13,59.31)
LANXIN: length 5.9
  TOP w0.114: X3101.1 45.9,89.71 45.34,89.16 45.34,87.56 45.42,87.48 46.12,87.48 46.5,87.1 C3125.1 46.5,86.71 46.29,86.5 U3101.28
LANXOUT: length 4.1
  TOP w0.114: U3101.29 45.89,85.97 46.01,86.09 46.01,86.62 45.68,86.95 44.76,86.95 C3116.1 44.66,87.6 X3101.3
LCD_BRIGHTNESS: length 11.2
  TOP w0.102: v1(220.19,40.31) 220.29,40.31 221.38,39.22 223.14,39.22 224.56,37.8 225.4,37.8 AFTP5519.1 225.45,37.49 225.33,37.36 224.89,37.36 224.42,36.89 RN5503.7
  BOTTOM w0.102: v1(220.19,40.31) 220.19,40.33 220.3,40.44 220.3,41.78 220.03,42.05 LCD1.31
LCD_CBL_DET#: length 136.7
  TOP w0.089: R2060.2 138.04,91.85 v1(137.92,91.97)
  L3 w0.089: v1(209.02,46.82) 208.57,47.27 208.57,48.28 208.64,48.35 208.64,49.14 208.53,49.24 208.53,50.63 208.8,50.9 209.16,50.9 209.3,50.76 209.69,50.76 209.93,51.01 209.93,52.35 207.82,54.46 206.93,54.46 205.8,55.6 205.66,55.6 204.65,55.6 204.58,55.52 201.78,55.52 201.47,55.21 192.96,55.21 191.63,53.88 179.76,53.88 179.76,53.88 179.48,54.15 179.25,54.39 177.57,54.39 177.42,54.39 177.35,54.33 177.35,54.33 177.12,54.1 177.11,54.1 176.77,53.76 173.98,53.76 173.88,53.86 173.77,53.96 158.17,69.57 158.17,70.91 153.06,76.03 152.21,76.03 152.04,76.19 152.03,76.19 148.83,79.39 148.83,81.47 146.18,84.12 146.18,84.98 144.82,86.34 143.78,86.34 142.7,87.42 142.7,88.44 142.69,88.46 142.69,88.66 139.38,91.97 v1(137.92,91.97)
  L4 w0.089: v1(120.2,98.05) 123.23,98.05 124.68,96.6 128.53,96.6 129.47,97.54 129.47,97.89 129.72,98.15 130.15,98.15 132.29,96.01 132.57,96.01 136.42,92.17 137.72,92.17 v1(137.92,91.97)
  BOTTOM w0.089: LCD1.29 217.85,43.05 216.87,44.03 216.87,44.54 216.87,44.76 216.21,45.42 AFTP5517.1 215.75,45.46 215.23,45.98 211.91,45.98 211.7,46.19 209.71,46.19 209.08,46.82 v1(209.02,46.82) ; v1(120.2,98.05) 120.74,98.05 121.08,98.39 CPU1.CN14
LCD_TST: length 280.2
  TOP w0.089: RN5503.1 222.62,37.48 221.8,38.3 220.58,38.3 220.22,38.66 v1(220.22,38.81) ; v1(191.63,36.83) 191.6,36.8 191.6,36.11 191.09,35.59 190.29,35.59 189.79,36.09 184.82,36.09 182.67,33.94 181.14,33.94 180.76,33.56 176.58,33.56 171.43,38.71 v2(171.1,38.71) v1(170.06,38.71) ; v1(159.67,65.66) 159.64,65.63 159.24,65.63 v1(158.27,64.67) ; U2401.26 23.01,62.49 22.74,62.76 22.74,62.82 v1(22.72,62.84)
  L2SGND w0.089: v1(158.27,64.67) 158.27,64.65 164.55,58.38 165.67,58.38 173.25,50.79 175.35,50.79 176.25,49.89 176.25,41.85 174.76,40.36 171,40.36 170.06,39.42 v1(170.06,38.71)
  L3 w0.089: v1(220.22,38.81) 220.14,38.74 213.73,38.74 213.21,38.22 209.06,38.22 208.48,37.63 207.88,37.63 207.65,37.87 202.03,37.87 200.28,36.13 192.12,36.13 191.65,36.6 191.65,36.81 191.63,36.83 v1(191.63,36.83)
  L4 w0.089: v1(22.72,62.84) 22.77,62.84 23.14,63.22 23.14,66.05 24.74,67.65 24.74,68.16 24.75,68.17 v1(24.75,68.48)
  BOTTOM w0.089: v1(158.27,64.67) 158.03,64.43 156.4,64.43 154.48,62.51 148.55,62.51 148.34,62.51 145.79,65.06 144.49,65.06 143.77,64.35 143.03,64.35 143.03,64.35 142.82,64.35 141.79,65.38 123.41,65.38 121.5,67.28 79.33,67.28 74.64,62.59 48.16,62.59 45.95,64.8 43.59,64.8 42.54,65.84 40.86,65.84 39.23,64.22 35.12,64.22 34.29,65.06 32.59,65.06 30.76,66.89 30.76,67.03 30.36,67.43 28.95,67.43 28.75,67.64 26,67.64 25.32,68.32 24.91,68.32 v1(24.75,68.48) ; v1(159.67,65.66) 160.23,66.22 161.33,66.22 162.85,67.74 162.85,72.77 164.09,74.01 173.97,74.01 176.74,71.25 177.8,71.25 178.68,70.37 179.57,70.37 D5503.2
LCD_TST_C: length 7.8
  TOP w0.102: v1(220.2,39.68) 220.22,39.68 220.41,39.49 220.68,39.49 221.31,38.86 AFTP5520.1 224.09,37.76 RN5503.8
  BOTTOM w0.102: v1(220.2,39.68) 219.92,39.68 219.89,39.7 219.81,39.7 219.71,39.8 219.71,41.08 219.24,41.55 LCD1.32
LCD_VCC_TEST_EN: length 171.6
  TOP w0.089: v1(36.33,63.2) 36,63.2 33.57,65.63 33.57,66.21 31.93,67.84 31.93,71.9 31.58,72.25 31.58,72.25 31.49,72.35 31.49,72.58 31.16,72.91 U2401.113 ; v1(144.01,84.93) v2(144.01,85.96) 142.89,87.08 142.89,87.83 D5502.2
  L4 w0.089: v1(144.01,84.93) 144.26,84.68 144.26,84.3 146.56,81.99 146.56,80.57 147.31,79.82 147.31,78.77 147.75,78.33 147.75,76.18 148.51,75.42 148.51,73.29 154.38,67.42 154.38,66.64 155.01,66.02 155.01,65.94 155.01,65.93 155.01,63.94 v1(155.76,63.19)
  BOTTOM w0.089: v1(36.33,63.2) 36.71,63.58 39.09,63.58 41.01,65.49 42.39,65.49 43.44,64.44 45.8,64.44 48.01,62.23 48.3,62.23 48.3,62.23 74.91,62.23 79.61,66.92 121.36,66.92 123.26,65.02 141.64,65.02 142.67,63.99 142.97,63.99 143.18,63.99 143.92,63.99 144.63,64.7 145.58,64.7 148.91,61.37 153.95,61.37 v1(155.76,63.19)
LCDVDD_EN: length 150.8
  TOP w0.102: v2(214.02,49.66) 213.55,49.66 v1(213.37,49.83) ; v1(220.03,38.2) 220.17,38.07 221.44,38.07 221.8,37.7 RN5502.4 ; 204.34,42.82 204.58,43.06 205.59,43.06 205.62,43.03 206.86,43.03 206.89,43.06 v1(206.93,43.06) ; 204.34,42.82 204.25,42.82 202.67,44.4 202.31,44.4 202.28,44.43 199.07,44.43 199.02,44.38 198.89,44.38 v1(198.88,44.38) ; 204.34,42.82 204.34,42.35 205.67,41.01 205.67,39.49 206.01,39.15 206.01,38.62 206.3,38.33 206.3,37.06 v1(205.87,36.63) ; D5502.3 145.92,89.02 144.86,87.96 144.85,87.96 144.24,87.35 v1(143.39,87.35)
  L2SGND w0.102: v1(198.88,44.38) 198.99,44.38 200.1,45.5 200.72,45.5 202.03,46.81 204.54,46.81 204.9,47.17 205.55,47.17 206.28,46.44 206.64,46.44 206.89,46.69 206.89,46.98 206.89,47.15 206.89,47.39 208.07,48.57 208.07,49.08 207.78,49.37 207.78,51.28 207.06,52 206.5,52 206.1,51.59 204.7,51.59 204.19,52.1 204.19,52.89 203.64,53.44 199.31,53.44 197.9,54.85 177.08,54.85 176.36,54.13 171.94,54.13 162.48,63.58 162.15,63.58 160.68,65.05 160.33,65.05 v1(160.25,64.97)
  L3 w0.102: v1(220.03,38.2) 217.18,38.2 216.18,37.21 214.78,37.21 214.71,37.14 214.18,37.14 213.98,37.33 213.96,37.33 213.27,38.02 209.21,38.02 207.82,36.63 v1(205.87,36.63) ; v1(213.37,49.83) 213.37,48.51 210.72,45.86 210.72,44.21 210.47,43.95 210.11,43.95 209.92,44.14 209.92,44.15 209.67,44.4 208.26,44.4 v1(206.93,43.06)
  L4 w0.102: v1(143.39,87.35) 144.02,87.35 145.81,85.56 145.81,84.37 148.44,81.74 148.44,81.72 148.53,81.63 148.53,79.41 149.03,78.91 149.03,76.98 158.13,67.88 158.13,66.15 159.41,64.87 160.15,64.87 v1(160.25,64.97)
  BOTTOM w0.102: v1(213.37,49.83) 213.34,49.83 213.32,49.86 213.09,49.86 213.07,49.87 U5501.4
LCDVDD_PG: length 4.5
  TOP w0.102: v2(151.89,126.71) 151.92,126.73 R5548.2 151.47,128.04 149.64,128.04 Q5504.1
LCDVDD_PWRGD: length 5.2
  TOP w0.102: R5553.1 149.56,131.79 C5535.1 149.67,132.57 R5552.1 150.22,132.58 D5505.K 152.02,134.38 v2(152.02,134.44)
LDO1_CAP: length 3.4
  TOP w0.203: 24.47,11.28 HDA27.21
  TOP w0.254: 24.47,11.28 24.18,11.28 23.27,10.36 C2703.1 R2702.1
LDO2_CAP: length 4.9
  TOP w0.203: 30.6,11.52 30.57,11.52 30.33,11.76 30.31,11.76 29.91,12.16 29.91,12.16 29.71,12.37 HDA27.32
  TOP w0.254: 30.6,11.52 31.35,10.77 31.35,10.77 v2(31.58,10.54) 31.73,10.39 32.72,10.39 33.02,10.09 C2711.1
LDO3_CAP: length 2.7
  TOP w0.203: HDA27.6 26.73,16.74 26.69,16.78
  TOP w0.254: C2722.1 25.58,18.16 v2(26.26,17.48) 26.69,17.05 26.69,16.78
LID_CL_SIO#: length 358.1
  TOP w0.089: RN6401.1 210.05,61.94 210.45,62.34 v1(210.46,62.34) ; v1(36.76,61.42) 36.76,61.16 37.43,60.49 U2401.66 39.92,60.49 40.04,60.61 40.32,60.61 41.76,62.05 41.76,63.27 42.7,64.21 42.7,65.53 42.14,66.1 42.14,66.82 42.35,67.04 43.1,67.04 43.87,66.27 44.55,66.27 44.88,65.94 44.88,65.64 45.34,65.18 45.7,65.18 U2402.2 ; RN2406.2 99.63,34.5 101.12,35.99 v2(101.99,35.99) v1(102.52,35.82)
  L3 w0.089: v1(223.31,63.85) 223.31,61.74 223.19,61.62 223.19,43.7 225.22,41.67 225.22,36.33 224.73,35.84 222.51,35.84 221.03,34.37 215.05,34.37 212.06,31.38 209.14,31.38 208.52,32 197.65,32 197.51,32 197.24,31.74 190.14,31.74 190,31.88 189.63,32.25 176.41,32.25 175.2,33.46 170.8,33.46 169.19,31.85 147.38,31.85 146.1,33.14 137.71,33.14 v1(136.99,32.41) 136.71,32.69 131.25,32.69 127.09,36.84 126.23,36.84 123.82,39.25 120.76,39.25 120.61,39.25 119.57,40.29 110.6,40.29 108.68,38.37 108.47,38.16 108.44,38.16 106.93,38.16 106.67,37.9 105.86,37.9 105.76,37.79 104.77,36.81 104.03,36.81 103.04,35.82 v1(102.52,35.82) 102.13,35.82 100.94,34.63 93.99,34.63 93.66,34.3 92.21,34.3 91.46,33.55 78.41,33.55 73.85,28.99 55.77,28.99 55.41,28.63 46.06,28.63 45.28,29.41 42.68,29.41 41.86,28.59 41.41,28.59 41.38,28.59 35.27,28.59 33.86,27.19 27.37,27.19 26.99,27.57 25.51,27.57 24.86,28.21 22.98,28.21 20.34,30.86 20.34,31.62 20.76,32.05 20.76,37.86 21.29,38.38 21.29,39.51 20.1,40.69 19.34,40.69 18.72,41.31 18.72,43.47 17.89,44.3 17.89,44.65 17.89,46.27 17.89,50.12 18.63,50.86 18.63,51.31 18.49,51.46 18.49,56.78 18.49,56.92 18.49,57.84 18.11,58.21 18.11,61.45 18.36,61.69 18.36,62.17 17.94,62.59 17.94,64.17 19,65.23 19.23,65.23 v1(20.32,66.32)
  BOTTOM w0.089: v1(36.76,61.42) 36.14,61.42 35.1,62.46 32.63,62.46 32.18,62.91 32.18,63.59 30.96,64.8 27.57,64.8 25.94,66.43 25.58,66.43 25.55,66.45 25.51,66.45 24.92,67.05 22.17,67.05 21.44,66.32 v1(20.32,66.32) ; FP1.6 222.45,63.32 222.98,63.85 v1(223.31,63.85) 223.31,65.34 223.02,65.63 219.76,65.63 217.64,63.51 212.02,63.51 210.86,62.34 v1(210.46,62.34) ; D2402.K 132.99,38.13 133.56,37.56 136.83,37.56 137.69,36.71 137.69,33.11 v1(136.99,32.41)
LID_CLOSE#_C: length 9.7
  TOP w0.089: RN6401.4 210.05,59.53 AFTP6401.1 209.47,58.47 EC6401.1 209.6,57.7 209.78,57.51 210.67,57.51 210.84,57.69 210.84,58.31 211.18,58.65 211.36,58.65 211.46,58.55 211.46,58.55 211.71,58.3 211.71,58.3 211.83,58.18 v1(211.83,57.75)
  BOTTOM w0.089: v1(211.83,57.75) 211.84,57.74 211.84,57.61 212.45,57 PWR1.3 212.45,55.57 ED6401.2
LINE1-L_C: length 11.1
  TOP w0.381: v1(25.23,9.37) 24.92,9.68 R2922.1 ; v2(18.47,12.23) 18.59,12.23 18.81,12.45 v1(18.81,12.7) 18.86,12.65 19.84,12.65 C2907.2
  L3 w0.381: v1(18.81,12.7) 18.84,12.68 22.51,12.68 22.66,12.52 22.66,11.41 24.69,9.37 v1(25.23,9.37)
LINE1-L_R: length 13.3
  TOP w0.381: C2908.2 19.42,13.83 18.96,13.37 v1(18.85,13.37) 18.76,13.37 18.49,13.64 18.31,13.64 v2(18.27,13.6) ; R2921.1 v1(27.08,8.79)
  L3 w0.381: v1(18.85,13.37) 19.11,13.37 19.15,13.41 23.57,13.41 24.06,12.93 24.06,11.41 25.3,10.16 26.26,9.61 v1(27.08,8.79)
LINE1_L: length 3.6
  TOP w0.203: 23.17,12.77 23.17,12.76 23.62,12.76 23.62,12.77 HDA27.18
  TOP w0.254: 23.17,12.77 22.73,12.77 22.54,12.58 v2(22.02,12.58) 21.98,12.62 C2907.1
LINE1_R: length 3.8
  TOP w0.203: v2(23.45,13.17) HDA27.17
  TOP w0.254: 21.81,13.52 22.17,13.17 v2(23.45,13.17)
  TOP w0.381: 21.81,13.52 21.52,13.82 C2908.1
LINE1_VREFO: length 4.1
  TOP w0.203: 26.32,10.14 26.38,10.2 26.38,10.81 26.33,10.86 HDA27.24
  TOP w0.254: D2901.3 25.1,8.51 25.2,8.61 25.2,8.62 25.81,9.23 25.81,9.65 v2(25.83,9.68) 25.86,9.68 26.32,10.14
LINE1_VREFO_D1: length 4.3
  TOP w0.254: D2901.1 24.82,4.98 v2(27.26,4.98) 27.32,4.98 27.34,5 27.88,5 R2912.1
LINE1_VREFO_D2: length 3.3
  TOP w0.254: R2913.1 26.32,7.95 26.32,6.92 v2(27.06,6.18) 26.53,5.65 D2901.2
LOM_CABLE_DETECT#: length 227.5
  TOP w0.102: R3104.2 v2(50.03,88.32) v1(50.61,88.9)
  L2SGND w0.102: v1(42.25,78.28) 42.19,78.28 42.14,78.33 40.92,78.33 38.24,75.66 36.46,75.66 34.12,73.31 33.34,73.31 v1(32.55,72.52)
  L3 w0.102: v1(32.55,72.52) 32.55,72.38 30.74,70.56 29.22,70.56 28.5,69.85 28.5,69.71 24.71,65.91 24.66,65.91 24.41,65.66 24.41,65.22 v1(24.78,64.85)
  L4 w0.102: v1(150.07,58.73) 149.68,58.33 145.68,58.33 122.59,81.42 122.59,82.31 v1(122.28,82.62)
  BOTTOM w0.102: v1(24.78,64.85) 24.92,64.71 25.24,64.71 25.46,64.49 25.94,64.49 27.92,62.51 27.92,56.67 28.11,56.49 29.87,56.49 31.18,55.19 42.29,55.19 42.47,55.37 55.2,55.37 57.15,57.33 90.43,57.33 95.34,62.24 95.73,62.24 108.31,62.24 111.79,58.77 146.64,58.77 146.99,58.42 149.76,58.42 v1(150.07,58.73) ; v1(42.25,78.28) 42.3,78.33 42.45,78.33 42.62,78.16 43.62,78.16 44.42,77.36 48.89,77.36 49.28,77.75 50.45,77.75 51.95,79.25 51.95,83.08 50.61,84.42 v1(50.61,88.9) ; v1(122.28,82.62) 121.97,82.93 121.57,82.93 121.33,83.17 121.33,83.41 121.04,83.69 120.69,83.69 120.52,83.86 120.52,84.18 120.56,84.23 120.56,84.47 120.39,84.64 120.34,84.64 119.58,85.41 CPU1.CK34
LOM_TCT: length 12.5
  TOP w0.254: XF3201.9 37.66,83.3 v1(37.16,83.8) 36.4,84.56 36.4,85.73 37.21,86.53 XF3201.10
  BOTTOM w0.254: XF3201.10 37.18,86.53 36.61,85.96 36.61,84.35 v1(37.16,83.8) 37.66,83.3 XF3201.9 38.92,82.72 v2(39.11,82.91) 39.12,82.92 C3203.1
LPS_SW: length 20.6
  TOP w0.254: v1(28.18,111.81) 28.3,111.81 28.9,111.21 R7401.2 ; v1(32.69,122.85) 32.69,123.24 33.29,123.84 C7401.2 33.6,123.9 R7407.1 34.34,123.87 R7403.1 34.37,123.19 U7418.4
  L3 w0.254: v1(32.69,122.85) 32.69,121.96 33,121.66 33,120.3 31.63,118.92 31.63,116.89 31.12,116.38 30.66,116.38 29.29,115.01 28.02,115.01 27.59,114.58 27.59,112.41 v1(28.18,111.81)
  BOTTOM w0.254: v2(27.66,111.58) 27.89,111.81 v1(28.18,111.81)
LPS_SW_A: length 2.1
  TOP w0.254: R7401.1 29.76,109.85 v2(29.76,109.84) 29.77,109.83 Q7406.3
LPS_SW_C: length 26.7
  TOP w0.254: Q7401.G 32.35,123.74 32.06,123.45 v1(32.06,122.85) 31.58,122.85 30.74,123.69 30.1,123.69 29.29,124.5 R7406.2 ; R7408.1 31.12,104.3 32.01,105.19 v2(32.01,106.46) v1(32.01,107.06)
  L4 w0.254: v1(32.01,107.06) 31.61,107.45 31.61,110.32 33.61,112.32 33.61,121.11 32.06,122.66 v1(32.06,122.85)
LPS_SW_D: length 3.1
  TOP w0.254: R7408.2 30.26,104.4 v2(31.09,105.23) 31.07,105.25 Q7406.6
LPS_SW_R: length 2.6
  TOP w0.102: Q7401.D 31.65,122.42 31.87,122.42 31.88,122.42 32.87,122.42 33.12,122.67 33.48,123.05 R7403.2
M2_PCIE_LED#: length 13.6
  TOP w0.102: v1(27.65,24.06) 27.26,24.44 27.26,25.87 v2(26.7,26.44) 26.25,26 D6401.2 ; v1(30.56,22.71) R6411.2
  BOTTOM w0.102: SSD1.10 34.2,23.5 33.4,22.71 v1(30.56,22.71) 29,22.71 v1(27.65,24.06)
M2_SSD_PEDET: length 298.2
  TOP w0.089: v1(16.11,29.74) 16.39,30.02 v2(16.39,30.28) ; v1(31.85,21.79) 31.85,21.52 31.73,21.39 R6348.2
  L3 w0.089: v1(164.82,66.9) 164.82,67.53 160.79,71.57 160.79,72.16 152.66,80.29 152.66,82.68 151.54,83.8 151.54,84.83 149.14,87.23 148.59,87.23 137.77,98.05 136.87,98.05 133.5,101.43 128.81,101.43 128.62,101.24 127.86,101.24 v1(127.62,101.01) ; v1(13.64,64.16) 13.57,64.09 13.57,63.4 13.87,63.1 13.87,59.88 14.18,59.58 14.18,58.52 14.18,58.52 14.18,58.21 15.17,57.22 15.17,55.75 15.17,52.45 15.38,52.23 15.38,50.31 14.63,49.56 14.63,43.18 16.5,41.31 16.5,40.39 16.94,39.95 16.94,30.57 v1(16.11,29.74)
  BOTTOM w0.076: 122.95,101.36 122.54,101.36 122.42,101.24 122.28,101.16 CPU1.CP10
  BOTTOM w0.089: v1(164.82,66.9) 164.82,66.59 159.62,61.39 158.37,61.39 155.41,58.43 150.88,58.43 150.22,57.78 147.07,57.78 146.48,58.37 111.62,58.37 108.16,61.83 95.49,61.83 90.59,56.93 57.37,56.93 55.41,54.97 42.64,54.97 42.3,54.64 37.34,54.64 36.72,54.02 31.27,54.02 30.56,54.72 28.66,54.72 28.51,54.57 28.15,54.57 27.89,54.83 27.89,55.85 27.26,56.49 27.26,61.79 26.2,62.84 25.78,63.26 24.57,63.26 24.43,63.13 23.09,63.13 22.91,63.3 22.17,63.3 20.47,65 16.72,65 16.41,65.32 16.05,65.32 15.83,65.09 13.96,65.09 13.64,64.78 v1(13.64,64.16) ; 122.95,101.36 122.95,101.35 123.29,101.35 123.48,101.54 127.08,101.54 v1(127.62,101.01) ; SSD1.69 19.45,31.11 18.09,29.74 v1(16.11,29.74) 15.44,29.74 14.38,28.69 14.38,27.78 16.89,25.27 16.89,24.31 18.29,22.91 21.67,22.91 22.25,22.33 28.02,22.33 29.39,20.96 31.37,20.96 31.85,21.44 v1(31.85,21.79)
M_A_A0: length 62.4
  L4 w0.089: v1(88.65,77.68) 88.34,77.37 88.34,76.69 87.87,76.21 87.87,74.63 85.82,72.58 85.23,72.58 83.72,71.07 83.72,70.93
  L4 w0.203: 83.72,70.93 83.72,70.2 82.81,69.29 82.53,69.29 82.18,69.63 81.9,69.63 81.61,69.35 81.61,69.06 81.95,68.72 81.95,68.43 81.67,68.14 81.38,68.14 81.04,68.48 80.75,68.48 80.46,68.2 80.46,67.91 80.8,67.57 80.8,67.28 80.52,66.99 80.23,66.99 79.89,67.33 79.6,67.33 79.31,67.05 79.31,66.76 79.65,66.42 79.65,66.13 76.75,63.22 72.46,63.22 63.83,54.6 63.83,50.05 63.63,49.84 63.63,47.45 64.19,46.9 v1(65.03,46.9)
  BOTTOM w0.076: CPU1.AC37 90.67,83.82 90.67,82.85 90.91,82.62 90.91,80.58 90.38,80.05 90.38,79.9
  BOTTOM w0.14: 90.38,79.9 90.38,78.42 90.17,78.21 90.17,77.8 90.04,77.68 v1(88.65,77.68)
  BOTTOM w0.216: DM1.144 66.08,44.13 66.3,44.35 66.3,46.33 65.53,47.1 65.23,47.1 v1(65.03,46.9)
M_A_A1: length 64.2
  L4 w0.089: 84.56,71.4 85.45,72.29 85.93,72.29 88.17,74.53 88.17,75.77 v1(88.81,76.41)
  L4 w0.203: v1(64.19,48.89) 64.62,48.89 64.75,49.01 64.75,49.76 64.57,49.94 64.57,54.69 66.84,56.95 67.12,56.95 67.3,56.78 67.59,56.78 67.88,57.06 67.88,57.35 67.7,57.53 67.7,57.82 67.99,58.1 68.27,58.1 68.45,57.93 68.74,57.93 69.03,58.21 69.03,58.5 68.85,58.68 68.85,58.97 69.13,59.25 69.42,59.25 69.6,59.08 69.89,59.08 70.18,59.36 70.18,59.65 70,59.83 70,60.12 70.28,60.4 70.57,60.4 70.75,60.22 71.04,60.22 71.33,60.51 71.33,60.8 71.15,60.98 71.15,61.27 71.43,61.55 71.72,61.55 71.9,61.37 72.19,61.37 72.48,61.66 72.48,61.95 72.3,62.13 72.3,62.42 72.62,62.74 76.98,62.74 84.56,70.32 84.56,71.4
  BOTTOM w0.076: CPU1.AC36 90.99,84.35 90.99,84.3 91.09,84.11 91.09,83.84 90.87,83.61 90.87,82.89 91.07,82.68 91.07,80.51 90.7,80.14 90.7,78.38 90.48,78.16
  BOTTOM w0.14: 90.48,78.16 90.48,76.63
  BOTTOM w0.216: v1(64.19,48.89) 63.94,48.64 63.49,48.64 63.33,48.8 DM1.133 ; 90.48,76.63 90.48,76.07 90.6,75.95 92.1,75.95 92.28,75.77 92.28,75.36 92.15,75.24 89.47,75.24 89.32,75.39 89.32,75.9 v1(88.81,76.41)
M_A_A2: length 62.6
  L4 w0.089: 83.32,71.18 85.02,72.87 85.43,72.87 85.74,73.18 86.01,73.18 87.69,74.86 87.69,76.33 88.14,76.79 88.14,77.82 v1(88.63,78.31)
  L4 w0.203: 83.32,71.18 82.71,70.56 82.11,70.56 78.46,66.92 78.46,66.63 78.84,66.25 78.84,65.96 78.55,65.67 78.27,65.67 77.89,66.05 77.6,66.05 77.31,65.77 77.31,65.48 77.69,65.1 77.69,64.81 77.4,64.52 77.12,64.52 76.74,64.9 76.45,64.9 75.28,63.73 72.32,63.73 63.3,54.71 63.3,50.09 63.22,50.01 63.22,47.28 63.25,47.26 63.25,46.24 63.46,46.03 63.78,46.03 v1(64.01,46.25)
  BOTTOM w0.076: 90.26,80.24 90.74,80.72 90.74,82.54 90.5,82.78 90.5,83.89 90.61,84.19 90.61,84.43 90.53,84.67 90.53,85.86 90.6,85.94 CPU1.AC34
  BOTTOM w0.14: v1(88.63,78.31) 88.65,78.3 89.89,78.3 90.02,78.43 90.02,80 90.26,80.24
  BOTTOM w0.216: DM1.132 63.08,45.95 63.38,46.25 v1(64.01,46.25)
M_A_A3: length 64.5
  L4 w0.089: 85.21,71.39 85.82,72 86.05,72 88.75,74.7 v1(88.75,75.74)
  L4 w0.203: v1(64.27,47.61) 65.01,47.61 65.21,47.81 65.21,53.75 65.4,53.93 65.4,54.21 65.22,54.39 65.22,54.68 65.5,54.97 65.79,54.97 65.97,54.79 66.25,54.79 66.55,55.08 66.55,55.36 66.37,55.54 66.37,55.83 66.65,56.12 66.94,56.12 67.12,55.94 67.4,55.94 73.74,62.28 77.24,62.28 85.21,70.25 85.21,71.39
  BOTTOM w0.076: CPU1.AC35 91.02,85.29 91.15,85.15 91.15,84.34 91.25,84.15 91.25,83.77 91.03,83.55 91.03,82.96 91.24,82.75 91.24,80.43 90.87,80.06 90.87,77.64 91.02,77.49
  BOTTOM w0.216: v1(64.27,47.61) 63.04,47.61 62.83,47.82 DM1.131 ; v1(88.75,75.74) 88.8,75.69 88.8,74.93 88.95,74.78 92.61,74.78 92.79,74.96 92.79,76.2 92,76.99 91.25,76.99 91.02,77.22 91.02,77.49
M_A_A4: length 61.8
  TOP w0.089: v1(62.57,45.32) 62.47,45.32 v2(62.05,44.9)
  L4 w0.089: 80.51,71.48 82.45,71.48 84.43,73.46 85.19,73.46 85.62,73.89 86.03,73.89 87.33,75.19 87.33,76.54 87.66,76.86 87.66,79.53 88.29,80.16 88.83,80.16 v1(88.86,80.19)
  L4 w0.203: 80.51,71.48 78.47,69.44 78.47,69.15 78.76,68.86 78.76,68.57 78.47,68.29 78.18,68.29 77.89,68.57 77.61,68.57 77.32,68.29 77.32,68 77.61,67.71 77.61,67.42 77.32,67.14 77.03,67.14 76.74,67.42 76.46,67.42 76.17,67.14 76.17,66.85 76.46,66.56 76.46,66.27 74.85,64.67 71.96,64.67 62.39,55.09 62.39,54.72 62.39,49.26 62.39,48.79 61.99,48.39 61.99,45.45 62.11,45.32 v1(62.57,45.32)
  BOTTOM w0.076: CPU1.AA35 89.63,85.19 89.8,84.73 89.8,84.54 89.76,84.43 89.76,84.19 89.81,84.03 89.81,82.75 89.34,82.27 89.34,81.48
  BOTTOM w0.14: 89.34,81.48 89.34,80.67 v1(88.86,80.19)
  BOTTOM w0.216: DM1.128 62.08,44.83 v1(62.57,45.32)
M_A_A5: length 62.6
  TOP w0.089: v2(61.91,46.15) 62.11,45.96 v1(62.54,45.96)
  L4 w0.089: 87.25,71.88 87.25,71.88 90.18,74.81 90.18,80.17 90.6,80.59 90.6,81.02 v1(90.14,81.48)
  L4 w0.203: v1(62.54,45.96) 62.72,45.96 63.14,45.54 63.14,44.82 63.71,44.25 66.12,44.25 66.3,44.43 66.3,52.09 74.46,60.25 78,60.25 87.17,69.43 87.17,71.8 87.25,71.88
  BOTTOM w0.076: v1(90.14,81.48) 90.58,81.91 90.58,82.13 90.58,82.13 90.58,82.46 90.58,82.46 90.58,82.48 90.34,82.71 90.34,83.92 90.45,84.22 90.45,84.4 90.28,84.86 CPU1.AB35
  BOTTOM w0.216: DM1.126 61.58,45.43 62.11,45.96 v1(62.54,45.96)
M_A_A6: length 63.2
  TOP w0.216: v2(62.39,49.09) 62.39,49.17 61.9,49.66 v1(61.83,49.67)
  L4 w0.089: v1(86.82,75.99) 86.44,75.61 86.44,75.12 85.07,73.75 84.31,73.75 82.36,71.81 80.12,71.81
  L4 w0.203: 80.12,71.81 74.92,66.6 74.92,66.31 75.24,65.99 75.24,65.7 74.95,65.41 74.67,65.41 74.34,65.74 74.05,65.74 73.44,65.13 71.77,65.13 71.29,64.65 71,64.65 70.81,64.84 70.53,64.84 70.24,64.55 70.24,64.26 70.43,64.07 70.43,63.78 70.14,63.5 69.85,63.5 69.66,63.69 69.38,63.69 69.09,63.4 69.09,63.11 69.28,62.92 69.28,62.64 68.99,62.35 68.71,62.35 68.51,62.54 68.23,62.54 67.94,62.25 67.94,61.96 68.13,61.77 68.13,61.49 67.84,61.2 67.56,61.2 67.36,61.39 67.08,61.39 66.79,61.1 66.79,60.82 66.98,60.62 66.98,60.34 66.69,60.05 66.41,60.05 66.21,60.24 65.93,60.24 65.64,59.95 65.64,59.67 65.83,59.47 65.83,59.19 65.54,58.9 65.26,58.9 65.06,59.09 64.78,59.09 64.49,58.8 64.49,58.52 64.68,58.32 64.68,58.04 64.39,57.75 64.11,57.75 63.92,57.94 63.63,57.94 63.34,57.65 63.34,57.37 63.53,57.17 63.53,56.89 63.24,56.6 62.96,56.6 62.77,56.79 62.48,56.79 62.19,56.5 62.19,56.22 62.38,56.03 62.38,55.74 61.83,55.18 61.83,54.59 61.62,54.39 61.17,54.39 60.96,54.19 60.96,53.78 61.17,53.58 61.62,53.58 61.83,53.37 61.83,52.97 61.62,52.76 61.17,52.76 60.96,52.56 60.96,52.15 61.17,51.95 61.62,51.95 61.83,51.75 61.83,51.34 61.62,51.14 61.17,51.14 60.96,50.94 60.96,50.53 61.17,50.33 61.62,50.33 61.83,50.12 v1(61.83,49.67)
  BOTTOM w0.076: 88.43,80.58 89.07,81.22 89.07,82.42 89.65,82.99 89.65,83.87 CPU1.AA37
  BOTTOM w0.14: 88.43,80.58 88.43,79.87 87.89,79.33 87.89,76.51 87.37,75.99 v1(86.82,75.99)
  BOTTOM w0.216: v1(61.83,49.67) DM1.127
M_A_A7: length 63.2
  TOP w0.089: v2(60.18,44.39) v1(60.57,44.78)
  L4 w0.089: v1(86.82,76.62) 86.26,76.06 86.26,75.35 84.95,74.04 84.19,74.04 82.24,72.1 79.76,72.1
  L4 w0.203: v1(60.57,44.78) 60.58,44.78 60.58,44.35 60.7,44.22 61.39,44.22 61.57,44.4 61.57,45.79 61.32,46.04 60.1,46.04 59.9,46.24 59.9,46.65 60.1,46.85 61.07,46.85 61.27,47.06 61.27,49.33 60.4,50.2 60.4,55.37 70.62,65.58 73.24,65.58 79.76,72.1
  BOTTOM w0.076: 88.85,81.33 88.85,82.44 89.48,83.06 89.48,83.62 89.28,83.82 89.28,84.12 89.31,84.18 89.37,84.24 89.53,84.57 CPU1.AA36
  BOTTOM w0.14: 88.85,81.33 88.2,80.67 88.2,79.97 87.66,79.43 87.66,76.76 87.52,76.62 v1(86.82,76.62)
  BOTTOM w0.216: v1(60.57,44.78) 60.58,44.78 DM1.122
M_A_A8: length 61.1
  TOP w0.089: v1(62.56,47.23) 62.31,47.48 v2(62.04,47.48)
  L4 w0.089: 81.95,71.07 82.58,71.07 84.67,73.17 85.31,73.17 85.73,73.59 86.08,73.59 87.51,75.01 87.51,76.41 87.84,76.73 87.84,78.89 88.5,79.55 v1(88.85,79.55)
  L4 w0.203: v1(62.56,47.23) 62.56,48.39 62.79,48.62 62.79,48.63 62.79,50.15 62.84,50.2 62.84,54.9 72.15,64.21 75.05,64.21 79.65,68.82 79.65,69.05 79.36,69.34 79.36,69.63 79.65,69.92 79.94,69.92 80.22,69.63 80.51,69.63 80.8,69.92 80.8,70.2 80.51,70.49 80.51,70.78 80.8,71.06 81.09,71.06 81.37,70.78 81.66,70.78 81.95,71.07
  BOTTOM w0.076: CPU1.AB34 89.92,85.35 89.92,84.88 89.96,84.76 89.96,84.51 89.92,84.4 89.92,84.22 89.98,84.06 89.98,82.68 89.71,82.42 89.71,81.74
  BOTTOM w0.14: 89.71,81.74 89.71,79.68 89.59,79.55 v1(88.85,79.55)
  BOTTOM w0.216: DM1.125 61.33,47.39 61.49,47.23 v1(62.56,47.23)
M_A_A9: length 61.8
  TOP w0.216: v2(59.61,47.91) v1(59,47.98)
  L4 w0.089: 78.35,72.98 81.97,72.98 85.27,76.28 85.27,79.55 85.83,80.11 v1(86.77,80.11)
  L4 w0.203: v1(59,47.98) 59,56.8 59.3,57.1 59.59,57.1 59.75,56.94 60.04,56.94 60.32,57.23 60.32,57.51 60.16,57.67 60.16,57.96 60.45,58.25 60.74,58.25 60.9,58.09 61.19,58.09 61.47,58.38 61.47,58.66 61.31,58.82 61.31,59.11 61.6,59.4 61.89,59.4 62.05,59.24 62.34,59.24 62.62,59.53 62.62,59.81 62.46,59.97 62.46,60.26 69.93,67.73 73.11,67.73 78.35,72.98
  BOTTOM w0.076: CPU1.W36 88.32,84.58 88.32,84.58 88.46,84.33 88.46,84.32 88.57,84.11 88.57,83.84 88.35,83.61 88.35,81.87 87.52,81.03 87.52,80.78
  BOTTOM w0.14: 87.52,80.78 87.52,80.35 87.28,80.11 v1(86.77,80.11)
  BOTTOM w0.216: DM1.121 60.33,49.6 60.33,49.59 60.33,48.07 59.72,47.46 59.23,47.46 59,47.68 v1(59,47.98)
M_A_A10: length 61.6
  L4 w0.089: 90.64,71.64 92.85,73.85 92.85,77.14 92.94,78.32 92.94,79.02 92.91,82.51 91.74,83.68 89.69,84.38 89.18,84.89 89.13,84.89 88.35,85.67 88.35,86.3 88.48,86.43 88.48,86.78 88.46,86.8 88.46,86.86 88.23,87.09 88.2,87.09 v1(87.96,87.33)
  L4 w0.203: v1(69.18,45.78) 68.97,45.78 68.6,46.15 68.6,50.35 75.61,57.35 79.18,57.35 90.64,68.81 90.64,71.64
  BOTTOM w0.089: CPU1.Y31 88.67,87.3 87.99,87.3 v1(87.96,87.33)
  BOTTOM w0.216: v1(69.18,45.78) 69.11,45.72 68.83,45.72 68.57,45.46 68.57,42.91 DM1.146
M_A_A11: length 60.8
  TOP w0.216: v2(59.74,46.28) v1(59.19,46.36)
  L4 w0.089: v1(86.79,78.82) 87.19,78.42 87.19,78.02 86.93,77.75 86.71,77.75 86.08,77.12 86.08,75.67 84.77,74.36 84.09,74.36 82.12,72.39 79.35,72.39
  L4 w0.203: 79.35,72.39 73,66.04 70.43,66.04 59.95,55.55 59.95,50.08 60.4,49.62 60.4,48.23 59.19,47.02 v1(59.19,46.36)
  BOTTOM w0.076: 88.19,81.43 88.52,81.75 88.52,83.55 88.74,83.77 88.74,84.15 88.62,84.36 88.62,85.31 88.32,85.93 CPU1.W34
  BOTTOM w0.14: v1(86.79,78.82) 87.2,79.22 87.2,79.62 87.74,80.16 87.74,80.98 88.19,81.43
  BOTTOM w0.216: v1(59.19,46.36) 59.36,46.36 60.08,45.64 DM1.120
M_A_A12: length 62.1
  TOP w0.216: v1(59.85,49.39) v2(60.35,49.12)
  L4 w0.089: 78.96,72.68 82,72.68 84.11,74.79 84.78,74.79 85.68,75.69 85.68,77.79 86.07,78.18 v1(86.79,78.18)
  L4 w0.203: v1(59.85,49.39) 59.49,49.74 59.49,55.74 63.5,59.76 63.5,60.05 63.34,60.21 63.34,60.49 63.63,60.78 63.92,60.78 64.08,60.62 64.37,60.62 64.65,60.91 64.65,61.19 64.49,61.35 64.49,61.64 64.78,61.93 65.07,61.93 65.23,61.77 65.52,61.77 65.8,62.06 65.8,62.34 65.64,62.5 65.64,62.79 65.93,63.08 66.22,63.08 66.38,62.92 66.67,62.92 66.95,63.21 66.95,63.49 66.79,63.65 66.79,63.94 67.08,64.23 67.37,64.23 67.53,64.07 67.81,64.07 68.1,64.36 68.1,64.64 67.94,64.8 67.94,65.09 68.23,65.38 68.52,65.38 68.68,65.22 68.96,65.22 69.25,65.51 69.25,65.79 69.09,65.95 69.09,66.24 69.38,66.53 69.67,66.53 69.83,66.37 70.11,66.37 70.24,66.5 70.64,66.5 70.81,66.67 70.81,67.09 70.99,67.27 71.45,67.27 71.62,67.1 71.62,66.66 71.78,66.5 72.24,66.5 72.37,66.63 72.37,67.13 72.49,67.26 73.54,67.26 78.96,72.68
  BOTTOM w0.076: 88.44,81.26 88.68,81.5 88.68,82.5 89.31,83.13 89.31,83.56 89.12,83.75 89.12,84.17 89.18,84.28 89.19,84.3 89.22,84.34 89.22,85.28 CPU1.AA34
  BOTTOM w0.14: v1(86.79,78.18) 87.3,78.18 87.43,78.31 87.43,79.52 87.97,80.07 87.97,80.79 88.44,81.26
  BOTTOM w0.216: DM1.119 59.83,49.41 v1(59.85,49.39)
M_A_A13: length 62
  L4 w0.089: 93.09,71.19 93.19,71.29 93.19,71.32 94.67,72.79 94.67,77.27 94.66,81.2 94.66,83.51 91.44,86.72 v1(90.7,86.72)
  L4 w0.203: v1(70.93,46.33) 70.58,46.68 70.58,47.6 70.51,47.66 70.51,48.57 71,49.05 71,49.76 72.83,51.6 73.33,51.6 76.62,54.89 82.45,54.89 82.78,55.21 82.78,55.5 82.48,55.8 82.48,56.09 82.76,56.38 83.05,56.38 83.35,56.07 83.64,56.07 83.93,56.36 83.93,56.65 83.62,56.95 83.62,57.24 93.09,66.71 93.09,71.19
  BOTTOM w0.14: CPU1.AC32 v1(90.7,86.72)
  BOTTOM w0.216: DM1.158 71.58,45.5 71.56,45.52 71.56,45.71 v1(70.93,46.33)
M_A_A14: length 61.8
  L4 w0.089: v1(90.68,87.4) 90.3,87.02 90.3,86.23 91.44,85.09 92.82,85.09 94.36,83.55 94.36,73.02 92.57,71.24
  L4 w0.203: v1(70.44,49.28) 70.44,49.78 72.66,52 73.04,52 76.39,55.35 81.08,55.35 87.7,61.96 87.7,62.25 87.33,62.63 87.33,62.91 87.61,63.2 87.9,63.2 88.28,62.83 88.56,62.83 88.85,63.11 88.85,63.4 88.48,63.78 88.48,64.06 88.76,64.35 89.05,64.35 89.43,63.98 89.71,63.98 90,64.26 90,64.55 89.63,64.93 89.63,65.21 89.91,65.5 90.2,65.5 90.58,65.13 90.86,65.13 91.15,65.41 91.15,65.7 90.78,66.08 90.78,66.36 91.06,66.65 91.35,66.65 91.73,66.28 92.01,66.28 92.57,66.84 92.57,71.24
  BOTTOM w0.089: CPU1.AC31 v1(90.68,87.4)
  BOTTOM w0.216: v1(70.44,49.28) 69.83,49.9 DM1.151
M_A_A15: length 62.6
  L4 w0.089: v1(89.79,86.67) 89.79,86.27 91.14,84.91 92.1,84.07 93.41,82.77 93.44,82.62 93.52,78.76 93.63,77.98 93.89,77.71 93.89,73.17 92.01,71.28
  L4 w0.203: v1(70.61,45.61) 70.61,45.86 70.37,46.1 70.37,46.2 70.17,46.41 70.17,47.43 69.88,47.72 69.88,49.79 72.49,52.41 72.77,52.41 76.35,55.98 79.75,55.98 80.72,56.96 81.01,56.96 81.37,56.6 81.65,56.6 81.94,56.89 81.94,57.18 81.59,57.53 81.59,57.82 81.87,58.11 82.16,58.11 82.52,57.75 82.8,57.75 83.09,58.04 83.09,58.33 82.74,58.68 82.74,58.97 83.02,59.26 83.31,59.26 83.67,58.9 83.95,58.9 84.24,59.19 84.24,59.48 83.88,59.83 83.88,60.12 92.01,68.24 92.01,71.28
  BOTTOM w0.089: CPU1.AB32 90.05,86.81 v1(89.79,86.67)
  BOTTOM w0.216: DM1.156 71.08,44.76 71.08,44.77 71.08,45.17 70.65,45.61 v1(70.61,45.61)
M_A_A16: length 59.3
  L4 w0.089: v1(89.81,87.31) 89.39,86.89 89.39,86.42 91.07,84.74 91.98,83.94 93.22,82.7 93.26,82.6 93.34,78.02 93.6,77.5 93.6,73.46 91.55,71.41
  L4 w0.203: 91.55,71.41 91.55,68.43 79.56,56.44 76.14,56.44 72.52,52.81 72.27,52.81 69.47,50.02 69.47,47.55 69.76,47.26 v1(69.76,46.02)
  BOTTOM w0.089: v1(89.81,87.31) 89.65,87.31 CPU1.Y32
  BOTTOM w0.216: DM1.152 70.07,42.91 70.07,45.18 69.76,45.49 v1(69.76,46.02)
M_A_ACT_N: length 61.8
  TOP w0.216: v2(57.19,46.04) v1(57.59,45.64)
  L4 w0.089: 77.01,74.24 81.43,74.24 v1(83.97,76.78)
  L4 w0.203: 77.01,74.24 72.34,69.57 68.97,69.57 55.94,56.54 55.94,48.03 56.42,47.56 56.61,47.56 57.59,46.58 v1(57.59,45.64)
  BOTTOM w0.076: 86.29,81.22 86.42,81.35 86.42,81.81 86.84,82.23 86.84,82.8 87.44,83.4 87.44,84.13 87.41,84.19 87.41,84.44 87.57,84.86 CPU1.V35
  BOTTOM w0.14: 86.29,81.22 86.29,78.87 84.2,76.78 v1(83.97,76.78)
  BOTTOM w0.216: DM1.114 58.58,44.89 57.82,45.64 v1(57.59,45.64)
