# Allegro board 17938-1.1228WZS1107.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BT_USB20_N: length 135.5
  TOP w0.127: v1(38.28,96.8) 38,96.52 36.92,96.52 36.7,96.74 ; 36.7,96.74 v2(36.81,96.85) ; 36.7,96.74 35.7,97.74 33.05,97.74 32.81,97.98 EL6101.2
  L3 w0.114: v1(38.28,96.8) 38.58,96.5 38.88,96.5 41.45,93.93 45.36,93.93 45.67,94.24 45.67,98.2 48.61,101.13 48.61,103.22 50.68,105.3 52.45,105.3 52.91,105.76 52.91,106.32 56.48,109.88 56.48,111.41 62.08,117.02 62.08,118.61 67.31,123.84 104.38,123.84 105.08,123.15 113.88,123.15 123.35,113.68 123.35,109.69 122.04,108.38 118.36,108.38 117.6,109.13 117.6,110.39 117.2,110.8 v1(116.84,110.8)
  BOTTOM w0.076: 116.1,109.93 116.1,109.91 116.07,109.88 116.07,109.31 115.27,108.5 115.27,107.91 115.35,107.82 115.48,107.7 115.48,107 115.3,106.82 115.3,106.51 115.33,106.43 115.33,106.15 115.3,106.07 115.3,105.86 115.33,105.8 115.39,105.65 CPU1.CC3
  BOTTOM w0.127: v1(116.84,110.8) 116.84,110.87 116.45,111.26 116.28,111.26 116.1,111.08 116.1,109.93
BT_USB20_P: length 135.8
  TOP w0.127: 34.75,97.5 35.6,97.5 36.82,96.27 37.98,96.27 v1(38.28,95.97) ; 34.75,97.5 32.99,97.5 32.78,97.3 EL6101.3 ; 34.75,97.5 v2(34.75,97.37)
  L3 w0.114: v1(38.28,95.97) 38.58,96.27 38.79,96.27 41.35,93.7 45.46,93.7 45.9,94.15 45.9,98.1 48.83,101.04 48.83,103.13 50.78,105.07 52.55,105.07 53.14,105.66 53.14,106.22 56.7,109.79 56.7,111.32 62.31,116.92 62.31,118.52 67.4,123.61 104.29,123.61 104.98,122.92 113.78,122.92 123.12,113.58 123.12,109.78 121.94,108.61 118.45,108.61 117.83,109.23 117.83,110.49 v1(116.82,111.5)
  BOTTOM w0.076: CPU1.CC4 115.52,104.68 115.28,105.25 115.28,105.47 115.16,105.73 115.12,105.82 115.12,106.11 115.13,106.14 115.15,106.18 115.15,106.4 115.13,106.45 115.12,106.47 115.12,106.89 115.3,107.07 115.3,107.62 115.09,107.84 115.09,107.98 115.09,108.57 115.89,109.38 115.89,109.88 115.86,109.91 115.86,109.93
  BOTTOM w0.127: 115.86,109.93 115.86,111.18 116.18,111.5 v1(116.82,111.5)
C10_GATE: length 6.9
  TOP w0.102: R4048.2 89.41,38.38 v1(89.36,38.43) ; R4010.2 88.83,38.96 v1(89.36,38.43) ; v1(89.36,38.43) 89.75,38.82 v2(89.75,38.93) 89.76,38.93 89.76,39.82 R4034.2 90.66,39.88 R4040.2
  BOTTOM w0.102: v1(89.36,38.43) 89.36,38.66 89.98,39.28 89.98,39.85 89.64,40.18 U4007.2
CAD_SNK_MUX: length 1.8
  TOP w0.102: U7101.29 v1(19.23,107.99)
  BOTTOM w0.102: v1(19.23,107.99) 18.65,108.58 R7189.2
CAM_EN: length 141.4
  TOP w0.089: v2(211.48,51.33) 211.89,50.93 v1(211.89,50.9)
  L3 w0.089: v1(117.22,100.18) 117.48,100.18 118.04,100.74 118.6,100.74 118.87,101.01 121.18,101.01 122.95,102.79 122.95,102.89 123.48,103.41 123.48,103.84 124.59,104.95 134.33,104.95 134.62,105.24 v1(134.72,105.24) 134.98,105.24 155.1,85.13 155.1,81.26 164.22,72.13 164.24,72.13 164.49,71.88 164.49,71.86 165.66,70.69 165.66,70.11 169.41,66.37 169.41,65.53 174.08,60.86 174.24,60.7 175.27,60.7 178.23,57.74 180.67,57.74 181.19,57.23 190.16,57.23 192.35,59.41 203.72,59.41 204.06,59.07 208.3,59.07 208.77,58.6 208.77,58.41 211.09,56.09 211.39,56.09 211.69,55.79 211.69,55.17 211.38,54.86 211.38,52.08 211.89,51.56 v1(211.89,50.9)
  L4 w0.089: v1(209.91,43.49) 209.96,43.54 209.96,44.09 209.86,44.19 209.86,45.96 212.01,48.1 212.01,50.78 v1(211.89,50.9)
  BOTTOM w0.089: v1(117.22,100.18) 117.43,100.18 117.67,100.43 117.67,100.92 117.27,101.32 CPU1.CE9 ; v1(209.91,43.49) 210.38,43.96 210.46,43.96 210.49,43.99 U5502.3 ; R5557.1 135.04,106.3 134.72,105.99 v1(134.72,105.24)
CAP_LED: length 32
  TOP w0.203: v1(75.26,34.44) 75.64,34.06 AFTP6541.1
  L3 w0.203: v1(75.26,34.44) 75.52,34.44 77.96,36.88 92.65,36.88 92.77,37.01 98.19,37.01 99.03,37.85 100.83,37.85 101.76,38.78 v1(102.48,38.78)
  BOTTOM w0.203: R6513.2 102.14,37.82 102.48,38.17 v1(102.48,38.78) ; KB1.4 75.12,34.59 v1(75.26,34.44)
CAP_LED#: length 6.7
  TOP w0.102: U2401.93 40.17,71.29 40.19,71.27 40.5,71.27 40.55,71.32 41.56,71.32 v2(41.76,71.51) 41.78,71.54 43,71.54 R2489.1 43.44,71.96 44.28,71.96 44.93,71.31 Q2414.S
CAP_LED#_R: length 160.5
  TOP w0.102: v2(98.5,42.94) 98.97,42.94 v1(99.06,43.03) ; Q2414.D 44.93,69.06 v1(44.61,68.73)
  L4 w0.102: v1(99.06,43.03) 98.53,43.03 97.74,42.24 95.89,42.24 95.63,41.98 94.08,41.98 93.98,41.88 92.01,41.88 91.75,42.12 83.13,42.12 82.72,41.72 81.76,41.72 80.97,40.92 73.65,40.92 73.65,40.91 73.12,40.91 73.11,40.92 67.19,40.92 67.18,40.93 64.85,40.93 64.76,40.84 60.96,40.84 59.48,42.32 36.79,42.32 35.94,41.48 35.94,40.83 36.51,40.26 36.51,39.57 36.58,39.49 36.58,37.98 36.5,37.9 36.5,37.6 35.83,36.93 35.83,34.14 32.12,30.43 32.12,28.98 31.31,28.17 29.36,28.17 28.92,28.6 27.11,28.6 27.11,28.6 26.75,28.6 26.24,29.11 21.95,29.11 19.56,31.5 19.56,35.38 18.86,36.08 18.86,39.21 18.57,39.5 18.57,40.03 18.12,40.48 18.12,50.25 18.67,50.79 18.67,56.75 23.38,61.47 23.38,66.01 25.18,67.81 25.18,67.85 25.52,68.19 25.52,68.36 25.89,68.73 26.12,68.73 27.68,70.29 28.04,70.29 v1(28.34,70.29)
  BOTTOM w0.102: v1(99.06,43.03) 100.81,41.29 Q6505.B ; v1(28.34,70.29) 28.55,70.5 29.26,70.5 29.56,70.21 29.56,70.21 29.83,69.93 29.84,69.93 30.07,69.7 31.55,69.7 31.73,69.52 41.96,69.52 42.04,69.6 43.74,69.6 44.15,69.19 44.17,69.19 44.43,68.94 44.43,68.91 v1(44.61,68.73)
CAP_LED_Q: length 3
  BOTTOM w0.203: Q6505.C 101.27,38.23 R6513.1 C6506.1 101.92,36.96 v2(102.19,36.69)
CARD1_USB20_CON_N: length 6.8
  BOTTOM w0.127: EL6601.3 204.46,39.43 204.34,39.56 202.51,39.56 201.78,40.29 201.37,40.29 ED6601.1 201.12,40.06 200.9,40.28 200.72,40.28 200.47,40.03 200.47,39.69 200.82,39.35 201.17,39.35 201.3,39.22 IOBD1.5
CARD1_USB20_CON_P: length 7
  BOTTOM w0.127: EL6601.2 204.51,40.11 204.19,39.8 203.83,39.8 ED6601.6 203.32,39.8 202.61,39.8 201.88,40.53 200.63,40.53 200.23,40.13 200.23,39.59 200.8,39.02 IOBD1.6
CARD1_USB20_N: length 156.4
  L3 w0.089: v1(118.27,102.29) 118.16,102.18 118.03,102.18 117.89,102.32 117.89,104.7 117.9,104.71 117.9,104.73
  L3 w0.114: v1(208.99,45.73) 209.03,45.76 209.29,45.76 212.67,49.15 212.67,50.1 213.26,50.7 213.26,51.64 212.28,52.61 212.28,52.8 212.28,52.8 212.28,54.41 212.65,54.78 212.65,56.12 212.11,56.65 211.76,57 211.47,57 209.93,58.53 209.93,58.75 208.71,59.98 204.44,59.98 204.05,60.37 191.58,60.37 189.35,58.13 181.56,58.13 181.05,58.65 178.68,58.65 168.16,69.17 168.16,71.04 157.52,81.68 157.52,85.07 135.74,106.84 135.74,112.29 135.05,112.98 127.76,112.98 123.17,108.4 123.17,107.05 122.55,106.43 119.56,106.43 117.9,104.77 117.9,104.73
  BOTTOM w0.127: 208.62,44.08 209.16,44.62 209.17,44.62 209.43,44.88 209.43,45.37 209.43,45.37 209.43,45.68 209.27,45.84 209.09,45.84 208.99,45.74 v1(208.99,45.73) ; 208.62,44.08 v2(208.77,43.94) ; 208.62,44.08 208.33,43.79 208.02,43.79 207.66,43.44 207.66,42.75 207.24,42.33 207.24,42.26 207.22,42.24 207.22,40.22 206.87,39.87 206.49,39.87 206.37,39.75 206.37,39.64 206.16,39.43 EL6601.4 ; CPU1.CG8 118.25,102.26 118.27,102.33 v1(118.27,102.29)
CARD1_USB20_P: length 156.2
  L3 w0.089: v1(118.29,101.65) 117.7,102.24 117.7,104.61 117.69,104.63 117.69,104.71 117.67,104.72 117.67,104.73
  L3 w0.114: 117.67,104.73 117.67,104.86 119.47,106.66 122.46,106.66 122.95,107.14 122.95,108.5 127.66,113.21 135.15,113.21 135.97,112.39 135.97,106.94 157.75,85.16 157.75,81.78 168.39,71.13 168.39,69.26 178.78,58.88 181.14,58.88 181.66,58.36 189.25,58.36 191.49,60.6 204.14,60.6 204.53,60.21 208.8,60.21 210.16,58.85 210.16,58.62 211.56,57.23 211.86,57.23 212.21,56.88 212.87,56.21 212.87,54.68 212.51,54.32 212.51,52.9 212.51,52.71 213.49,51.73 213.49,50.6 212.9,50.01 212.9,49.05 209.43,45.58 209.43,45.55 209.17,45.29 209.16,45.29 209.15,45.28 209.09,45.28 208.99,45.18 v1(208.99,45.06)
  BOTTOM w0.127: 206.97,40.49 206.97,42.34 207,42.36 207,42.43 207.42,42.85 207.42,43.54 207.92,44.03 208.23,44.03 208.9,44.7 208.9,44.97 v1(208.99,45.06) ; 206.97,40.49 v2(206.81,40.49) ; 206.97,40.49 206.97,40.32 206.77,40.11 EL6601.1 ; CPU1.CG9 v1(118.29,101.65)
CBN: length 7.6
  TOP w0.203: HDA27.28 27.93,10.89 29.06,9.75 29.06,9.49 v1(29.09,9.46)
  TOP w0.254: v2(31.78,7.72) 31.91,7.6 31.91,7.21 v1(31.96,7.16) 31.98,7.14 32.69,7.14 C2708.1
  L3 w0.254: v1(31.96,7.16) 31.88,7.16 29.58,9.46 v1(29.09,9.46)
CBP: length 5.5
  TOP w0.203: HDA27.30 29.14,10.87 29.33,10.87 29.35,10.85 29.39,10.85 29.7,10.54
  TOP w0.254: C2708.2 32.79,8.84 32.06,9.58 31.6,9.79 30.85,10.54 30.77,10.54 30.76,10.54 30.35,10.54 v2(30.34,10.55) 30.31,10.55 30.3,10.54 29.7,10.54
CCD_USB20_CON_N: length 8.3
  BOTTOM w0.127: LCD1.20 218.37,47.55 218.22,47.7 217.89,47.7 216.54,49.05 215.57,49.05 ED5502.1 215.06,49.05 214.55,49.05 213.84,48.33 211.88,48.33 EL5501.2
CCD_USB20_CON_P: length 8.5
  BOTTOM w0.127: 216.36,49.29 216.64,49.29 217.99,47.94 218.17,47.94 218.28,48.05 LCD1.19 ; 216.36,49.29 214.45,49.29 213.74,48.58 213.1,48.58 ED5502.6 212.66,48.58 212.22,48.58 211.91,48.88 EL5501.3 ; 216.36,49.29 v2(216.36,49.46)
CCD_USB20_N: length 144.2
  L4 w0.114: v1(118.89,113.62) 119.72,113.62 120.63,114.52 122.05,114.52 123.47,113.1 135.11,113.1 135.99,112.21 135.99,107.23 140.59,102.63 140.59,97.78 149.32,89.05 149.9,89.05 153.51,85.45 153.51,84.78 153.9,84.39 153.9,79.65 159.63,73.93 159.63,72.09 164.21,67.51 164.21,67.41 164.25,67.38 164.25,66.82 168.73,62.34 168.73,61.36 175.11,54.97 189.26,54.97 191.07,56.78 194.9,56.78 195.62,56.06 201.12,56.06 202.56,54.61 204.66,54.61 204.99,54.28 208.16,54.28 210.18,52.26 210.18,50.4 210.42,50.16 210.42,49 209.71,48.29 v1(209.71,48.12)
  BOTTOM w0.076: 116.12,108.95 116.11,108.94 116.11,108.9 115.66,108.45 115.66,106.99 115.57,106.66 CPU1.CC1
  BOTTOM w0.127: EL5501.1 209.79,48.2 v1(209.71,48.12) ; v1(118.89,113.62) 118.77,113.49 118.2,113.49 117.94,113.23 ; 117.94,113.23 v2(117.83,113.34) ; 117.94,113.23 117.3,112.59 117.3,110.14 116.12,108.95
CCD_USB20_P: length 144.3
  L4 w0.114: v1(209.52,48.72) 209.82,48.72 210.19,49.09 210.19,50.06 209.95,50.31 209.95,52.17 208.06,54.05 204.9,54.05 204.56,54.39 202.47,54.39 201.02,55.83 195.52,55.83 194.8,56.55 191.16,56.55 189.35,54.74 175.02,54.74 168.5,61.26 168.5,62.25 164.02,66.72 164.02,67.28 163.99,67.32 163.99,67.41 159.4,72 159.4,73.83 153.67,79.56 153.67,84.29 153.28,84.69 153.28,85.36 149.81,88.83 149.22,88.83 140.36,97.69 140.36,102.54 135.77,107.13 135.77,112.11 135.01,112.87 123.38,112.87 121.95,114.29 120.72,114.29 119.82,113.39 119.3,113.39 119.18,113.27 119.18,113.06 119.1,112.98 v1(118.89,112.98)
  BOTTOM w0.076: 116.29,108.78 116.28,108.77 116.23,108.77 115.84,108.38 115.84,106.54 115.77,106.4 CPU1.CC2
  BOTTOM w0.127: EL5501.4 210.2,48.72 v1(209.52,48.72) ; 117.54,112.1 117.54,110.04 116.29,108.78 ; 117.54,112.1 117.54,112.49 118.3,113.25 118.48,113.25 118.75,112.98 v1(118.89,112.98) ; 117.54,112.1 v2(117.67,112.1)
CCG4_FLIP#: length 24.3
  TOP w0.102: R7128.1 36.78,120.7 v1(36.91,120.83) ; R7127.1 32.83,121.91 v1(32.31,121.4) ; U7201.24 v1(42.36,108.43)
  L4 w0.102: v1(42.36,108.43) 42.36,110.83 42.07,111.13 42.07,119.59 40.82,120.83 40.26,120.83 39.76,120.33 37.42,120.33 v1(36.91,120.83)
  BOTTOM w0.102: v1(36.91,120.83) 36.84,120.91 32.81,120.91 v1(32.31,121.4)
CCG4_I2C_INT#: length 88.1
  TOP w0.102: U2401.32 22.78,60.09 22.7,60.02 20.73,60.02 20.46,60.29 20.46,61.35 v2(20.35,61.47) 20.3,61.52 18.19,61.52 18.11,61.44 17.75,61.44 17.46,61.73 17.46,61.92 17.04,62.35 16.09,62.35 15.72,62.72 15.72,63.29 v1(16.03,63.6) ; U7201.8 41.33,113.74 41.07,114 R7215.2 41.51,114.89 41.51,115.58 41.34,115.75 v1(40.31,115.75)
  L4 w0.102: v1(16.03,63.6) 16.67,63.6 19.18,66.11 19.18,66.95 19.78,67.54 19.78,68.08 20.5,68.81 20.5,69.61 21.09,70.2 21.09,71.04 21.76,71.71 22.34,71.71 22.54,71.51 22.9,71.51 23.15,71.76 23.15,72.12 24.97,73.94 37.29,73.94 40.4,77.05 40.4,77.22 40.4,95.6 40.76,95.96 40.76,104.55 39.07,106.25 39.07,114.94 39.88,115.75 v1(40.31,115.75)
CCG4_I2C_SCL: length 11.4
  TOP w0.114: v1(38.42,114.72) 38.45,114.69 38.45,114.63 38.81,114.27 RN7201.3 ; Q2417.6 33.75,112.82 33.47,112.55 v1(33.1,112.55)
  TOP w0.14: RN7201.3 39.04,113.72 39.44,113.32 v2(39.6,113.32) 39.62,113.34 39.8,113.34 40.33,112.81 U7201.10
  L3 w0.127: v1(33.1,112.55) 33.28,112.37 33.7,112.37 35.35,114.02 35.56,114.02 38.27,114.02 38.39,114.14 38.39,114.66 38.42,114.69 v1(38.42,114.72)
CCG4_I2C_SDA: length 13.2
  TOP w0.114: 40.35,113.98 v2(40.83,113.5) U7201.9
  TOP w0.127: RN7201.4 39.9,114.48 40.21,114.48
  TOP w0.14: 40.21,114.48 v1(40.35,114.48) 40.35,113.98 ; Q2417.3 v1(35.05,110.75)
  L3 w0.127: v1(35.05,110.75) 33.94,111.86 33.94,112.25 35.45,113.76 38.43,113.76 38.97,114.3 40.19,114.3 40.31,114.43 40.31,114.44 v1(40.35,114.48)
CCG4_ID_1: length 4.7
  TOP w0.102: v1(43.89,109.81) 44.28,109.81 R7212.2 44.56,109.52 R7214.1 ; U7201.2 42.85,109.66 43.14,109.37 43.14,109.15 43.37,108.92 v1(43.37,108.52)
  L4 w0.102: v1(43.37,108.52) 43.37,109.3 43.5,109.42 43.51,109.42 v1(43.89,109.81)
CEXT: length 2.9
  TOP w0.127: U5802.17 53.3,115.11 53.39,115.02 v1(53.39,114.7)
  BOTTOM w0.203: C5863.1 53.39,114.49 v1(53.39,114.7)
  BOTTOM w0.254: v2(54.61,113.26) 54.61,113.49 53.94,114.16 C5863.1
CFG0: length 36.2
  BOTTOM w0.076: 86.26,107.74 86.54,107.46 86.54,105.28 CPU1.T4
  BOTTOM w0.102: 86.26,107.74 85.14,108.86 74.21,108.86 69.85,104.5 66.82,104.5 66.45,104.13 64.35,104.13 62.9,105.58 v2(60.39,105.58) 59.47,105.58 58.98,105.08 58.98,103.69 R602.1
CFG0_DP_MUX: length 2.8
  TOP w0.102: R5815.2 44.55,114.77 45.02,115.25 45.02,115.55 45.9,116.43 U5802.59
CFG1: length 1.3
  TOP w0.102: TP623.1 86.28,105.11 v1(85.8,105.11)
  BOTTOM w0.102: v1(85.8,105.11) 85.83,105.08 85.83,104.98 86.14,104.67 CPU1.R4
CFG3: length 30.5
  BOTTOM w0.076: CPU1.R3 85.98,105.61 85.93,106.22 85.85,106.46 85.85,106.46 85.85,106.9 85.87,106.92 85.87,107.29 85.53,107.62
  BOTTOM w0.102: R1517.1 v2(61.52,105.07) 63.02,105.07 64.17,103.93 66.53,103.93 66.91,104.3 69.94,104.3 74.22,108.59 84.57,108.59 85.53,107.62
CFG4: length 28.4
  BOTTOM w0.076: CPU1.J4 82.76,104.92 82.76,106.09 82.75,106.13 82.62,106.26 82.41,106.26 82.13,106.54
  BOTTOM w0.102: R1518.1 60.71,103.48 60.71,103.05 62.38,101.38 65.16,101.38 v2(65.38,101.61) 67.27,103.49 70.28,103.49 74.83,108.04 80.67,108.04 82.13,106.58 82.13,106.54
CFG19: length 1.2
  TOP w0.102: TP640.1 84.66,104.65 v1(84.48,104.47)
  BOTTOM w0.102: v1(84.48,104.47) 84.67,104.67 CPU1.N4
CFG_RCOMP: length 1.3
  TOP w0.305: v1(90.56,103.54) 90.53,103.58 R601.1
  BOTTOM w0.305: CPU1.AB5 90.49,103.54 v1(90.56,103.54)
CHG_AMBER_LED#: length 11.5
  BOTTOM w0.102: Q2416.3 22.26,75.47 21.56,75.47 21.09,75.94 21.09,77.25 R2452.2 22.37,78.54 22.37,79.34 v2(22.43,79.4) 22.91,78.93 23.76,78.93 R6408.1 24.48,79.65 25.6,79.65 25.74,79.5 26.34,79.5 27.02,78.83 Q6406.1
CHG_AMBER_LED#_Q: length 82.8
  TOP w0.102: R6405.2 40.08,81.62 Q6407.2 39.8,80.91 39.8,79.98 39.32,79.49 v1(39.32,79.48) 38.92,79.07 v2(38.87,79.07)
  L3 w0.102: v1(24.93,76.23) 25.82,77.12 27.29,77.12 27.42,76.99 28.2,76.21 29.41,76.21 29.79,75.83 31.35,75.83 31.4,75.88 35.79,75.88 36.11,76.2 37.92,76.2 38,76.29 38.08,76.35 38.19,76.46 38.99,77.26 38.99,78.25 38.94,78.3 38.94,79.1 v1(39.32,79.48) 39.74,79.9 39.74,92.14 37.89,93.99 35.84,93.99 35.51,93.66 29.5,93.66 28.66,94.5 28.07,94.5 27.42,95.15 27.42,97.42 27.45,97.45 27.45,101.48 25.4,103.53 25.4,107.6 22.32,110.68 19.87,110.68 18.81,111.74 17,111.74 15.94,110.68 15.64,110.68 v1(15.19,110.23)
  BOTTOM w0.102: v1(24.93,76.23) 24.93,76.76 24.36,77.33 24.36,78.65 ; R6408.2 24.36,78.65 ; 24.36,78.65 Q6406.6 ; v1(15.19,110.23) 14.44,110.23 13.8,109.6 12.65,109.6 12.32,109.93 12.32,110.55 Q6403.B
CHGR_PSYS_IMVP: length 7
  TOP w0.102: PR4671.2 199.84,55.43 200.33,54.94 v2(200.33,54.79) 200.33,53.57 200.78,53.12 200.85,53.12 201.21,52.76 201.21,52.28 200.62,51.69 200.62,51.21 200.76,51.08 200.76,50.59 201.05,50.29 PR4442.2
CLK_ITE8010: length 19.4
  TOP w0.127: v2(216.56,52.83) 216.56,52.53 217.05,52.05 WWAN1.14
  TOP w0.14: WWAN1.14 218.03,52.05 218.18,52.2 218.19,52.2 218.3,52.32 218.3,52.91 218.77,53.37 220.15,53.37 220.94,54.16 220.94,57.04 v1(219.89,58.09) ; R2460.1 213.16,56.01 v1(213.45,55.72)
  BOTTOM w0.14: v1(219.89,58.09) 219.79,58.09 219.45,58.43 218.35,58.43 218.24,58.31 218.24,57.66 216.93,56.35 214.53,56.35 214.18,56.01 213.74,56.01 v1(213.45,55.72)
CLK_PCIE_LAN_REQ#: length 322.3
  TOP w0.089: v1(45.39,79.78) 45.39,79.87 45.92,80.39 45.92,80.75 45.89,80.77 U3101.12
  L4 w0.089: v1(118,88.02) 118.47,87.55 119.21,87.55 119.69,88.03 120.76,88.03 121.42,87.38 128.68,87.38 133.13,82.94 133.13,79.71 134.7,78.14 135.58,78.14 138.96,74.76 139.88,74.76 147.87,66.77 147.87,65.84 150.27,63.45 150.27,61.68 150.8,61.15 152.25,61.15 162.79,50.61 162.79,44.62 158.86,40.69 158.86,40.03 158.4,39.56 156.49,39.56 156.46,39.53 151.1,39.53 149.23,41.41 132.72,41.41 132.08,40.77 128.87,40.77 128.13,41.5 124.68,41.5 121.87,44.31 109.31,44.31 107.52,42.52 102.18,42.52 102.1,42.44 100.33,42.44 100.1,42.21 98.67,42.21 96.71,40.25 94.94,40.25 94.88,40.3 90.99,40.3 90.73,40.04 81.94,40.04 81.78,39.87 74.09,39.87 74.08,39.87 72.69,39.87 72.68,39.87 65.27,39.87 64.89,39.49 59.96,39.49 59.96,39.49 58.42,39.49 57.34,38.41 56.4,38.41 55.99,38 55.75,38 51.54,33.79 38.88,33.79 32.6,27.52 28.74,27.52 27.42,26.2 22.11,26.2 17.16,31.14 17.16,34.82 16.88,35.11 16.88,38.44 16.53,38.78 16.53,39.06 14.83,40.77 14.83,47.76 15.2,48.13 15.2,49.46 16.05,50.31 16.05,52.01 16.67,52.62 16.67,58.19 16.86,58.39 16.86,59.95 v1(16.77,60.03)
  BOTTOM w0.089: v1(118,88.02) 117.99,88.02 117.99,88.02 117.83,88.02 CPU1.CF30 ; v1(16.77,60.03) 16.75,60.03 16.41,60.37 15.54,60.37 13.78,62.13 13.78,62.32 10.67,65.43 10.67,66.65 11.34,67.32 12.38,67.32 13.38,68.32 13.84,68.32 15.41,69.88 15.41,71.34 16.88,72.81 17.9,72.81 20.41,75.32 20.88,75.32 21.04,75.32 21.55,74.81 21.55,74.27 21.75,74.08 22.66,74.08 22.89,73.85 24.65,73.85 25.55,74.76 25.55,75.13 26.31,75.89 27.23,75.89 27.24,75.9 27.26,75.9 27.28,75.93 27.33,75.93 27.54,76.13 37.85,76.13 37.86,76.14 38.09,76.14 39.78,77.83 39.78,77.83 40.36,78.41 40.36,78.41 40.88,78.93 42.1,78.93 42.1,78.94 42.4,78.94 42.41,78.95 42.43,78.95 42.68,79.2 42.68,79.21 v2(43.17,79.71) 43.4,79.94 45.23,79.94 v1(45.39,79.78) 45.39,78.92 45.62,78.7 45.63,78.7 45.64,78.68 45.66,78.68 45.83,78.52 48.53,78.52 49.38,79.37 R1826.2
CLK_PCIE_NVME_REQ#: length 288
  TOP w0.089: v2(162.23,61.39) 162.15,61.47 162.02,63.07 v1(162.09,63.15) ; v1(117.1,87.99) 117.16,87.99 117.61,87.54 117.61,87.18 118.04,86.75 118.04,77.84 118.36,77.52 118.36,77.19 118.9,76.65 119.52,76.65 120.2,77.33 120.2,77.39 120.3,77.49 120.6,77.49 120.6,77.5 121.03,77.5 R1822.2
  L3 w0.089: v1(117.1,87.99) 116.66,87.54 116.66,86.61 117,86.26 118.28,86.26 119.24,87.22 119.96,87.22 120.15,87.03 121.52,87.03 121.8,87.31 127.54,87.31 127.6,87.37 131.49,87.37 133.34,85.52 135.06,85.52 136.55,84.02 141.33,84.02 144.17,81.19 145.73,81.19 145.88,81.04 145.96,80.95 145.96,80.59 145.72,80.35 145.72,79.75 146.17,79.31 146.86,79.31 154.11,72.06 154.14,72.06 162.09,64.11 v1(162.09,63.15) ; v1(21.85,24) 21.85,25.95 17.41,30.39 17.41,30.44 17.41,40.04 16.89,40.55 16.89,42.42 16.04,43.28 16.04,43.66 15.03,44.67 15.03,49.39 16,50.37 16,52.04 16.66,52.7 16.66,57.08 16.19,57.54 15.98,57.54 15.04,58.48 15.04,59.84 14.82,60.07 14.82,62.92 15.12,63.22 15.12,63.94 16.06,64.89 v1(16.23,64.89)
  BOTTOM w0.089: SSD1.52 23.7,24.43 23.08,23.82 22.04,23.82 v1(21.85,24) ; CPU1.CE30 117.09,88.05 v1(117.1,87.99) ; v1(16.23,64.89) 16.33,64.79 20.43,64.79 21.54,63.69 21.54,63.42 22.54,62.42 22.9,62.42 23.43,62.95 23.53,62.95 24.51,62.95 24.64,63.08 25.71,63.08 26.02,62.77 26.93,61.86 26.93,56.55 27.71,55.76 27.71,54.75 28.07,54.39 28.58,54.39 28.73,54.55 30.49,54.55 31.19,53.84 36.8,53.84 37.41,54.46 42.38,54.46 42.71,54.8 55.49,54.8 57.44,56.75 90.67,56.75 95.56,61.65 108.08,61.65 111.54,58.19 146.37,58.19 146.96,57.6 150.3,57.6 150.95,58.26 155.48,58.26 158.44,61.22 160.15,61.22 v1(162.09,63.15)
CLK_PCIE_SD_REQ#: length 14.2
  TOP w0.102: R1823.2 120.24,77.09 119.6,76.46 118.82,76.46 118.16,77.11 118.16,77.43 117.81,77.78 117.81,86.66 v1(117.13,87.35)
  BOTTOM w0.089: CPU1.CE31 117.11,87.4 v1(117.13,87.35)
CLK_PCIE_WLAN_REQ#: length 272.8
  TOP w0.089: R1827.2 41.23,91.47 41.23,92.4 41.8,92.97 41.8,93.94 42.74,94.88 42.74,95.78 AFTP6109.1 43.19,95.97 v1(43.61,95.56)
  L3 w0.089: v1(117.13,86.7) 118.22,86.7 118.92,87.4 120.03,87.4 120.22,87.21 121.45,87.21 121.73,87.49 127.47,87.49 127.53,87.55 131.96,87.55 133.6,85.9 135.13,85.9 136.81,84.22 141.39,84.22 144.25,81.36 145.8,81.36 146.2,80.97 146.2,80.97 146.2,80.48 146.56,80.12 146.57,80.11 146.57,79.85 154.18,72.24 154.21,72.24 162.27,64.19 162.27,63.59 162.55,63.31 v1(162.55,62.71) ; v1(43.75,91.89) 42.97,92.66 42.4,92.66 41.15,91.42 41.15,77.09 37.41,73.35 28.32,73.35 27.36,72.39 27.36,72 25.97,70.61 25.91,70.61 23.86,68.57 23.86,68.15 22.73,67.02 22.73,66.61 22.19,66.07 22.19,65.19 22.17,65.17 22.17,65.15 21.09,64.08 v1(21.09,63.53)
  L4 w0.089: v1(43.61,95.56) 43.07,95.02 43.07,93.1 43.75,92.43 v1(43.75,91.89)
  BOTTOM w0.089: CPU1.CE32 v1(117.13,86.7) ; v1(162.55,62.71) 160.83,61 158.47,61 155.56,58.08 151.02,58.08 150.37,57.42 146.85,57.42 146.26,58.01 111.46,58.01 108,61.47 95.64,61.47 90.74,56.57 57.51,56.57 55.56,54.62 42.85,54.62 42.51,54.28 37.49,54.28 36.87,53.67 31.05,53.67 30.37,54.34 28.79,54.34 28.67,54.22 28,54.22 27.54,54.68 27.54,55.69 26.75,56.48 26.75,61.64 26.75,61.79 25.84,62.7 25.64,62.9 24.71,62.9 24.58,62.77 23.6,62.77 23.5,62.77 22.97,62.24 22.47,62.24 21.18,63.53 v1(21.09,63.53) ; WLAN1.53 43.95,96.67 44.02,96.61 44.02,95.97 v1(43.61,95.56)
CLK_TP_SIO: length 160
  TOP w0.127: U2401.78 38.32,65.29 38.24,65.22 37.77,65.22 37.75,65.2 37.23,65.2 37.22,65.22 36.92,65.22 v1(36.15,65.99)
  TOP w0.14: RN6502.1 103.18,30.93 EC6503.1 103.2,30.56 v1(102.92,30.28) 103.17,30.03 RN6501.4 ; v1(101.65,34.16) 101.46,33.97 v2(101.46,33.5)
  L3 w0.127: v1(101.65,34.16) 101.43,33.94 94.19,33.94 93.96,33.71 93.73,33.71 93.73,33.71 92.45,33.71 91.7,32.96 90.4,32.96 90.05,32.61 78.31,32.61 74.1,28.4 56.01,28.4 55.56,27.95 39.99,27.95 37.69,25.66 23.91,25.66 18.62,30.94 18.62,40.54 18.11,41.06 18.11,43.1 17.27,43.93 17.27,44.05 17.27,44.05 17.27,44.33 17.27,46.52 17.27,46.52 17.27,51.47 17.74,51.94 17.74,52.06 17.87,52.19 17.87,57.03 17.87,57.18 17.87,57.58 17.29,58.17 17.29,59.56 17.47,59.74 17.47,60.32 17.07,60.73 17.07,62.26 17.25,62.44 17.25,64.35 17.34,64.43 17.34,64.44 18.74,65.85 18.93,65.85 19.37,66.29 19.37,68.64 v1(18.87,69.14)
  BOTTOM w0.14: v1(18.87,69.14) 19.58,69.85 20.58,69.85 21.09,69.34 21.41,69.34 21.74,69.01 22.12,69.01 22.15,69.04 24.28,69.04 24.45,69.21 25.05,69.21 25.41,68.85 26.44,68.85 27.13,68.17 28.97,68.17 29.17,67.96 30.58,67.96 31.29,67.25 31.29,67.14 32.84,65.59 35.75,65.59 v1(36.15,65.99) ; v1(101.65,34.16) 101.65,33.25 102.92,31.98 v1(102.92,30.28)
CLKIN_XTAL_LCP: length 24
  BOTTOM w0.114: 123.09,105.97 122.94,105.82 122.44,105.82 122.26,105.64 121.18,105.64 121.02,105.64 CPU1.CM3
  BOTTOM w0.14: R1804.1 C1809.1 135.54,118.95 R1817.1 134.86,118.27 134.86,115.79 130.61,111.54 127.82,111.54 126.43,110.15 126.43,110.14 124.21,107.92 124.21,106.86 123.32,105.97 123.09,105.97
CMP_VIN0: length 3.5
  TOP w0.14: 21.82,65.43 22.63,64.62 22.85,64.62 23.12,64.89 U2401.20 ; 21.82,65.43 21.82,65.38 21.39,64.95 v2(21.39,64.75) ; 21.82,65.43 R2470.2
CMP_VIN0_R: length 90.2
  TOP w0.14: R2470.1 20.96,65.86 21.16,66.07 C2612.1 20.53,67.08 20.11,67.08 20.03,67.16 18.34,67.16 17.29,68.21 v1(17.29,68.38)
  L4 w0.127: v1(28.55,93.97) 30.44,92.08 37.75,92.08 38.18,91.65 38.18,81.28 37.14,80.24 37.14,78.39 36.97,78.22 36.97,77.72 36.19,76.94 28.68,76.94 27.9,77.73 22.51,77.73 17.73,72.94 17.73,70.25 17.4,69.93 17.4,68.49 v1(17.29,68.38)
  BOTTOM w0.14: R2610.1 57.68,91.75 C2613.1 56.75,91.74 55.01,91.74 v2(54.98,91.7) 52.73,89.45 51.6,89.45 50.5,90.55 40.04,90.55 37.65,92.94 34.47,92.94 33.94,93.47 29.37,93.47 28.96,93.07 R2608.2 28.71,93.17 28.71,93.82 v1(28.55,93.97)
CMP_VOUT0: length 197.7
  TOP w0.14: v1(37.7,66.14) 37.7,66.19 37.49,66.39 37.49,67.11 37.5,67.11 37.5,67.55 38.05,68.09 U2401.85 39.57,68.09 39.69,68.19 39.84,68.34 39.84,68.82 40.06,69.04 40.06,69.39 R2607.2
  L3 w0.127: v1(161.73,82.06) 161.7,82.09 161.68,82.09 161.31,82.46 161.31,84.36 160.87,84.8 160.87,86.24 159.95,87.15 159.95,87.15 142.23,104.88 142.23,107.07 140.13,109.17 140.13,109.19 140.13,109.2 140.13,114.85 v1(139.84,115.14)
  BOTTOM w0.14: v1(37.7,66.14) 44.96,66.14 48.26,62.84 74.38,62.84 79.07,67.53 121.61,67.53 123.51,65.63 141.89,65.63 142.93,64.6 143.67,64.6 144.38,65.31 145.9,65.31 148.44,62.76 153.89,62.76 155.5,64.37 155.5,66.9 156.77,68.17 157.14,68.17 158.99,70.02 158.99,74.55 156.47,77.07 156.47,78.64 157.64,79.81 158.4,79.81 159.97,81.38 v2(161.09,81.38) 161.73,82.02 v1(161.73,82.06) ; v1(139.84,115.14) 140.6,115.14 R2602.2 140.84,115.38 R2615.2
CNV_BRI_DT: length 4.3
  TOP w0.102: v1(118.84,93.96) 119.39,93.41 119.44,93.41 v2(119.44,93.41) 119.49,93.36 119.89,93.36 119.93,93.32 120.02,93.32
  TOP w0.14: R2058.2 121.25,93.32 120.02,93.32
  BOTTOM w0.14: CPU1.CJ20 119.32,94.43 v1(118.84,93.96)
CNV_BRI_DT_R: length 208.9
  TOP w0.14: v1(48.15,69.93) 48.32,69.76 48.61,69.76 50.01,71.16 50.01,71.65 51.91,73.55 51.91,80.43 52.13,80.66 52.13,83.58 53.45,84.91 53.45,92.07 53.12,92.41 53.12,97.45 50.08,100.49 47.96,100.49 v2(47.96,100.49) 47.96,100.49 47.08,100.49 46.19,101.38 41.9,101.38 40.46,102.82 v2(39.94,102.82) 39.03,102.82 v1(38.96,102.75) ; R2058.1 120.63,92.66 120.4,92.89 v1(120.39,92.89)
  L4 w0.127: v1(152.43,65.58) 152.42,65.59 151.42,65.59 150.24,66.77 150.24,67.73 141.06,76.9 141.06,77.27 140.57,77.77 140.57,79.17 140.9,79.5 140.9,80.17 141.05,80.32 141.05,81.51 140.27,82.29 140.27,82.86 140.26,82.86 140.26,82.88 137.65,85.5 137.63,85.5 137.62,85.5 137.12,85.5 136.78,85.84 136.7,85.84 136.44,86.1 136.44,86.82 133.86,89.4 132.42,89.4 132,89.82 132,90.04 131.74,90.3 130.44,90.3 128.85,91.89 125.59,91.89 125.52,91.81 122.12,91.81 120.96,92.98 120.5,92.98 120.42,92.89 v1(120.39,92.89)
  BOTTOM w0.14: v1(38.96,102.75) 38.98,102.77 39.2,102.77 39.7,103.27 WLAN1.36 ; v1(152.43,65.58) 149.51,65.58 147.07,68.02 124.5,68.02 122.6,69.92 77.82,69.92 73.21,65.31 52.32,65.31 50.97,66.66 50.97,66.85 51.06,66.94 51.06,67.12 50.83,67.34 50.65,67.34 50.57,67.26 50.37,67.26 48.19,69.45 48.19,69.64 48.15,69.67 v1(48.15,69.93)
CNV_BRI_RSP: length 213.2
  TOP w0.14: R6123.1 35.72,101.03 v2(40.02,101.03) 40.11,101.03 40.59,100.54 45.48,100.54 46.68,99.35 50.04,99.35 52.28,97.11 52.28,92.06 52.62,91.73 52.62,85.25 51.29,83.93 51.29,81 51.07,80.78 51.07,73.9 49.22,72.05 49.21,72.05 48.59,71.43 v1(48.59,70.38) ; RN2001.4 126.01,95.23 125.88,95.1 124.85,95.1 124.47,94.73 124.02,94.73 123.74,95.01 121.94,95.01 121.08,94.16 120.31,94.16 120.17,94.02 120.17,94 v1(120.12,93.95)
  L4 w0.127: v1(151.97,66.04) 151.34,66.04 150.49,66.88 150.49,67.83 141.32,77.01 141.32,77.38 140.91,77.78 140.91,79.03 141.27,79.39 141.6,79.39 141.94,79.74 141.94,81.68 141.56,82.07 140.92,82.07 140.59,82.4 140.59,82.94 137.85,85.68 137.85,87.24 132.95,92.14 125.54,92.14 125.43,92.03 122.22,92.03 120.32,93.94 120.15,93.94 120.14,93.95 v1(120.12,93.95)
  BOTTOM w0.14: v1(120.12,93.95) 120.12,93.98 120.11,93.99 CPU1.CK20 ; v1(48.59,70.38) 51.98,66.99 53.84,65.59 72.93,65.59 77.54,70.2 122.71,70.2 124.62,68.3 147.2,68.3 149.63,65.86 151.79,65.86 v1(151.97,66.04)
CNV_BRI_RSP_R: length 3.4
  TOP w0.14: v1(36.2,103.54) 35.87,103.54 v2(35.4,103.07) R6123.2
  BOTTOM w0.14: WLAN1.22 v1(36.2,103.54)
CNV_RGI_DT: length 5.4
  TOP w0.14: v1(118.02,95) 118.39,94.63 v2(118.39,94.42) 118.41,94.39 118.41,93.59 118.68,93.33 118.68,92.78 119,92.46 119.7,92.46 120.09,92.07 R2057.2
  BOTTOM w0.14: v1(118.02,95) 118.04,95.04 117.98,95.47 CPU1.CG19
CNV_RGI_DT_R: length 209.2
  TOP w0.14: v1(49.52,71.32) 49.52,71.56 51.63,73.67 51.63,80.55 51.85,80.77 51.85,83.7 53.17,85.02 53.17,91.96 52.84,92.29 52.84,97.34 50.07,100.11 v2(49.33,100.11) 46.98,100.11 45.99,101.1 41.66,101.1 40.72,102.05 39,102.05 v2(38.98,102.07) 38.47,102.58 v1(38.47,103.53) R1515.2 37.83,104.26 R1516.1 ; R2057.1 121.45,92.08 121.34,92.2 120.44,92.2 119.78,92.86 119.78,92.92 v1(119.76,92.94)
  L4 w0.127: v1(119.76,92.94) 119.28,93.42 118.65,93.42 118.39,93.68 118.39,94.11 118.67,94.39 120.53,94.39 122.66,92.25 122.67,92.25 122.68,92.25 125.34,92.25 125.49,92.39 133.06,92.39 138.1,87.35 138.1,85.79 140.93,82.96 141.6,82.96 141.9,82.66 141.9,82.12 142.26,81.77 142.26,80.28 142.7,79.83 142.77,79.83 144.37,78.23 144.37,74.31 150.94,67.75 v1(150.94,67.06)
  BOTTOM w0.14: v1(150.94,67.06) 147.46,68.86 124.85,68.86 122.95,70.76 77.07,70.76 72.46,66.15 54.99,66.15 51.82,69.32 51.62,69.32 51.57,69.26 51.37,69.26 51.17,69.46 51.17,69.66 51.23,69.71 51.23,69.91 51.03,70.11 50.83,70.11 50.77,70.05 50.58,70.05 50.38,70.25 50.38,70.45 50.44,70.5 50.44,70.7 49.82,71.32 v1(49.52,71.32) ; WLAN1.32 38.7,103.77 38.47,103.54 v1(38.47,103.53)
CNV_RGI_RSP: length 210.6
  TOP w0.14: R6120.1 37.74,101.4 40.32,101.4 40.91,100.82 45.79,100.82 v2(46.87,99.74) 50.05,99.74 52.56,97.22 52.56,92.17 52.89,91.84 52.89,85.14 51.57,83.81 51.57,80.89 51.35,80.67 51.35,73.78 49.33,71.77 49.33,71.77 49.04,71.48 v1(49.04,70.87) ; v1(118.72,94.98) 119.11,94.6 120.91,94.6 122.06,95.74 125.22,95.74 RN2001.3
  L4 w0.127: v1(118.72,94.98) 119.1,94.6 120.62,94.6 122.75,92.47 122.76,92.46 125.2,92.46 125.39,92.65 133.16,92.65 138.36,87.45 138.36,85.89 141.04,83.21 141.71,83.21 142.16,82.76 142.16,82.23 142.51,81.88 142.51,80.39 142.77,80.13 142.89,80.13 144.63,78.39 144.63,74.42 151.43,67.61 v1(151.43,66.57)
  BOTTOM w0.14: CPU1.CH19 v1(118.72,94.98) ; v1(151.43,66.57) 151.18,66.31 149.59,66.31 147.33,68.58 124.73,68.58 122.83,70.48 77.29,70.48 72.67,65.87 54.04,65.87 v1(49.04,70.87)
CNV_RGI_RSP_R: length 6.3
  TOP w0.14: R6120.2 36.71,102.35 v2(36.6,102.46) 36.2,102.86 v1(36.2,102.9)
  BOTTOM w0.14: WLAN1.34 39.2,103.63 38.65,103.08 38.51,103.08 38.34,102.9 v1(36.2,102.9)
CNV_WR_CLK_DN: length 193.3
  L3 w0.114: v1(153.95,110.03) 153.95,109.5 153.01,108.56 147.67,108.56 142.76,113.47 142.76,115.95 133.03,125.69 109.32,125.69 108.63,124.99 105.68,124.99 105.12,125.55 65.57,125.55 59.5,119.48 57.85,119.48 54.55,116.18 54.55,110.47 51.72,107.65 49.59,107.65 48.97,107.03 48.97,106.17 41.63,98.82 37.1,98.82 36.41,98.13 36.41,96.29 35.85,95.73 v1(35.44,95.73)
  BOTTOM w0.076: CPU1.CN31 121.78,87.7 122.04,87.95 122.67,87.95 122.76,87.86 123.87,87.86 124.69,87.04 124.94,87.04 124.97,87.07 124.99,87.07
  BOTTOM w0.127: v1(153.95,110.03) 153.95,109.53 152.68,108.25 152.68,107.94 149.36,104.61 149.36,101.49 149.04,101.18 141.52,93.66 141.52,93.17 137.58,89.23 136.01,89.23 134.32,87.55 127.63,87.55 127.16,87.07 124.99,87.07 ; v1(35.44,95.73) 35.64,95.54 35.89,95.54 36.08,95.73 36.08,96.47 35.95,96.6 WLAN1.21
CNV_WR_CLK_DP: length 193.3
  L3 w0.114: v1(154.49,109.63) 154.4,109.63 153.11,108.33 147.58,108.33 142.53,113.38 142.53,115.86 132.93,125.46 109.41,125.46 108.72,124.77 105.58,124.77 105.02,125.32 65.67,125.32 59.6,119.25 57.94,119.25 54.77,116.09 54.77,110.37 51.82,107.42 49.69,107.42 49.2,106.94 49.2,106.07 41.72,98.59 37.19,98.59 36.63,98.03 36.63,96.2 35.74,95.3 35.64,95.3 v1(35.44,95.1)
  BOTTOM w0.076: 125.11,86.83 125.11,86.83 ; 124.99,86.83 124.97,86.83 124.94,86.86 124.62,86.86 123.8,87.68 122.69,87.68 122.67,87.7 CPU1.CP31
  BOTTOM w0.127: 125.11,86.83 127.26,86.83 127.73,87.3 134.42,87.3 136.11,88.99 137.68,88.99 141.76,93.07 141.76,93.56 149.28,101.08 149.28,101.08 149.6,101.39 149.6,104.51 152.92,107.84 152.92,108.15 154.4,109.63 v1(154.49,109.63) ; 124.99,86.83 125.11,86.83 ; v1(35.44,95.1) 35.64,95.3 35.99,95.3 36.32,95.63 36.32,96.47 36.45,96.6 WLAN1.23
CNV_WR_DN0: length 193.9
  L3 w0.114: v1(152.77,109.87) 152.81,109.83 152.81,109.45 152.49,109.13 147.94,109.13 143.35,113.72 143.35,116.24 133.32,126.27 109.09,126.27 108.39,125.57 105.91,125.57 105.36,126.12 65.34,126.12 59.28,120.07 57.36,120.07 52.71,115.41 52.71,111.42 52.22,110.93 52.22,109.05 51.39,108.22 49.35,108.22 48.93,107.8 48.07,107.8 47.53,107.26 47.53,105.67 41.36,99.49 35.85,99.49 34.77,98.41 34.77,95.42 34.68,95.33 34.51,95.33 34.39,95.45 34.39,95.82 34.27,95.95 34.15,95.95 v1(33.94,95.73)
  BOTTOM w0.076: 125.03,87.88 124.95,87.95 124.84,87.95 124.48,88.31 122.99,88.31 122.83,88.47 122.65,88.47 CPU1.CR30
  BOTTOM w0.127: v1(152.77,109.87) 152.77,109.3 152.65,109.17 152.39,109.17 152.25,109.03 152.25,108.7 152.05,108.51 152.05,108.19 148.73,104.87 148.73,101.75 148.42,101.44 140.9,93.91 140.9,93.43 137.32,89.86 135.7,89.86 134.04,88.19 127.26,88.19 126.66,87.59 125.32,87.59 125.03,87.88 ; v1(33.94,95.73) 34.24,95.73 34.32,95.65 34.32,95.45 34.43,95.34 34.59,95.34 34.71,95.46 34.71,96.34 34.45,96.6 WLAN1.15
CNV_WR_DN1: length 194.4
  L3 w0.114: v1(32.44,95.73) 32.83,95.73 33.18,96.08 33.18,97.73 35.65,100.2 40.92,100.2 42.31,101.6 42.31,104.09 46.57,108.35 46.67,108.35 46.69,108.38 48.7,108.38 49.81,109.48 49.81,110.87 50.32,111.38 51.32,111.38 51.95,112.01 51.95,115.67 55.3,119.02 55.3,120.09 56.44,121.22 56.91,121.22 57.58,121.9 60.16,121.9 64.96,126.7 105.59,126.7 106.15,126.14 108.13,126.14 108.87,126.87 133.52,126.87 143.95,116.44 143.95,113.95 145.23,112.68 146.15,112.68 146.72,112.11 146.72,111.23 148.24,109.7 151.26,109.7 v1(151.84,110.29)
  BOTTOM w0.076: CPU1.CM30 120.94,88.72 121.61,88.72 121.67,88.77 121.91,88.77 122.06,88.74 122.26,88.74 122.34,88.78 122.38,88.82 122.97,88.82 123.07,88.72 123.13,88.65 124.67,88.65 124.98,88.34 125.36,88.34 125.4,88.38 125.41,88.38
  BOTTOM w0.127: v1(32.44,95.73) 32.64,95.54 32.88,95.54 33.08,95.73 33.08,96.47 32.95,96.6 WLAN1.9 ; v1(151.84,110.29) 151.59,110.03 151.59,108.92 151.43,108.77 151.43,108.45 148.11,105.13 148.11,102.01 147.8,101.69 140.24,94.13 140.24,93.65 137.06,90.48 135.43,90.48 134.97,90.02 133.77,88.83 126.75,88.83 126.3,88.38 125.41,88.38
CNV_WR_DP0: length 194
  L3 w0.114: v1(33.94,95.1) 34.77,95.1 35,95.32 35,98.32 35.94,99.26 41.45,99.26 47.76,105.57 47.76,107.17 48.16,107.57 49.03,107.57 49.45,107.99 51.48,107.99 52.45,108.96 52.45,110.84 52.94,111.33 52.94,115.32 57.46,119.84 59.37,119.84 65.43,125.9 105.26,125.9 105.82,125.34 108.48,125.34 109.18,126.04 133.23,126.04 143.12,116.15 143.12,113.63 147.84,108.9 152.59,108.9 153.14,109.45 v1(153.25,109.45)
  BOTTOM w0.076: CPU1.CP30 122.42,88.13 124.41,88.13 124.83,87.71 124.85,87.71
  BOTTOM w0.127: 124.85,87.71 125.22,87.35 126.76,87.35 127.36,87.95 134.14,87.95 135.8,89.61 137.42,89.61 141.14,93.33 141.14,93.81 148.66,101.34 148.97,101.65 148.97,104.77 152.29,108.09 152.29,108.41 153.25,109.36 v1(153.25,109.45) ; WLAN1.17 34.95,95.36 34.69,95.1 v1(33.94,95.1)
CNV_WR_DP1: length 194.4
  L3 w0.114: v1(152.15,109.73) 152.03,109.85 151.73,109.85 151.35,109.48 148.15,109.48 146.49,111.13 146.49,112.02 146.06,112.45 145.14,112.45 143.73,113.86 143.73,116.35 133.43,126.65 108.96,126.65 108.23,125.91 106.06,125.91 105.5,126.47 65.05,126.47 60.25,121.67 57.68,121.67 57,120.99 56.53,120.99 55.53,119.99 55.53,118.92 52.17,115.57 52.17,111.91 51.41,111.15 50.42,111.15 50.04,110.78 50.04,109.39 48.8,108.15 46.79,108.15 46.76,108.12 46.67,108.12 42.54,103.99 42.54,101.5 41.02,99.98 35.75,99.98 33.4,97.63 33.4,95.98 32.93,95.51 32.85,95.51 v1(32.44,95.1)
  BOTTOM w0.076: CPU1.CN30 121.42,88.54 121.69,88.54 121.74,88.59 121.89,88.59 122.05,88.56 122.31,88.56 122.45,88.64 122.45,88.64 122.89,88.64 123.06,88.48 124.6,88.48 124.91,88.16 125.44,88.16 125.46,88.14
  BOTTOM w0.127: v1(152.15,109.73) 151.83,109.41 151.83,108.82 151.67,108.67 151.67,108.35 148.35,105.03 148.35,101.91 148.04,101.59 140.48,94.03 140.48,93.55 137.16,90.24 135.53,90.24 135.07,89.78 133.87,88.58 126.85,88.58 126.4,88.14 125.46,88.14 ; v1(32.44,95.1) 32.64,95.3 32.98,95.3 33.32,95.63 33.32,96.47 33.45,96.6 WLAN1.11
CNV_WT_CLK_DN: length 195.8
  L4 w0.114: v1(47.52,95.54) 47.81,95.25 48.25,95.25 48.4,95.4 48.4,97.2 50.78,99.58 53.34,99.58 56.35,102.59 56.35,111.19 56.35,111.29 56.35,113.18 58.09,114.93 58.09,117.64 55.63,120.1 55.63,122.86 56.15,123.38 59.78,123.38 59.99,123.17 71.3,123.17 72.66,124.52 104.69,124.52 105.26,123.95 109.05,123.95 110.67,125.57 112.14,125.57 112.95,126.38 118.37,126.38 118.98,126.99 132.76,126.99 142.88,116.87 142.88,112.68 143.97,111.59 143.97,109.86 147.17,106.66 147.17,101.91 148.11,100.97 148.84,100.97 150.45,99.36 v1(150.45,99.19)
  BOTTOM w0.076: CPU1.CP34 122.23,85.9 122.36,85.97 122.46,86.02 122.46,86.02 122.86,86.02 123.57,85.31 123.57,85.02 123.61,84.98 123.61,84.93 123.62,84.92
  BOTTOM w0.127: v1(47.52,95.54) 47.74,95.32 48.26,95.32 48.45,95.52 WLAN1.71 ; 123.62,84.92 123.71,84.83 123.71,82.78 124.82,81.68 124.82,81.4 126.7,79.52 127.03,79.52 127.36,79.19 130.92,79.19 133.71,81.97 133.71,83.01 133.71,83.86 136.97,87.12 138.45,87.12 143.63,92.3 143.63,92.56 149.49,98.42 149.77,98.42 150.32,98.97 150.32,99.06 v1(150.45,99.19)
CNV_WT_CLK_DP: length 195.9
  L4 w0.114: v1(47.52,94.91) 47.63,95.02 48.35,95.02 48.63,95.31 48.63,97.11 50.88,99.35 53.44,99.35 56.58,102.49 56.58,111.19 56.58,113.09 58.32,114.83 58.32,117.73 55.85,120.2 55.85,122.76 56.25,123.15 59.69,123.15 59.9,122.94 71.4,122.94 72.75,124.3 104.6,124.3 105.17,123.72 109.15,123.72 110.77,125.34 112.24,125.34 113.05,126.15 118.46,126.15 119.07,126.76 132.67,126.76 142.65,116.78 142.65,112.58 143.74,111.49 143.74,109.76 146.94,106.56 146.94,101.81 148.02,100.74 148.75,100.74 149.81,99.67 v1(149.81,99.16)
  BOTTOM w0.076: 123.79,85.09 123.75,85.13 123.75,85.39 123.04,86.1 122.94,86.2 122.39,86.2 122.35,86.17 122.29,86.13 122,86.13 121.94,86.19 121.47,86.19 CPU1.CN34
  BOTTOM w0.127: 123.79,85.09 123.95,84.93 123.95,82.88 125.06,81.78 125.06,81.5 126.8,79.76 127.13,79.76 127.46,79.43 130.82,79.43 133.47,82.07 133.47,82.91 133.47,83.96 136.87,87.36 138.35,87.36 143.39,92.4 143.39,92.66 149.39,98.67 149.67,98.67 149.81,98.81 v1(149.81,99.16) ; v1(47.52,94.91) 47.69,95.08 48.36,95.08 48.69,95.42 48.69,96.39 48.95,96.65 WLAN1.73
CNV_WT_DN0: length 196.3
  L3 w0.114: v1(45.11,95.73) 44.78,95.41 44.53,95.41 44.36,95.58 44.36,96.97 43.9,97.42 43.9,99.92 50.81,106.83 52.07,106.83 55.35,110.11 55.35,112.6 56.11,113.36 56.11,114.66 59.28,117.83 59.96,117.83 60.68,118.55 60.68,119.5 65.93,124.75 104.79,124.75 105.35,124.19 108.96,124.19 109.61,124.85 132.67,124.85 134.79,122.74 134.79,122.58 134.7,122.49 134.7,122.13 134.99,121.84 135.34,121.84 135.43,121.93 135.59,121.93 135.76,121.77 135.76,121.6 135.67,121.51 135.67,121.16 135.96,120.87 136.31,120.87 136.4,120.96 136.57,120.96 141.91,115.61 141.91,113.16 147.36,107.71 153.4,107.71 153.77,108.08 154.1,108.08 154.1,108.08 v1(154.38,108.08)
  BOTTOM w0.076: 125.09,85.55 125.08,85.56 125.08,85.61 123.44,87.25 122.69,87.25 122.68,87.26 122.45,87.26 122.44,87.25 122.07,87.25 122.07,87.26 121.77,87.26 121.76,87.25 121.44,87.25 CPU1.CN32
  BOTTOM w0.127: WLAN1.65 46.95,96.84 47.03,96.76 47.03,96.58 46.42,95.97 46.42,95.63 46.1,95.31 45.76,95.31 45.65,95.42 45.65,95.9 45.56,95.99 45.36,95.99 v1(45.11,95.73) ; v1(154.38,108.08) 154.38,107.95 154.23,107.8 154.05,107.8 153.83,108.02 153.67,108.02 153.54,107.89 153.54,107.58 150.22,104.26 150.22,101.13 149.9,100.82 149.9,100.82 142.38,93.3 142.38,92.81 137.94,88.37 137.11,88.37 137.11,88.37 136.46,88.37 132.46,84.38 132.46,82.49 130.46,80.48 128.05,80.48 127.77,80.76 127.22,80.76 126.06,81.92 126.06,82.23 125.6,82.69 125.6,85.04 125.09,85.55
CNV_WT_DN1: length 196.4
  L3 w0.114: v1(155.55,108.16) 155.55,108.12 154.53,107.11 153.28,107.11 153.17,106.99 153.17,106.61 152.92,106.36 152.5,106.36 152.25,106.61 152.25,106.99 152.14,107.11 151.91,107.11 151.79,106.99 151.79,106.61 151.55,106.36 151.13,106.36 150.88,106.61 150.88,106.99 150.77,107.11 150.54,107.11 150.42,106.99 150.42,106.61 150.17,106.36 149.76,106.36 149.51,106.61 149.51,106.99 149.39,107.11 149.17,107.11 149.05,106.99 149.05,106.61 148.8,106.36 148.39,106.36 148.14,106.61 148.14,106.99 148.02,107.11 147.09,107.11 141.53,112.67 141.53,112.7 141.28,112.95 141.28,115.35 138.18,118.46 138.02,118.46 137.39,117.83 137.04,117.83 136.74,118.12 136.74,118.48 137.37,119.1 137.37,119.26 137.21,119.43 137.05,119.43 136.57,118.95 136.22,118.95 135.93,119.25 135.93,119.68 131.4,124.2 115.89,124.2 115.37,123.69 113.71,123.69 113.12,124.27 109.85,124.27 109.19,123.61 105.12,123.61 104.55,124.18 66.5,124.18 61.5,119.18 61.5,118.14 60.1,116.74 59.54,116.74 57.08,114.28 57.08,112.95 55.93,111.81 55.93,109.86 52.3,106.22 51.11,106.22 46.1,101.22 46.1,100.07 45.61,99.58 45.61,98.98 45.49,98.85 45.28,98.85 v1(45.06,99.06)
  BOTTOM w0.076: CPU1.CP33 122.24,86.45 123.19,86.45 124.43,85.2 124.43,84.91 124.4,84.88 124.4,84.86
  BOTTOM w0.127: v1(45.06,99.06) 45.27,99.27 45.45,99.27 45.71,99.02 45.71,98.48 45.45,98.22 WLAN1.59 ; 124.4,84.86 124.4,83.01 125.44,81.97 125.44,81.66 126.96,80.14 127.42,80.14 127.74,79.82 130.68,79.82 133.09,82.23 133.09,82.75 133.09,84.12 136.71,87.75 137.36,87.75 137.37,87.75 138.2,87.75 143.01,92.56 143.01,93.04 150.53,100.56 150.53,100.56 151.06,101.09 151.06,104 154.24,107.18 154.49,107.18 155.01,107.69 155.01,107.69 155.47,108.16 v1(155.55,108.16)
CNV_WT_DP0: length 196.3
  L3 w0.114: v1(45.11,95.07) 45,95.18 44.44,95.18 44.13,95.49 44.13,96.87 43.67,97.33 43.67,100.02 50.72,107.06 51.98,107.06 55.12,110.21 55.12,112.69 55.88,113.46 55.88,114.76 59.19,118.06 59.87,118.06 60.45,118.64 60.45,119.6 65.83,124.98 104.88,124.98 105.44,124.42 108.86,124.42 109.52,125.08 132.77,125.08 135.01,122.83 135.01,122.48 134.92,122.39 134.92,122.23 135.09,122.07 135.25,122.07 135.34,122.16 135.69,122.16 135.99,121.86 135.99,121.51 135.9,121.42 135.9,121.26 136.06,121.1 136.22,121.1 136.31,121.19 136.66,121.19 142.14,115.7 142.14,113.25 147.46,107.94 153.3,107.94 153.88,108.52 v1(153.92,108.52)
  BOTTOM w0.076: 125.27,85.72 125.25,85.73 125.21,85.73 123.51,87.43 122.78,87.43 122.77,87.44 122.38,87.44 122.37,87.43 122.15,87.43 122.14,87.44 121.69,87.44 121.69,87.43 121.21,87.43 CPU1.CM32
  BOTTOM w0.127: WLAN1.67 47.45,96.83 47.27,96.65 47.27,96.48 46.66,95.87 46.66,95.53 46.2,95.07 v1(45.11,95.07) ; 125.27,85.72 125.84,85.14 125.84,82.79 126.3,82.33 126.3,82.02 127.32,81 127.87,81 128.15,80.72 130.36,80.72 132.22,82.59 132.22,84.48 136.36,88.61 137.01,88.61 137.01,88.61 137.84,88.61 142.14,92.91 142.14,93.4 149.66,100.92 149.66,100.92 149.98,101.23 149.98,104.36 153.3,107.68 153.3,107.99 153.82,108.52 v1(153.92,108.52)
CNV_WT_DP1: length 196.5
  L3 w0.114: v1(155.04,108.64) 155.11,108.35 155.11,108.01 154.44,107.34 153.19,107.34 152.94,107.09 152.94,106.7 152.82,106.59 152.59,106.59 152.48,106.7 152.48,107.09 152.23,107.34 151.81,107.34 151.57,107.09 151.57,106.7 151.45,106.59 151.22,106.59 151.11,106.7 151.11,107.09 150.86,107.34 150.44,107.34 150.19,107.09 150.19,106.7 150.08,106.59 149.85,106.59 149.74,106.7 149.74,107.09 149.49,107.34 149.07,107.34 148.82,107.09 148.82,106.7 148.71,106.59 148.48,106.59 148.37,106.7 148.37,107.09 148.12,107.34 147.19,107.34 141.76,112.77 141.76,112.8 141.51,113.04 141.51,115.45 138.27,118.68 137.92,118.68 137.3,118.06 137.13,118.06 136.97,118.22 136.97,118.38 137.6,119.01 137.6,119.36 137.3,119.66 136.95,119.66 136.48,119.18 136.32,119.18 136.15,119.34 136.15,119.77 131.5,124.43 115.8,124.43 115.28,123.91 113.8,123.91 113.21,124.5 109.76,124.5 109.09,123.84 105.22,123.84 104.64,124.41 66.41,124.41 61.27,119.27 61.27,118.23 60,116.97 59.45,116.97 56.85,114.37 56.85,113.05 55.71,111.91 55.71,109.95 52.21,106.45 51.01,106.45 45.88,101.32 45.88,100.17 45.48,99.77 v1(45.16,99.77)
  BOTTOM w0.076: 124.64,84.86 124.64,84.88 124.61,84.91 124.61,85.28 123.26,86.62 122.47,86.62 122.38,86.71 122.15,86.71 CPU1.CN33
  BOTTOM w0.127: v1(155.04,108.64) 155.04,108.26 154.91,108.14 154.86,108.14 154.83,108.11 154.83,107.89 154.77,107.83 154.77,107.79 154.39,107.42 154.14,107.42 150.82,104.1 150.82,101.19 150.29,100.66 150.29,100.66 142.76,93.14 142.76,92.66 138.1,87.99 137.27,87.99 137.26,87.99 136.61,87.99 132.85,84.22 132.85,82.65 132.85,82.65 132.85,82.33 130.58,80.06 127.84,80.06 127.52,80.38 127.06,80.38 125.68,81.76 125.68,82.07 124.64,83.11 124.64,84.86 ; v1(45.16,99.77) 45.29,99.77 45.95,99.12 WLAN1.61
CNV_WT_RCOMP: length 20
  TOP w0.203: R2101.1 133.7,85.2 132.2,83.69 132.2,82.65 130.33,80.78 128.06,80.78 127.63,80.84 125.17,83.3 v1(125.17,84.76)
  BOTTOM w0.203: CPU1.CP32 122.54,87 CPU1.CR32 123.23,86.98 125.16,85.05 125.16,84.85 125.17,84.84 v1(125.17,84.76)
CNVI_EN#: length 473.4
  TOP w0.089: v1(155.52,35.76) 155.51,35.76 154.51,36.76 154.51,38.22 154.88,38.59 v1(154.89,38.59) ; v1(169.42,38.72) 169.87,39.17 171.22,39.17 176.65,33.74 180.69,33.74 181.07,34.12 182.59,34.12 184.74,36.27 190.27,36.27 190.5,36.04 v1(190.5,36.02) ; R6110.2 47.53,107.19 v2(47.53,106.93) 47.53,106.71 v1(47.09,106.27)
  L4 w0.089: v1(169.42,38.72) 169.42,38.64 166.93,36.15 162.08,36.15 161.5,35.56 156,35.56 155.8,35.76 155.52,35.76 v1(155.52,35.76) ; v1(47.09,106.27) 47.09,106.87 46.73,107.23 46.73,111.72 48.26,113.26 48.26,118.95 50.19,120.88 50.19,124.41 50.45,124.66 51.08,124.66 53.77,127.36 53.77,128.81 59.78,134.81 62.28,134.81 76.13,148.66 95.39,148.66 96.98,147.07 105.03,147.07 106.45,148.49 119.76,148.49 121.85,146.41 127.94,146.41 131.73,150.2 163.63,150.2 166.87,146.95 166.87,125.47 165.27,123.86 165.27,119.12 165.44,118.96 165.44,110.32 164.88,109.76 164.88,109.42 164.07,108.61 163.1,108.61 158.3,103.8 158.3,98.05 167.23,89.11 167.23,81.72 167.23,81.61 179.13,69.72 179.14,69.72 179.9,68.95 179.9,67.97 184.71,63.16 186.89,63.16 189.49,65.76 209.78,65.76 210.11,65.44 218.92,65.44 221.68,62.68 221.68,44.33 220.35,43 219.33,43 217.31,40.98 215.92,40.98 214.19,39.24 213.87,39.24 212.02,37.39 209.53,37.39 207.8,35.66 199.33,35.66 198.16,34.49 192.03,34.49 v1(190.5,36.02) ; v1(125.55,89.38) 128.95,89.38 130.97,87.37 132.26,87.37 134.47,85.16 135.37,85.16 137.01,83.52 138.02,83.52 138.45,83.08 138.45,82.12 138.69,81.89 138.69,79.04 138.45,78.81 138.45,78.78 137.96,78.28 137.96,77.93 138.59,77.3 138.59,76.59 139.45,75.73 140.31,75.73 148.87,67.16 148.87,66.21 151.7,63.38 151.7,62.93 158.29,56.33 158.45,56.33 164.78,50 164.78,43.84 161.44,40.49 161.44,39.89 161.13,39.58 160.07,39.58 159.42,38.93 155.23,38.93 v1(154.89,38.59)
  BOTTOM w0.089: CPU1.CR26 123.44,90.91 123.55,90.8 123.57,90.8 124.16,90.2 124.28,90.2 124.3,90.19 124.31,90.19 124.35,90.19 124.42,90.13 124.65,90.13 124.7,90.08 125.32,90.08 125.55,89.84 v1(125.55,89.38)
CNVI_EN#_R: length 6.1
  TOP w0.102: v2(49.86,107.7) 49.05,107.7 R6110.1 48.97,108.55 R6101.1 48.98,108.64 49.68,109.35 50.24,109.35 50.55,109.04 50.55,108.52 51.26,107.81 Q6102.G
CPU_DP1_CTRL_CLK: length 319.7
  TOP w0.114: v1(20.75,88.76) Q5702.4
  L3 w0.114: v1(116.42,102.22) 117.4,101.24 118.51,101.24 118.99,101.72 119.38,101.72 119.73,102.06
  L3 w0.127: v1(20.75,88.76) 22.6,88.76 24.39,90.55 26.53,90.55 27.33,91.35 36.81,91.35 37.84,90.33 37.84,81.14 37.02,80.33 37.02,77.64 36.84,77.46 35.58,77.46 35.27,77.14 30.88,77.14 30.83,77.08 30.31,77.08 29.93,77.47 28.72,77.47 27.94,78.25 27.81,78.37 21.68,78.37 18.66,75.36 18.66,74.67 15.75,71.76 15.75,70.54 15.27,70.06 15.27,69.39 12.27,66.39 12.27,66.01 v1(12.42,65.86) ; 119.73,102.06 120.29,102.06 121.92,103.7 121.92,104.55 123.14,105.77 123.74,105.77 124.89,106.91 124.89,107.72 128.55,111.38 132.79,111.38 133.76,110.42 v1(134.32,110.42) 134.42,110.32 134.42,109.77 134.78,109.41 134.78,106.51 155.84,85.44 155.84,81.55 163.54,73.85 163.58,73.85 164.22,73.21 164.22,73.18 166.21,71.18 166.38,71.18 167.03,70.53 v1(167.03,69.62)
  BOTTOM w0.127: CPU1.CC8 v1(116.42,102.22)
  BOTTOM w0.14: v1(12.42,65.86) 12.6,65.69 13.52,65.69 13.83,65.37 15.75,65.37 16.01,65.63 16.51,65.63 16.81,65.33 22.02,65.33 22.15,65.46 v2(22.15,65.48) 22.18,65.51 22.18,66.05 22.23,66.11 22.46,66.34 24.62,66.34 25.24,65.72 25.61,65.72 29.19,62.13 31.1,62.13 31.85,61.38 31.85,56.9 33.3,55.45 42.18,55.45 42.37,55.63 55.09,55.63 57.04,57.59 90.32,57.59 95.24,62.51 95.83,62.51 95.83,62.5 108.42,62.5 111.89,59.03 146.75,59.03 146.97,58.81 149.51,58.81 149.88,59.18 154.14,59.18 157.69,62.73 160.31,62.73 164.13,66.55 164.13,67.19 166.57,69.63 167.03,69.63 v1(167.03,69.62) ; v1(134.32,110.42) 134.64,110.73 136.42,110.73 137.05,110.1 137.05,109.95 137.22,109.79 RN401.5
CPU_DP1_CTRL_DATA: length 320.8
  TOP w0.14: Q5702.1 v1(22.62,91.48) 22.62,92.13 v2(22.58,92.18)
  L3 w0.114: v1(116.42,101.58) 116.98,101.02 118.59,101.02 118.78,101.21 120.4,101.21 120.53,101.33
  L3 w0.127: v1(14.07,67.1) 14.07,67.83 15.52,69.28 15.52,69.95 16.01,70.44 16.01,71.65 18.92,74.57 18.92,75.25 21.79,78.12 27.71,78.12 27.83,77.99 27.84,77.99 28.62,77.21 29.82,77.21 30.2,76.83 30.93,76.83 30.99,76.89 35.37,76.89 35.69,77.2 36.94,77.2 37.28,77.54 37.28,77.75 37.28,80.18 38.09,80.99 38.09,90.44 36.92,91.61 27.23,91.61 26.43,90.81 24.28,90.81 22.5,89.03 21.24,89.03 21.1,89.16 21.1,89.76 21.35,90.01 22.42,90.01 23.14,90.73 23.14,90.96 v1(22.62,91.48) ; v1(166.58,70.08) 166.58,70.63 166.28,70.93 166.1,70.93 163.96,73.07 163.96,73.1 163.47,73.59 163.44,73.59 155.58,81.45 155.58,85.34 134.52,106.4 134.52,109.3 134.2,109.63 134.19,109.63 v1(133.91,109.91) 132.69,111.13 128.66,111.13 125.17,107.64 125.17,106.84 123.83,105.49 123.22,105.49 122.44,104.71 122.44,103.24 120.53,101.33
  BOTTOM w0.102: 29.86,63.03 30.9,63.03
  BOTTOM w0.127: CPU1.CC9 v1(116.42,101.58)
  BOTTOM w0.14: 29.86,63.03 28.69,63.03 25.72,66 25.36,66 24.74,66.62 22.35,66.62 21.62,65.89 21.61,65.89 21.34,65.61 16.99,65.61 16.2,66.39 v1(14.07,67.1) ; 30.9,63.03 32.13,61.81 32.13,57.01 33.41,55.73 40.86,55.73 40.89,55.76 42.24,55.9 42.25,55.91 54.97,55.91 56.93,57.87 90.2,57.87 95.12,62.78 95.35,62.78 95.95,62.78 108.53,62.78 112.01,59.31 146.87,59.31 147.09,59.08 149.39,59.08 149.76,59.46 154.02,59.46 157.57,63.01 160.19,63.01 163.85,66.66 163.85,67.35 v1(166.58,70.08) ; RN401.6 137.18,110.37 137.05,110.5 137.05,110.54 136.58,111.01 134.52,111.01 134.37,110.87 134.13,110.87 133.87,110.6 133.87,109.95 v1(133.91,109.91)
CPU_DP1_HPD: length 405.5
  L3 w0.089: v1(16.7,112.54) 16.84,112.4 19.15,112.4 20.13,111.42 22.14,111.42 26.03,107.54 26.03,103.63 27.9,101.76 27.9,97.26 27.87,97.23 27.87,95.34 28.26,94.95 28.78,94.95 29.66,94.06 35.34,94.06 35.67,94.39 38.06,94.39 40.14,92.31 40.14,77.55 38.18,75.59 36.34,75.59 35.31,74.56 29.65,74.56 29.28,74.92 29.28,75.11 29.03,75.35 28.37,75.35 28.36,75.37 28.05,75.37 28.03,75.39 24.96,75.39 24.66,75.09 24.66,74.82 23.33,73.49 21.89,73.49 21.24,72.83 21.24,72.04 21.24,72.04 21.24,71.54 19.26,69.56 18.69,69.56 18.25,69.11 18.25,67.67 18.26,67.65 18.26,66.84 17.91,66.49 17.47,66.49 17.16,66.17 17.16,65.02 16.85,64.71 16.85,64.64 16.76,64.55 16.76,62.65 15.79,61.67 v1(15.79,61.02)
  L4 w0.089: v1(124.44,103.71) 130.89,103.71 131.45,103.15 132.66,103.15 132.83,102.98 133.32,102.98 137.58,98.72 137.58,96.7 140.44,93.85 140.44,93.22 144.57,89.09 144.72,89.09 145.09,88.72 145.1,88.72 145.47,88.35 145.65,88.35 151.07,82.94 151.07,77.83 152.67,76.23 153.03,76.23 156.87,72.39 156.87,70.74 159.01,68.6 159.01,67.79 165.82,60.98 165.82,60.42 176.07,50.16 176.07,46.02 175.08,45.03 175.08,41.63 173.9,38.36 173.89,38.31 173.61,37.54 169.71,33.64 168.14,33.64 167.25,34.53 162.72,34.53 162.33,34.15 161.69,34.15 161.68,34.15 160.69,34.15 158.46,31.92 145.28,31.92 144.17,33.04 135.21,33.04 133.43,34.82 130.72,34.82 130.06,35.48 129.17,35.48 127.53,37.11 124.66,37.11 122.24,39.54 121.46,39.54 120.32,40.68 120.32,41.3 119.68,41.94 112.68,41.94 111.64,40.89 111.64,40 104.54,32.9 101.59,32.9 100.59,33.9 76.65,33.9 73.9,31.15 54.29,31.15 53.52,31.15 52.98,30.61 42.64,30.61 41.83,29.8 36,29.8 32.93,26.73 32.92,26.73 32.34,26.15 28.63,26.15 28.1,25.61 21.88,25.61 16.59,30.91 16.59,34.55 15.5,35.64 15.5,39.2 14.2,40.5 14.2,47.94 14.63,48.37 14.63,49.7 15.38,50.45 15.38,60.6 v1(15.79,61.02)
  BOTTOM w0.089: CPU1.CN6 121.51,103.76 121.75,103.76 121.77,103.78 122.02,103.78 122.15,103.91 122.72,103.91 122.82,104.01 123.24,104.01 123.51,103.73 124.39,103.73 124.41,103.71 v1(124.44,103.71) ; v1(16.7,112.54) 16.64,112.54 16.17,113.01 R5782.1 15.24,112.13 16.01,112.13 16.48,111.66 16.48,110.59 v2(16.18,110.29) 16.18,108.95 16.31,108.82 16.69,108.82 16.83,108.68 16.83,106.67 16.67,106.52 15.43,106.52 Q5703.E
