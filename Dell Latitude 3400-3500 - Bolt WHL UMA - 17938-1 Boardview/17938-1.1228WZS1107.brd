# Allegro board 17938-1.1228WZS1107.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PWR_CHG_CSOP_RR: length 5.3
  TOP w0.254: 189.72,44.72 190.07,44.72 190.55,44.23 191.95,44.23 PR4486.2 ; 189.72,44.72 v2(189.72,44.61) ; 189.72,44.72 188.93,44.72 188.58,44.36 188.58,43.3 PR4424.2
PWR_CHG_DCIN: length 6.7
  TOP w0.254: v2(208.53,53.7) 208.41,53.29 PR4403.1 207.24,52.17 206.41,52.17 206.05,52.16 v1(205.92,52.03)
  BOTTOM w0.203: 206.71,51.33 205.71,51.33 205.2,50.82 PU4401.17
  BOTTOM w0.254: PC4419.1 206.71,51.33 206.02,52.02 205.93,52.02 v1(205.92,52.03)
PWR_CHG_DCIN_R: length 27.4
  TOP w0.254: v1(192.59,39.84) 192.6,39.84 v2(193.1,40.34) 194.6,40.34 194.73,40.46 194.76,40.46 195.08,40.78 195.08,40.81 196.57,42.31 198.05,42.31 v1(198.12,42.24) ; PR4403.2 208.31,50.94 208.73,51.36 v1(208.88,51.36)
  L3 w0.254: v1(208.88,51.36) 208.87,51.36 208.86,51.37 208.65,51.37 207.88,50.6 207.88,49.29 208.21,48.95 208.21,48.53 207.7,48.02 207.7,45.72 205.53,43.55 201.64,43.55 201.3,43.21 201.3,43 200.71,42.41 199.65,42.41 199.44,42.62 198.98,42.62 198.97,42.61 198.5,42.61 v1(198.12,42.24)
  BOTTOM w0.254: PD4407.K 192.59,40.41 v1(192.59,39.84) ; v1(198.12,42.24) 198.17,42.29 PD4401.3
PWR_CHG_HG1_R: length 2.9
  TOP w0.762: v3(191.7,51.94) v2(191.7,53.14) 192.17,53.61 PR4414.2
PWR_CHG_HG2_R: length 12.6
  L3 w0.762: v3(185.55,44.48) 185.55,44.96 189.55,48.96 195.09,48.96 195.62,49.49 v3(195.62,49.64)
  vias: v2(194.95,49.63)
PWR_CHG_LGATE1:
  vias: v2(192.43,48.39) v3(191.77,48.06) v3(201.15,51.47)
PWR_CHG_LGATE2: length 17.9
  L3 w0.762: v3(195.76,50.88) 195.76,50.8 195.63,50.67 188.88,50.67 181.89,43.69 v3(180.9,43.69)
  vias: v2(195.05,51)
PWR_CHG_LGATE2/ASGATE: length 2.3
  BOTTOM w0.203: PU4401.7 200.85,50.04 200.38,50.51 v2(200.38,50.78) 200.32,50.84 200.05,50.84 199.65,50.44 v3(199.65,50.42)
PWR_CHG_NGATE: length 5.9
  TOP w0.356: v3(199.73,47.63) 199.91,47.63 200.16,47.37 v2(200.38,47.37)
  TOP w0.508: PR4453.2 198.49,47.51 PR4480.1 199.62,47.51 v3(199.73,47.63)
  BOTTOM w0.203: PU4401.3 200.64,48.44 199.92,47.71 199.82,47.71 v3(199.73,47.63)
  BOTTOM w0.508: v3(199.73,47.63) 199.73,47.58 198.98,46.82 PC4439.2
PWR_CHG_NTC: length 2.1
  TOP w0.254: PR4491.1 202.33,50.82 v2(201.28,50.82) 201.28,50.73 201.86,50.15 PR4492.1
PWR_CHG_OTGEN: length 7.6
  TOP w0.203: PR4451.1 205.75,47.99 206.47,47.99 v2(206.6,48.12)
  TOP w0.254: v1(207.64,48.75) 207.64,48.85 PR4449.2 206.81,49.33 206.69,49.2 206.12,49.2 205.82,48.9 205.82,48.89 PR4417.2 PR4451.1
  BOTTOM w0.203: PU4401.20 205.91,49.24 205.91,49.24 206.16,49.24 206.27,49.34 206.38,49.34 206.41,49.38 207.01,49.38
  BOTTOM w0.254: v1(207.64,48.75) 207.61,48.77 207.61,49.1 207.33,49.38 207.01,49.38
PWR_CHG_OTGPG: length 12
  TOP w0.254: v1(203.5,45.74) 203.5,45.75 203.43,45.82 203.43,46.18 203.2,46.41 202.72,46.41 202.34,46.03 202.34,45.71 202.04,45.42 201.48,45.42 200.64,46.25 197.77,46.25 PR4448.2 196.9,46.31 TP4411.1 196.17,46.18 PR4447.1
  BOTTOM w0.203: v1(203.5,45.74) 203.51,45.74 203.58,45.67 204.15,45.67 204.45,45.97 204.45,46.4 204.24,46.61 PU4401.26
PWR_CHG_PHASE1: length 5.4
  BOTTOM w0.203: PU4401.10 202.24,51.32 202.04,51.53 202,51.53 201.05,52.48 200.73,52.48 v3(200.68,52.54)
  BOTTOM w0.508: v3(200.68,52.54) 200.2,53.02 200.2,53.77 199.42,54.54 PC4436.1
  vias: v1(189.72,51.51) v2(189.15,51.46) v3(195.08,52.12)
PWR_CHG_PHASE2: length 16.1
  TOP w0.305: AFTP4405.1 184.81,44.63 v3(184.48,44.3)
  L3 w0.762: v3(196.46,47.96) 196.46,46.53 195.02,45.09 188.34,45.09 186.72,43.46 184.79,43.46 184.48,43.77 v3(184.48,44.3)
PWR_CHG_PHASE2_R: length 4.2
  BOTTOM w0.203: PU4401.6 200.3,49.64 v2(200.23,49.57) 199.97,49.84 199.24,49.84 PR4441.2
  BOTTOM w0.254: PR4444.1 198.57,50.29 PR4441.2
PWR_CHG_PROCHOT#: length 4.7
  BOTTOM w0.102: PU4401.23 205.79,48.04 205.83,47.99 206.79,47.99 206.98,48.19 v2(207.24,48.19) 207.3,48.24 208.26,48.24 PR4435.2 208.33,47.97 207.78,47.43 PQ4416.2
PWR_CHG_PROCHOT#_R: length 5.2
  TOP w0.102: PR4472.2 207.75,43.84 207.29,44.3 207.29,44.83 v2(207.43,44.96) 207.33,44.96 206.77,45.52 v1(206.57,45.52)
  BOTTOM w0.102: PQ4416.6 206.7,45.37 206.57,45.5 v1(206.57,45.52) 206.57,45.73 206.87,46.03 207.6,46.03 207.78,45.85 PQ4416.5
PWR_CHG_PROG: length 7
  TOP w0.254: 204.02,46.12 204.02,45.15 204.89,44.28 205.37,44.28 205.46,44.38 PR4493.1 ; 204.02,46.12 v1(203.97,46.17) ; 204.02,46.12 204.19,45.95 204.46,45.95 204.54,46.03 v2(204.55,46.03) 204.55,46.07 204.53,46.1 204.53,46.37 PC4441.1 203.68,46.78 203.36,47.1 203.36,47.48 PR4410.2
  BOTTOM w0.203: v1(203.97,46.17) 203.97,46.2 203.84,46.33 PU4401.27
PWR_CHG_PSYS: length 5
  TOP w0.102: PR4442.1 201.05,48.65 200.92,48.52 PR4413.1 200.92,47.96 201.83,47.04 v1(201.83,45.92)
  BOTTOM w0.102: v1(201.83,45.92) 202.06,46.15 202.11,46.15 202.64,46.68 PU4401.30
PWR_CHG_SNB:
  vias: v2(189.87,49.18)
PWR_CHG_UGATE1: length 4.1
  TOP w0.762: v3(197.17,54.12) 197.03,54.12 196.99,54.08 v2(196,54.08) 195.36,54.08 PR4414.1
  BOTTOM w0.203: v3(202,52.36) 202,52.13 202.64,51.48 PU4401.11
PWR_CHG_UGATE2: length 1.8
  BOTTOM w0.203: v3(199.56,49.25) 199.64,49.17 200.85,49.17 200.92,49.24 PU4401.5
  vias: v2(199.12,49.74)
PWR_CHG_VBAT1: length 3.8
  BOTTOM w0.203: PU4401.31 202.24,46.71 201.99,46.46
  BOTTOM w0.254: 201.99,46.46 201.72,46.46 201.7,46.43 201.62,46.43 201.32,46.13 201.27,46.13 PC4445.1 201.18,45.81 201.58,45.41 PC4440.2 200.76,45.1 PR4478.1
PWR_CHG_VBATIN: length 16.7
  TOP w0.089: R4402.2 185.89,36.86 185.83,36.8 185.8,36.8 v1(185.76,36.76)
  TOP w0.305: v1(175.63,35.66) 174.8,36.5 AFTP4401.1 175.62,37.34 R9338.2
  L5SGND w0.305: v1(185.76,36.76) 185.75,36.75 185.19,36.75 181.66,33.22 176.51,33.22 175.63,34.1 v1(175.63,35.66)
  vias: v2(174.95,35.85)
PWR_CHG_VBATIN_R: length 38.8
  TOP w0.089: R4401.2 185.91,37.64 185.66,37.39 v1(185.65,37.39)
  TOP w0.305: v1(185.65,37.39) 185.65,39.65 185.42,39.88 184.82,39.88 184.5,40.19 184.5,40.24 184.4,40.34 184.4,42.9 185.09,43.59 186.13,43.59 R9337.2 186.18,43.59 186.49,43.59 187.81,44.91 AFTP4406.1 188.22,45.65 193.88,45.65 194.97,46.74 194.97,47.27 194.48,47.77 AFTP4404.1 194.71,48.67 197.75,48.67 197.83,48.59 198.68,48.59 PR4480.2
  L5SGND w0.305: v1(185.65,37.39) 185.65,37.38 185.57,37.38 185.52,37.33 185.16,37.33 181.48,33.65 176.69,33.65 176.29,34.05 v1(176.29,35.66)
  vias: v2(175.72,37.39)
PWR_CHG_VDDP: length 4.4
  BOTTOM w0.203: PU4401.8 201.28,50.44 200.78,50.94 200.78,50.95 200.42,51.31 200.42,51.34
  BOTTOM w0.356: PR4405.1 199.11,52.93 199.11,53.54 199.17,53.6 v2(199.17,53.7)
  BOTTOM w0.508: PR4405.1 199.27,52.75 199.69,52.33 199.69,51.81 PC4421.1 199.69,51.79 199.83,51.64 200.12,51.64 200.42,51.34
PWR_DCBATOUT_1D05V:
  vias: v2(121.36,141.73)
PWR_DCBATOUT_VCCGTA:
  vias: v2(93.51,140.46) v2(100.99,139.93) v3(90.81,140.82) v3(91.64,140.75) v3(91.58,139.55) v3(92.42,139.53) v3(99.8,141.28) v3(100.66,141.2) v3(100.89,142.09)
PWR_DCBATOUT_VCCGTA_C: length 85.3
  TOP w0.102: R9330.2 161.08,144.75 v2(161.56,144.27) 162,144.27 v1(162.12,144.15)
  L2SGND w0.089: v1(84.97,144.93) 84.97,144.86 85.5,144.32 97.6,144.32 98.47,143.45 106.96,143.45 109.08,145.58 118.26,145.58 120.51,143.33 128.79,143.33 130.21,144.75 147.49,144.75 147.67,144.93 152.98,144.93 153.77,144.14 154.49,144.14 154.76,143.87 156.72,143.87 156.82,143.98 157.65,143.98 158.52,143.1 160.88,143.1 161.43,143.65
  L2SGND w0.102: v1(162.12,144.15) 161.93,144.15 161.43,143.65
  BOTTOM w0.102: v1(84.97,144.93) 85.09,144.81 R9312.2 ; PMBD1.3 161.37,143.81 161.6,144.05 162.02,144.05 v1(162.12,144.15)
PWR_DCBATOUT_VCCSA_C: length 55.8
  L2SGND w0.102: v1(108.92,144.55) 109.58,144.55 110.2,145.18 118.1,145.18 120.35,142.93 128.95,142.93 130.38,144.35 147.07,144.35 147.86,143.56 148.47,143.56 149.43,144.53 152.73,144.53 153.54,143.71 154.35,143.71 154.83,143.23 155.31,143.23 v1(155.34,143.2)
  BOTTOM w0.102: PMBD1.17 158.57,142.66 158.34,142.43 157.19,142.43 157.06,142.3 155.68,142.3 155.34,142.64 ; 155.34,142.64 v2(155.34,142.64) ; 155.34,142.64 v1(155.34,143.2) 154.93,143.2 154.62,143.51 R9323.2 ; v1(108.92,144.55) 108.54,144.17 R9318.2
PWR_DCBATOUT_VCORE:
  vias: v2(82.42,144.07) v3(81.28,143.23) v3(81.26,142.37) v3(82.15,140.84) v3(83.04,140.82) v3(83.9,140.77)
PWR_DCBATOUT_VCORE_C: length 64.6
  L2SGND w0.102: v1(105.24,142.65) 105.35,142.75 106.96,142.75 108.13,143.92 109.5,143.92 110.37,144.78 117.93,144.78 120.2,142.52 129.14,142.52 130.56,143.94 136.81,143.94 137.61,143.14 143.15,143.14 144.03,142.25 147.08,142.25 147.14,142.32 147.98,142.32 149.75,144.09 152.58,144.09 153.41,143.26 154.25,143.26 154.98,142.52 156.33,142.52 156.43,142.62 156.47,142.62 v1(157.12,143.28)
  BOTTOM w0.102: R9334.2 155.69,145.19 156.55,144.33 v2(156.55,143.88) 156.55,143.53 156.79,143.28 v1(157.12,143.28) 157.37,143.52 157.37,144.18 158.07,144.89 159.1,144.89 159.37,145.15 PMBD1.14 ; R9308.2 104.74,142.41 105,142.67 105.22,142.67 v1(105.24,142.65)
PWR_DCBATOUT_VDDQ:
  vias: v1(116.8,30.76) v2(117.04,33.15) v3(117.99,32.16) v3(118.88,32.16) v3(119.59,32.93) v3(120.5,32.31)
PWR_DCBATOUT_VDDQ_C: length 215.6
  TOP w0.089: R9317.2 117.78,34.7 117.78,37.94 117.08,38.65 110.95,38.65 108.23,41.37 105.99,41.37 104.94,42.42 103.1,42.42 101.85,43.67 100.53,43.67 100.48,43.72 v2(100.48,43.72) 100.17,44.03 v1(100.17,44.3)
  L4 w0.102: v1(174.65,70.38) 174.5,70.23 173.79,70.23 163.53,80.49 163.53,82.86 162.7,83.68 162.7,86.35 163.34,86.99 163.34,87.93 160.24,91.03 159.41,91.03 158.12,92.33 158.12,93.19 154.99,96.32 154.99,105.76 155.62,106.39 156.57,106.39 162.87,112.69 162.87,116.82 161.21,118.48 161.21,126.99 160.25,127.95 160.25,128.2 160.24,128.2 160.24,134.56 157.67,137.14 157.67,141.44 157.81,141.58 157.81,143.97 158.05,144.21 v1(158.15,144.21)
  BOTTOM w0.089: v1(100.17,44.3) 100.17,45.53 100.86,46.23 100.86,52.14 103.6,54.88 109.45,54.88 109.55,54.98 109.62,54.98 110.66,56.02 145.34,56.02 145.8,55.56 147.7,55.56 148.14,55.12 156.21,55.12 157.04,55.95 162.02,55.95 164.78,58.71 165.52,58.71 167.14,60.32 167.14,62 169.23,64.09 169.23,65.75 170.38,66.89 174.01,66.89 174.63,66.27 175.75,66.27 175.97,66.5 175.97,67.19 174.58,68.59 174.58,70.31 v1(174.65,70.38)
  BOTTOM w0.102: R9325.2 158.52,141.81 159.37,142.66 PMBD1.13 159.37,144.42 159.15,144.63 158.45,144.63 158.15,144.34 v1(158.15,144.21)
PWR_LED#: length 6.6
  TOP w0.102: U2402.4 47.7,65.62 46.33,64.25 46.33,64.01 v2(46.21,63.88) 46.05,63.88 45.85,64.09 R6412.1 45.34,64.03 44.88,63.58 43.87,63.58 43.6,63.85 Q6402.S
PWR_LED#_C: length 3.8
  TOP w0.203: AFTP6407.1 212.58,58.06 v1(212.58,58.54) 212.58,59.42 R6410.2
  BOTTOM w0.203: PWR1.4 212.95,57.06 212.4,57.6 212.4,58.36 v1(212.58,58.54)
PWR_LED#_Q: length 256
  TOP w0.089: v1(210.58,66.16) 208.16,63.74 v1(208.16,63.65) ; Q6402.D 43.72,65.43 v1(43.72,65.38) 43.72,65.14 44.48,64.39 R6412.2 ; v2(27.74,50.67) 27.92,50.67 28.27,50.32 v1(28.37,50.32)
  L3 w0.089: v1(208.16,63.65) 206.91,64.9 190.51,64.9 187.68,62.07 184.22,62.07 180.27,66.03 177.96,66.03 177.29,66.7 175.55,66.7 175.53,66.71 v1(175.52,66.71) ; v1(43.72,65.38) 43.68,65.43 42.07,65.43 41.53,64.89 41.53,63.38 41.15,62.99 38.84,62.99 38.22,63.62 36.15,63.62 35.54,63.02 35.54,60.25 34.23,58.94 32.45,58.94 30.69,57.18 30.69,54.4 30.69,54.07 27.9,51.27 27.9,50.79 v1(28.37,50.32)
  BOTTOM w0.089: v1(28.37,50.32) 28.76,50.71 28.76,50.77 28.77,50.78 28.77,51.15 29.78,52.15 37.52,52.15 38.12,52.76 43.1,52.76 43.42,53.07 56.2,53.07 58.2,55.07 109.37,55.07 110.66,56.36 145.48,56.36 145.95,55.9 147.84,55.9 148.28,55.46 156.07,55.46 156.91,56.29 161.89,56.29 164.64,59.05 165.38,59.05 166.79,60.47 166.79,62.14 168.88,64.24 168.88,65.67 170.3,67.08 174.09,67.08 174.2,66.97 174.47,66.7 175.49,66.7 175.5,66.71 v1(175.52,66.71) ; v1(210.58,66.16) 210.53,66.12 210.53,66.1 209.97,65.53 199.37,65.53 197.37,63.54 197.37,61.99 197.18,61.8 195.96,61.8 194.94,60.77 194.94,60.77 194.52,60.36 194.52,58.24 194.63,58.13 194.63,58.13 194.73,58.03 194.73,58.03 194.87,57.89 195.33,57.89 195.34,57.88 195.47,57.75 195.64,57.58 195.87,57.35 195.87,57.34 195.97,57.24 195.97,55.72 196.96,54.73 197.75,54.73 197.78,54.73 198.01,54.5 Q6405.B
PWR_LED#_R: length 18.5
  TOP w0.203: v1(206.93,58.43) 206.56,58.81 v2(206.56,58.98) ; v1(212.01,58.87) 212.01,58.89 211.64,59.26 R6410.1
  L4 w0.203: v1(212.01,58.87) 211.94,58.94 209.62,58.94 208.82,58.15 207.22,58.15 v1(206.93,58.43)
  BOTTOM w0.203: v1(206.93,58.43) 206.46,58.9 205.18,58.9 204.85,58.57 204.85,58.12 204.67,57.94 202.68,57.94 EC6405.1 201.45,57.05 198.58,57.05 197.98,56.45 197.71,56.45 197.68,56.42 Q6405.C
PWR_VCCGT_BOOTA: length 4.4
  TOP w0.508: v1(96.93,141.59) 96.82,141.48 95.99,141.48 95.3,142.17 PR4826.2 94.7,141.76 v2(94.26,141.76)
  BOTTOM w0.305: v1(96.93,141.59) 96.95,141.59 97.31,141.24 PU4801.5
PWR_VCCGT_BOOTA_RC: length 2.5
  TOP w0.508: v2(94.41,144.58) PR4826.1 95.31,143.69 PC4808.1
PWR_VCCGT_BOOTB: length 2.9
  BOTTOM w0.305: v2(88.76,142.36) 88.59,142.19 PU4802.5
  BOTTOM w0.508: PR4810.2 88.76,142.42 v2(88.76,142.36)
PWR_VCCGT_BOOTB_RC: length 2.5
  BOTTOM w0.203: v2(91.89,144.1) 91.58,144.1 91.11,144.57 PC4811.1
  BOTTOM w0.508: PR4810.1 PC4811.1
PWR_VCCGT_BOOTRA: length 3.2
  TOP w0.406: PC4808.2 97.05,142.37 97.16,142.25 97.21,142.25 v1(97.89,141.57)
  BOTTOM w0.305: v2(97.48,141.98) v1(97.89,141.57) 98,141.46 98.07,141.46 98.31,141.23 PU4801.7
PWR_VCCGT_BOOTRB: length 3
  BOTTOM w0.305: PU4802.7 89.59,141.48 v2(89.92,141.81)
  BOTTOM w0.508: v2(89.92,141.81) 90.86,142.75 PC4811.2
PWR_VCCGT_COMP: length 5.3
  TOP w0.254: PR4626.2 138.89,143.13 PC4610.2 138.03,143.18 v2(137.98,143.13) 137.98,141.68 137.59,141.3 v1(137.59,140.88)
  BOTTOM w0.203: PU4601.4 137.36,140.63 137.52,140.79 137.52,140.87 137.59,140.87 137.59,140.88 v1(137.59,140.88)
PWR_VCCGT_COMP1: length 3.1
  TOP w0.254: PR4626.1 v2(139.75,141.42) 139.78,141.45 139.85,141.45 140.31,141.91 140.31,142.28 PC4612.1 PC4651.1
PWR_VCCGT_FB: length 8.5
  TOP w0.381: PR4633.2 PR4636.2 142.84,141.6 PR4630.2 142.33,141.09 140.66,141.09 139.82,140.26 v2(139.82,140.13) 139.8,140.11 138.15,140.11 v1(137.93,140.34)
  BOTTOM w0.203: v1(137.93,140.34) 137.82,140.23 PU4601.5
PWR_VCCGT_FB1: length 2.3
  TOP w0.305: PC4614.1 142.04,142.02 PR4630.1 141.22,141.86 v2(140.97,141.61)
PWR_VCCGT_FB2: length 5.5
  TOP w0.305: v2(144.46,144.47) 144.46,144.22 144.35,144.11 144.35,144.01 v1(144.25,143.9)
  TOP w0.381: PR4633.1 143.68,143.12 PC4618.2 144.18,143.83 v1(144.25,143.9)
  BOTTOM w0.381: PC4619.1 PR4665.2 PR4631.1 143.18,143.28 143.18,143.97 PC4615.2 143.3,143.9 v1(144.25,143.9)
PWR_VCCGT_FB_RC: length 1.8
  TOP w0.305: v2(143.01,144.76) 143.01,144.37 142.76,144.13 PC4618.1 142.76,143.15 PR4636.1
PWR_VCCGT_FCCM#: length 74
  TOP w0.254: v1(86.79,145.59) 86.79,145.37 87.21,144.96 v2(89.2,144.96) 92.09,144.96 93.21,143.84 v1(93.21,143.72)
  L3 w0.254: v1(136.5,137.68) 136.33,137.85 133.66,137.85 133.63,137.82 133.59,137.82 130.72,134.95 130.72,130.8 130.36,130.44 130.36,129.24 129.92,128.79 126.48,128.79 125.71,129.56 107.25,129.56 103.76,133.05 103.76,141.66 100.74,144.68 94.11,144.68 93.28,143.85 93.28,143.81 93.21,143.74 v1(93.21,143.72)
  BOTTOM w0.203: PU4601.11 136.39,137.64 136.43,137.68 v1(136.5,137.68)
  BOTTOM w0.254: PR4806.2 95.1,143.99 94.79,144.3 93.73,144.3 93.28,143.85 93.28,143.81 93.21,143.74 v1(93.21,143.72) ; v1(86.79,145.59) 86.79,145.43 86.9,145.33 PR4812.2
PWR_VCCGT_FCCM#_RA: length 2.3
  BOTTOM w0.254: PR4806.1 95.1,142.4 v2(95.58,141.91) 95.81,141.69 PU4801.2
PWR_VCCGT_FCCM#_RB: length 3
  BOTTOM w0.254: PU4802.2 87.09,141.47 86.7,141.87 v2(86.7,142.57) 86.7,143.31 PR4812.1
PWR_VCCGT_IMON: length 5.6
  BOTTOM w0.203: PU4601.2 137,141.43 137.45,141.89
  BOTTOM w0.254: 137.45,141.89 137.81,141.89 139.25,143.32 139.25,143.47 139.25,143.47 v2(139.25,143.49) 139.25,144.45 PR4608.2 139.47,144.63 PC4604.2
PWR_VCCGT_ISEN1: length 6.9
  BOTTOM w0.203: 137.93,137.85 137.14,138.63 PU4601.9
  BOTTOM w0.254: 137.93,137.85 137.93,137.65 138.89,136.69 PC4625.1 139.42,136.02 PR4669.2 139.42,135.03 PR4821.1 PR4824.2 140.41,135.1 v2(140.41,135.82)
PWR_VCCGT_ISEN2: length 8.3
  TOP w0.254: v1(137.63,137.2) 139.6,137.2 139.74,137.34 v2(139.77,137.34) 139.77,137.37 140.22,137.81 PR4670.1
  BOTTOM w0.203: PU4601.10 136.78,138.23 137.04,137.97
  BOTTOM w0.254: PR4823.1 PR4822.2 138.74,135.31 138.56,135.48 PR4669.1 138.56,136.12 138.48,136.19 138.48,136.24 138.38,136.34 138.38,136.45 PC4626.1 138.03,136.81 137.99,136.81 137.63,137.17 v1(137.63,137.2) 137.63,137.38 137.04,137.97
PWR_VCCGT_ISUMN: length 69.8
  TOP w0.254: PR4647.1 140.97,137.59 v1(140.85,137.47) 139.2,135.82 138.05,135.82 137.98,135.89 v1(137.95,135.89) ; AFTP4603.1 v1(100.28,131.09)
  L4 w0.254: v1(137.95,135.89) 138.97,135.89 140.87,133.99 140.87,133.15 139.77,132.06 139.08,132.06 137.39,130.37 134.04,130.37 132.85,131.57 127.54,131.57 126.97,131 126.97,129.62 126.42,129.07 111.24,129.07 109.32,127.15 109.14,127.15 108.31,126.32 101.18,126.32 100.38,127.12 100.38,130.99 v1(100.28,131.09)
  BOTTOM w0.254: PR4646.2 v1(100.28,131.09) ; 141.76,136.75 PC4633.1 141.07,136.07 PR4815.2 ; 141.76,136.75 PR4643.2 141.61,138.02 PC4630.2 140.97,137.59 v1(140.85,137.47) 140.67,137.29 PR4645.2 140.08,136.83 PC4625.2 139.4,136.96 139.4,137.22 139.37,137.24 139.37,137.87 PR4642.2 ; 141.76,136.75 PR4809.2 ; PC4626.2 137.95,135.97 v1(137.95,135.89)
PWR_VCCGT_ISUMN_GA: length 62.4
  TOP w0.254: v1(142.62,139.12) 143.01,139.5 v2(143.01,139.55)
  L3 w0.254: v1(142.62,139.12) 142.62,138.91 142.19,138.48 142.19,137.87 138.38,134.06 138.38,133.1 v1(138.51,132.97)
  L4 w0.254: v1(138.51,132.97) 138.22,132.97 137.89,132.64 136.88,132.64 135.79,133.73 129.12,133.73 127.78,135.08 124.44,135.08 124.11,134.75 124.11,130.94 123.26,130.09 110.71,130.09 109.72,129.1 106.72,129.1 102.72,133.09 101.25,133.09 99.24,131.08 97.18,131.08 96.78,130.68 96.37,130.68 v1(96.15,130.9)
  BOTTOM w0.254: PR4822.1 138.74,134.04 138.26,133.55 138.26,133.22 v1(138.51,132.97) ; PR4809.1 142.6,139.09 v1(142.62,139.12) ; PG4809.1 96.29,130.76 v1(96.15,130.9)
PWR_VCCGT_ISUMN_GB: length 63.5
  TOP w0.254: v2(88.42,131.4) v1(88.85,130.96)
  L4 w0.254: v1(88.85,130.96) 88.88,130.99 88.88,131.91 89.35,132.39 98.75,132.39 100.75,134.39 103.22,134.39 106.85,130.76 109.47,130.76 110.07,131.36 122.73,131.36 122.84,131.46 122.84,135.27 123.94,136.37 128.28,136.37 129.07,135.59 132.34,135.59 132.67,135.26 138.49,135.26 139.08,134.67 139.08,134.02 v1(139.64,133.47)
  BOTTOM w0.254: PR4815.1 PR4824.1 140.26,134.01 139.72,133.47 v1(139.64,133.47) ; PG4815.1 89,130.81 v1(88.85,130.96)
PWR_VCCGT_ISUMN_P_1: length 4.4
  TOP w0.254: v1(141.23,139.7) 141.23,139.24 PR4647.2
  BOTTOM w0.254: PC4653.2 PC4654.2 PC4628.2 140.67,140.79 v2(141.51,140.79) 141.51,140.74 141.23,140.46 v1(141.23,139.7)
PWR_VCCGT_ISUMN_P_2: length 58.6
  TOP w0.254: v1(143.34,137.19) AFTP4604.1
  L3 w0.254: v1(140.36,133.38) 140.36,134.39 143.16,137.19 v1(143.34,137.19)
  L4 w0.254: v1(140.36,133.38) 139.55,132.56 138.86,132.56 137.18,130.88 134.35,130.88 133.15,132.08 127.31,132.08 126.46,131.23 126.46,129.84 126.2,129.58 110.99,129.58 109.18,127.76 106.45,127.76 106.39,127.71 106.14,127.71 105.33,126.9 101.32,126.9 100.89,127.33 100.89,131.88 v1(100.92,131.9)
  BOTTOM w0.254: v1(143.34,137.19) 143.46,137.31 v2(143.46,138.02) 143.46,138.08 143.13,138.41 143.13,139.67 142.82,139.98 PR4641.2 ; v1(100.92,131.9) 100.89,131.93 100.89,132.01 PR4646.1
PWR_VCCGT_ISUMN_RC: length 1.8
  BOTTOM w0.254: PR4645.1 140.08,138.99 v2(140.11,139.02) 140.06,139.02 139.55,139.02 PC4623.1
PWR_VCCGT_ISUMNB: length 2.8
  BOTTOM w0.203: PU4601.8 137.4,139.03 137.59,138.84 v2(137.6,138.84)
  BOTTOM w0.254: v2(137.6,138.84) 137.65,138.84 137.8,138.69 138.31,138.69 PC4623.2 138.41,137.97 PR4642.1
PWR_VCCGT_ISUMP: length 13.9
  TOP w0.254: v2(142.09,138.71) 141.86,138.94 v1(141.86,139.35)
  L4 w0.254: v1(141.86,139.35) 141.86,136.07 v1(142.41,135.52)
  BOTTOM w0.203: PU4601.7 138.44,139.43 138.81,139.8
  BOTTOM w0.254: v1(142.41,135.52) 141.91,135.03 PR4816.1 ; 138.81,139.8 PC4653.1 PC4654.1 PC4628.1 140.59,139.57 140.97,139.19 PC4630.1 141.18,138.74 PR4643.1 141.79,139.27 v1(141.86,139.35) 141.99,139.47 PR4641.1 141.99,140.34 PR4808.1
PWR_VCCGT_ISUMP_GA: length 62.4
  L3 w0.254: v1(138.9,133.47) 138.76,133.61 138.76,133.9 142.57,137.71 142.57,138.32 143.52,139.27 v1(143.64,139.27)
  L4 w0.254: v1(96.68,131.29) 96.77,131.2 97.03,131.46 99.08,131.46 101.09,133.48 102.88,133.48 106.88,129.48 109.56,129.48 110.56,130.47 123.1,130.47 123.73,131.1 123.73,134.91 124.28,135.46 127.94,135.46 129.28,134.11 135.94,134.11 137.04,133.02 137.73,133.02 138.19,133.48 138.89,133.48 v1(138.9,133.47)
  BOTTOM w0.254: v1(143.64,139.27) 143.87,139.5 143.87,139.89 v2(143.84,139.93) 143.84,140.27 PR4808.2 ; v1(138.9,133.47) 139.04,133.61 139.06,133.61 139.25,133.79 139.25,133.81 139.5,134.06 PR4821.2 ; PG4808.1 96.29,131.67 v1(96.68,131.29)
PWR_VCCGT_ISUMP_GB: length 67.6
  TOP w0.254: v2(90.05,131.27) 89.48,131.27 v1(89.43,131.22)
  L4 w0.254: v1(89.43,131.22) 89.39,131.22 89.26,131.36 89.26,131.75 89.51,132.01 98.9,132.01 100.91,134.01 103.06,134.01 106.69,130.38 109.63,130.38 110.23,130.98 122.89,130.98 123.22,131.31 123.22,135.12 124.09,135.99 128.12,135.99 128.91,135.21 132.18,135.21 132.51,134.88 138.33,134.88 138.7,134.51 138.7,134.16 138.57,134.04 138.03,134.04 v1(137.52,133.53)
  BOTTOM w0.254: PG4813.1 89,131.61 89.39,131.22 v1(89.43,131.22) ; PR4816.2 140.26,132.44 138.28,132.44 137.52,133.2 v1(137.52,133.53) 137.67,133.68 137.67,133.69 137.98,133.99 PR4823.2
PWR_VCCGT_NTC: length 4.4
  BOTTOM w0.203: 138.05,141.36 138.04,141.36 137.39,141.36 137.06,141.03 PU4601.3
  BOTTOM w0.254: PR4616.1 139.8,143.07 139.61,142.88 139.57,142.88 v2(138.46,141.77) 138.05,141.36
PWR_VCCGT_NTC1: length 59.9
  TOP w0.254: v2(142.46,145.91) v1(142.07,145.52)
  L4 w0.254: v1(142.07,145.52) 141.86,145.52 139.65,143.31 138.43,143.31 138.4,143.33 133.79,143.33 133.36,143.77 132.31,143.77 131.75,144.32 130.25,144.32 129.66,143.74 120.88,143.74 118.76,145.86 108.17,145.86 105.97,143.66 99.85,143.66 98.3,142.11 95.69,142.11 93.55,144.25 93.02,144.25 92.68,143.91 92.68,143.87 v1(92.57,143.76)
  BOTTOM w0.254: v1(142.07,145.52) 141.66,145.52 PR4621.2 140.97,144.6 140.31,143.93 PR4616.2 ; v1(92.57,143.76) 92.37,143.76 91.75,143.14 PR4617.1
PWR_VCCGT_PWMA: length 64.5
  TOP w0.254: v1(93.66,143.28) 93.66,143.27 93.78,143.15 94.19,143.15 94.19,143.14 v2(94.24,143.14)
  L3 w0.254: v1(93.66,143.28) 93.67,143.28 93.8,143.28 94.12,143.6 94.12,143.92 94.36,144.17 100.52,144.17 103.25,141.43 103.25,133.26 103.25,132.84 107.04,129.06 125.42,129.06 126.23,128.25 130.2,128.25 130.9,128.96 130.9,130.2 131.29,130.59 131.29,134.8 133.8,137.32 135.66,137.32 v1(136.15,136.83)
  BOTTOM w0.203: v1(136.15,136.83) 136.02,136.83 135.61,137.24 PU4601.12
  BOTTOM w0.254: v1(93.66,143.28) 93.66,143.29 93.78,143.4 93.78,143.58 93.93,143.74 PR4802.2
PWR_VCCGT_PWMA_RA: length 2.7
  BOTTOM w0.254: PU4801.1 95.31,141.32 95.02,141.61 94.62,141.61 v2(94.36,141.86) 94.36,142.29 94.31,142.34 PR4802.1
PWR_VCCGT_PWMB: length 64.2
  L4 w0.254: v1(135.36,136.81) 130.87,136.81 128.73,138.95 125.73,138.95 125.45,139.23 124.35,139.23 120.93,142.65 120.35,142.65 118.8,144.2 114.28,144.2 113.74,143.66 112.75,143.66 112.45,143.96 112.45,144.5 111.99,144.96 110.42,144.96 109.48,144.02 107.55,144.02 104.98,141.45 103.33,141.45 102.09,142.7 99.75,142.7 97.97,140.92 93.14,140.92 91.39,142.67 91.39,143.87 v1(92.71,145.19)
  BOTTOM w0.203: PU4601.13 135.21,136.95 v1(135.36,136.81)
  BOTTOM w0.254: PR4811.2 86.19,144.45 86.19,145.98 86.46,146.25 v2(91.65,146.25) v1(92.71,145.19)
PWR_VCCGT_PWMB_RA: length 3.3
  BOTTOM w0.254: PU4802.1 86.59,141.22 86.19,141.63 v2(85.89,141.63) 85.89,143.3 PR4811.1
PWR_VCCGT_RTN: length 7.9
  BOTTOM w0.203: PU4601.6 138.14,139.83
  BOTTOM w0.254: 138.14,139.83 138.43,140.13 138.43,140.14 138.56,140.27 138.56,140.94 138.85,141.23 139.7,141.23 PR4639.1 140.69,141.48 PC4622.1 141.33,141.45 PR4666.2 141.53,142.29 PC4619.2 141.4,143.1 141.59,143.29 v2(141.59,143.36)
PWR_VCCGT_SNB1: length 2.2
  TOP w0.508: PR4805.2 94.45,135.74 PC4810.1 v2(94.45,137.08)
PWR_VCCGT_SNB2: length 2.9
  TOP w0.508: PR4814.2 88.85,133.78 89.74,134.67 89.74,134.85 v2(89.79,134.9) 89.36,135.33 PC4813.1
PWR_VCCGT_SWA:
  vias: v1(93.6,133.53) v2(93.96,131.27)
PWR_VCCGT_SWB: length 3.2
  TOP w0.508: v2(86.16,131.85) PR4814.1 86.16,134.11 v1(86.82,134.77)
PWR_VCCGT_VCCDA: length 4.6
  BOTTOM w0.305: PU4801.3 96.31,141.8
  BOTTOM w0.508: 96.31,141.8 96.31,142.1 96.02,142.39 PC4809.1 96.02,143.6 96,143.63 v2(96,143.64) 95.76,143.88 95.76,144.28 PR4825.1
PWR_VCCGT_VCCDB: length 3.5
  BOTTOM w0.305: PU4802.3 87.59,141.75 v2(87.66,141.81) 87.66,142.39
  BOTTOM w0.508: PR4813.1 PC4812.1 87.66,142.39
PWR_VCCSA_BST: length 2.9
  TOP w0.305: PR5001.2 111.41,143.94 v1(111.81,144.35) 112.09,144.63 v2(112.37,144.63)
  BOTTOM w0.305: v1(111.81,144.35) 111.74,144.28 PU5001.2
PWR_VCCSA_BST_RC: length 2.9
  TOP w0.305: PR5001.1 112.79,143.21 113.31,142.29 113.31,142.2 113.37,142.09 v2(113.63,141.83) 113.22,141.43 PC5005.1
PWR_VCCSA_COMP: length 5
  BOTTOM w0.203: PU4601.24 131.34,139.43 131.2,139.29 130.67,139.29 130.59,139.22 129.85,139.22 129.47,139.6 129.44,139.6 v2(129.43,139.61)
  BOTTOM w0.254: v2(129.43,139.61) 129.26,139.45 PC4624.1 128.43,139.52 PR4640.1
PWR_VCCSA_COMP_RC: length 1.9
  BOTTOM w0.254: PR4640.2 127.36,138.74 v2(127.46,138.63) 127.38,138.56 PC4601.1
PWR_VCCSA_DRVH: length 9.9
  TOP w0.762: v3(110.42,142.95) 109.15,142.95 106.33,140.13 v2(106.33,139.7) 106.33,137.31 105.11,136.1 v3(105.02,136.1)
PWR_VCCSA_DRVL:
  vias: v2(112.8,139.57)
PWR_VCCSA_FB: length 4.7
  TOP w0.381: v2(130.53,139.09) 130.36,139.27 v1(130.36,139.7) 130.2,139.55 PR4637.1 129.58,139.54 PR4632.2 129.69,138.65 PR4638.2
  BOTTOM w0.203: v1(130.36,139.7) 130.59,139.7 130.66,139.63 131.06,139.63 131.27,139.83 PU4601.25
PWR_VCCSA_FB1: length 2.1
  TOP w0.254: PC4621.2 v2(129.39,137.06) 129.39,137.21 128.83,137.77 PR4638.1
PWR_VCCSA_FB2: length 4.5
  TOP w0.254: v2(126.18,138.86) 126.19,138.84 126.37,138.84 PC4620.1 ; PC4617.2 128.02,139.47 128.63,139.47 PR4637.2 128.71,140.28 PC4616.2 127.99,140.34 PR4601.1
  TOP w0.305: PC4617.2 127.87,139.52 127.1,139.52 PC4620.1
PWR_VCCSA_FB_RC: length 1.6
  TOP w0.254: PC4617.1 127.92,137.9 v2(127.94,137.87)
  TOP w0.305: PC4617.1 128.15,138.66 128.25,138.76 PR4632.1
PWR_VCCSA_FCCM: length 24.5
  TOP w0.254: v1(111.97,139.88) 113.18,138.66 114.36,138.66 115.96,140.26 119.46,140.26 v2(121.44,142.24) 122.2,143 129.44,143 129.97,142.47 v1(130.34,142.47)
  BOTTOM w0.203: PU4601.29 131.45,141.43 131.38,141.5 131.36,141.5 131.23,141.64 131.23,141.65 131.14,141.73
  BOTTOM w0.254: v1(111.97,139.88) 111.74,140.1 PU5001.7 ; v1(130.34,142.47) 130.76,142.47 131.14,142.09 131.14,141.73
PWR_VCCSA_IMON: length 3.6
  BOTTOM w0.203: PC4629.2 129.82,137.9 129.82,138.51 130.08,138.76 v2(130.48,138.76) 130.6,138.76 130.8,138.96 131.34,138.96 131.4,139.03 PU4601.23
  BOTTOM w0.254: PC4629.2 PR4644.1
PWR_VCCSA_ISUMN: length 38.9
  TOP w0.254: v1(112.25,131.9) 112.25,131.85 AFTP4605.1 ; v1(126.37,141.89) 126.08,141.89 v2(125.72,142.25) 125.53,142.44 124.4,142.44 124,142.04 PR5004.2
  L3 w0.254: v1(112.25,131.9) 112.45,132.11 112.45,132.85 113.5,133.9 113.5,136.03 113.96,136.49 113.96,138.46 114.99,139.49 114.99,142.43 114.89,142.53 114.89,144.01 115.48,144.6 119.43,144.6 120.5,143.54 124.92,143.54 126.14,142.32 126.14,142.11 v1(126.37,141.89)
  BOTTOM w0.203: PR4620.1 128.88,141.96 PR4613.1 ; PC4603.2 128.12,142.01 PR4613.1 ; PC4603.2 127.49,143.33 ; PC4603.2 128.83,142.7 PR4615.1 ; PC4605.1 129.16,141.2 PR4618.2 128.5,141.63 PR4613.1
  BOTTOM w0.254: v1(112.25,131.9) 112.32,131.83 112.32,131.22 PR4611.1 ; 127.49,143.33 127.02,143.33 126.37,142.68 v1(126.37,141.89)
PWR_VCCSA_ISUMN_P_1: length 1.9
  BOTTOM w0.203: PC4608.2 127.31,141.58 PR4613.2
  BOTTOM w0.254: PR4613.2 127.18,142.09 v2(127.18,142.88)
PWR_VCCSA_ISUMN_P_2: length 28.7
  TOP w0.254: AFTP4606.1 113.21,132.19 v1(112.96,131.93)
  L3 w0.254: v1(126.22,141.15) 125.58,141.78 125.58,142.14 124.73,142.99 120.26,142.99 119.15,144.1 115.69,144.1 115.4,143.8 115.4,142.74 115.5,142.64 115.5,139.25 114.47,138.22 114.47,136.28 114.02,135.83 114.02,133.71 112.96,132.64 v1(112.96,131.93)
  BOTTOM w0.254: v1(126.22,141.15) PR4625.2 ; v1(112.96,131.93) 112.83,131.8 112.83,130.76 112.4,130.33 PR4611.2
PWR_VCCSA_ISUMN_R: length 26.3
  TOP w0.254: v1(125.82,137.75) 125.82,137.94 v2(124.65,139.11) 124,139.76 PR5004.1
  L3 w0.254: v1(125.82,137.75) 125.82,137.61 125.35,137.14 125.35,136.69 123.59,134.93 123.59,131.54 123,130.96 108.92,130.96 108.66,131.22 v1(108.66,131.4)
  BOTTOM w0.254: PG5001.1 108.36,131.03 108.54,131.21 108.54,131.27 v1(108.66,131.4)
PWR_VCCSA_ISUMN_RC: length 1.9
  BOTTOM w0.254: PC4611.1 129.64,144.17 v2(129.39,144.42) 129.39,144.37 128.88,143.87 PR4615.2
PWR_VCCSA_ISUMNB: length 3.3
  BOTTOM w0.203: PU4601.28 131.16,141.03 130.66,141.53 v2(130.66,141.71) ; PC4611.2 129.64,142.17 PR4620.2
  BOTTOM w0.254: PR4620.2 130.08,142.01 130.38,141.71 v2(130.66,141.71)
PWR_VCCSA_ISUMP: length 6.9
  BOTTOM w0.203: v2(130.33,140.46) 130.46,140.59 131.06,140.59 131.09,140.56 131.76,140.56 PU4601.27
  BOTTOM w0.254: v2(130.33,140.46) 130.22,140.58 129.45,140.58 PC4605.2 129.16,140.29 128.55,140.29 PR4618.1 127.74,140.34 PC4608.1 PR4625.1 126.72,140.13 126.72,139.45 126.57,139.29 PR5003.2
PWR_VCCSA_ISUMP_R: length 26.2
  TOP w0.254: v2(108.59,132.08) 108.03,131.52 v1(108.03,131.42)
  L3 w0.254: v1(126.27,137.25) 125.99,137.25 125.73,136.99 125.73,136.53 123.97,134.77 123.97,131.38 123.16,130.58 108.77,130.58 108.03,131.31 v1(108.03,131.42)
  BOTTOM w0.254: v1(126.27,137.25) 126.33,137.25 126.57,137.49 PR5003.1 ; v1(108.03,131.42) 108.16,131.55 108.16,131.61 108.36,131.81 PG5011.1
PWR_VCCSA_PWM: length 22.5
  TOP w0.254: v2(130.69,143.66) 130.64,143.62 v1(130.64,143.08)
  L4 w0.254: v1(112.96,144.17) 113.49,144.71 119.05,144.71 120.54,143.21 130.51,143.21 v1(130.64,143.08)
  BOTTOM w0.203: PU4601.30 131.83,142.2 131.48,142.54
  BOTTOM w0.254: v1(112.96,144.17) 112.39,144.17 112.24,144.02 PU5001.3 ; 131.48,142.54 131.29,142.74 131.05,142.74 130.7,143.08 v1(130.64,143.08)
PWR_VCCSA_RTN: length 5.5
  TOP w0.254: v1(130.86,140.11) 130.86,140.56 v2(130.56,140.87) 130.03,140.34 PC4616.1 129.57,141.05 PC4613.1 129.44,141.17 PR4627.2 127.94,141.17 PR4602.1
  BOTTOM w0.203: v1(130.86,140.11) 130.99,140.23 PU4601.26
PWR_VCCSA_SW: length 10.3
  TOP w0.305: PC5005.2 110.59,141.43 v3(110.34,141.68)
  TOP w0.762: v3(110.34,141.68) 109.32,141.68 107.65,140.01 v2(107.65,138.33) 107.65,136.3 v3(106.12,134.77)
PWR_VCORE_BOOT: length 3.9
  TOP w0.508: PR4705.2 75.26,142.17 76.13,141.3 v2(76.38,141.3) 77.52,141.3 v1(77.65,141.43)
  BOTTOM w0.305: PU4701.5 77.93,141.21 77.7,141.43 v1(77.65,141.43)
PWR_VCORE_BOOT_RC: length 2.4
  TOP w0.508: PR4705.1 PC4707.1 76.79,144.73 v2(76.89,144.83)
PWR_VCORE_BOOTR: length 3.5
  TOP w0.508: PC4707.2 76.71,142.14 v2(77.78,142.14) 77.93,142.14 78.44,141.63 v1(78.44,141.44)
  BOTTOM w0.305: PU4701.7 78.93,141.17 78.66,141.44 v1(78.44,141.44)
PWR_VCORE_COMP: length 4.1
  BOTTOM w0.203: 134.15,135.93 134.01,136.07 v2(134.01,136.35) PU4601.16
  BOTTOM w0.254: PR4656.1 134.86,134.27 134.66,134.27 PC4639.1 134.28,134.66 134.28,135.81 134.15,135.93
PWR_VCORE_COMP1: length 2
  BOTTOM w0.254: PC4640.1 135.47,132.06 v2(135.03,132.5) 135.03,132.56 135.16,132.69 PR4656.2
PWR_VCORE_FB: length 7
  BOTTOM w0.203: 133.61,136.83 PU4601.17
  BOTTOM w0.305: PR4660.1 133.15,132.11 132.57,132.69 v2(132.57,133.22) 132.57,134.67 132.92,135.03 PR4657.1 132.92,135.9 133.61,136.6 133.61,136.83
  BOTTOM w0.381: PR4660.1 PR4658.1
PWR_VCORE_FB1: length 2.2
  BOTTOM w0.381: PC4641.1 133.3,133.91 v2(133.3,134.58) 133.3,134.67 133.78,135.15 PR4657.2
PWR_VCORE_FB2: length 5.5
  BOTTOM w0.381: 132.21,132.03 131.7,131.52 PC4643.2 131.85,130.63 PC4644.1 ; 132.21,132.03 PR4660.2 ; 132.21,132.03 131.93,132.03 PC4642.2 ; v2(130.69,129.8) 130.97,130.07 PR4667.2 131.09,130.56 PC4644.1 ; PC4644.1 132.06,130.56 PR4663.2
PWR_VCORE_FB_RC: length 2.3
  BOTTOM w0.381: PC4643.1 133.81,131.24 PR4658.2 134.11,131.17 134.64,130.64 v2(134.7,130.64)
PWR_VCORE_FCCM#: length 74
  TOP w0.254: v2(131.16,136.5) 131.16,137.88 v1(131.07,137.97)
  L3 w0.254: v1(131.07,137.97) 132.16,139.07 132.16,139.14 132.34,139.31 132.34,144.2 129.72,146.81 121.91,146.81 119.03,149.69 112.6,149.69 105.14,149.69 103.65,148.2 99,148.2 98.28,148.92 80.21,148.92 v1(74.02,142.72)
  BOTTOM w0.203: PU4601.21 131.45,138.23 131.19,137.97 v1(131.07,137.97)
  BOTTOM w0.254: PR4706.2 74.2,142.93 74.02,142.75 v1(74.02,142.72)
PWR_VCORE_FCCM#_R: length 3
  BOTTOM w0.254: PU4701.2 76.43,141.61 76.37,141.67 76.37,142.79 v2(76.26,142.9) 76.25,142.9 76.23,142.91 76.22,142.91 76.2,142.93 PR4706.1
PWR_VCORE_IMON: length 4
  BOTTOM w0.203: PU4601.14 134.81,136.64 135.18,136.28 135.63,136.28 PC4638.1
  BOTTOM w0.254: PC4638.1 135.72,136.05 135.16,135.49 v2(135.16,135.44) 135.3,135.3 135.93,135.3 PR4661.1
PWR_VCORE_ISUMN: length 75.5
  TOP w0.254: v1(127.53,133.82) 128.16,133.82 AFTP4601.1 128.96,134.62 PR4701.2
  L3 w0.254: v1(82.83,134.04) 82.83,135.18 83.52,135.87 83.52,139.37 85.63,141.48 86.56,141.48 92.02,146.94 97.19,146.94 98.11,146.03 104.2,146.03 105.96,147.79 118.05,147.79 121.03,144.81 125.86,144.81 127.87,142.8 127.87,134.98 128.12,134.73 128.12,134.31 127.64,133.83 127.54,133.83 v1(127.53,133.82)
  BOTTOM w0.254: v1(82.83,134.04) 82.83,133.53 PR4650.1 ; PR4649.2 128.96,133.33 PC4634.1 ; PR4649.2 PR4652.2 ; PR4649.2 128.7,133.71 127.64,133.71 v1(127.53,133.82) 127.53,133.89 127.1,134.31 127.1,134.34 PC4631.1 126.88,135.31 PR4651.2 127.92,135.59 127.94,135.56
PWR_VCORE_ISUMN_G: length 80.4
  TOP w0.254: PR4701.1 129.26,133.12 v2(129.12,133.12) 128.98,133.12 128.86,133.25 127.62,133.25 v1(127.56,133.19)
  L3 w0.254: v1(79.56,130.96) 79.3,131.22 79.3,131.52 79.48,131.7 81.21,131.7 81.97,132.46 81.97,135.03 82.65,135.72 82.65,138.38 81.49,139.55 81.49,141.12 82.35,141.99 86.29,141.99 91.75,147.45 97.4,147.45 98.26,146.58 104.01,146.58 105.72,148.29 118.28,148.29 121.16,145.41 126.07,145.41 128.45,143.03 128.45,138.63 129.04,138.04 129.04,134.5 127.72,133.19 127.56,133.19 v1(127.56,133.19)
  BOTTOM w0.254: PG4708.1 79.15,130.2 79.56,130.61 v1(79.56,130.96)
PWR_VCORE_ISUMN_P_1: length 2.8
  BOTTOM w0.254: PC4652.1 129.67,135.51 PC4635.1 129.06,134.72 PR4649.1 128.75,134.82 128.5,134.57 128.43,134.57 128.07,134.21 v2(128.07,134.14)
PWR_VCORE_ISUMN_P_2: length 71.6
  TOP w0.254: v1(127.61,134.52) AFTP4602.1
  L3 w0.254: v1(83.09,131.78) 83.37,132.06 83.37,134.93 84.03,135.59 84.03,139.16 85.84,140.97 86.77,140.97 92.23,146.43 96.98,146.43 97.89,145.52 104.41,145.52 106.17,147.28 117.83,147.28 120.81,144.3 125.63,144.3 127.36,142.57 127.36,134.77 v1(127.61,134.52)
  BOTTOM w0.254: PR4653.2 130.86,136.65 130.86,136.6 130.3,136.04 129.37,136.04 129.07,135.74 128.93,135.74 128.26,135.08 128.17,135.08 v1(127.61,134.52) ; v1(83.09,131.78) 83.09,132.41 PR4650.2
PWR_VCORE_ISUMN_RC: length 1.9
  BOTTOM w0.254: PC4632.1 125.68,136.4 v2(125.53,136.25) 126.19,135.59 PR4651.1
PWR_VCORE_ISUMNA: length 6
  BOTTOM w0.254: PC4632.2 127.26,136.42 PR4648.1 128.63,136.42 128.81,136.25 ; v2(128.83,136.22) 128.81,136.25 ; 128.81,136.25 128.86,136.25 129.21,136.6 130.14,136.6 130.36,136.81 130.36,137.06 130.61,137.31 131.4,137.31 131.73,137.64 PU4601.20
PWR_VCORE_ISUMP: length 8.3
  BOTTOM w0.203: PR4653.1 132.29,136.73 132.74,137.18 132.74,137.19 132.81,137.26 PU4601.19
  BOTTOM w0.254: PR4653.1 131.04,135.97 130.99,135.97 PC4652.2 130.58,135.51 PC4635.2 PR4652.1 129.67,133.05 PC4634.2 PR4708.2 128.98,131.62 v2(128.98,131.34)
PWR_VCORE_ISUMP_G: length 80.9
  TOP w0.254: v2(128.04,132.16) 128.04,132.72 v1(128.02,132.74)
  L3 w0.254: v1(78.87,130.89) 78.92,130.94 78.92,131.68 79.32,132.08 81.05,132.08 81.59,132.62 81.59,135.19 82.27,135.88 82.27,138.22 81.11,139.39 81.11,141.28 82.19,142.37 86.13,142.37 91.6,147.83 97.56,147.83 98.42,146.97 103.85,146.97 105.56,148.68 118.44,148.68 121.32,145.79 126.23,145.79 128.83,143.19 128.83,138.79 129.42,138.2 129.42,134.35 128.02,132.95 v1(128.02,132.74)
  BOTTOM w0.254: v1(78.87,130.89) 78.87,130.99 79.12,131.24 PG4707.1 ; PR4708.1 128.55,132.23 128.04,132.74 v1(128.02,132.74)
PWR_VCORE_NTC: length 5.6
  BOTTOM w0.203: 134.62,136.24 134.41,136.45 PU4601.15
  BOTTOM w0.254: 134.62,136.24 134.71,136.15 134.71,135.08 135,134.8 135.39,134.8 135.66,134.52 135.66,134.39 135.69,134.35 135.69,134.27 v2(136.04,133.92) 136.04,133.87 135.98,133.81 PR4662.1
PWR_VCORE_NTC1: length 74.7
  TOP w0.254: v2(74.55,141.33) v1(75.16,141.33)
  L4 w0.254: v1(137.26,135.87) 136.96,136.17 130.79,136.17 128.52,138.44 125.52,138.44 125.24,138.72 124.07,138.72 120.68,142.11 120.15,142.11 118.88,143.38 117.07,143.38 116.26,142.57 116.25,142.57 116.1,142.42 115.32,142.42 114.71,143.03 112.39,143.03 111.68,143.74 109.93,143.74 109.71,143.51 108.57,143.51 106,140.95 102.21,140.95 101.68,140.41 92.86,140.41 91.32,141.95 84.93,141.95 84.59,141.61 79.72,141.61 79.16,142.17 75.8,142.17 75.15,141.52 75.15,141.34 v1(75.16,141.33)
  BOTTOM w0.254: PR4654.1 v1(75.16,141.33) ; v1(137.26,135.87) 137.41,135.72 137.41,134.37 136.85,133.81 PR4662.2 136.16,132.28 PR4655.2
PWR_VCORE_PROG1: length 2.9
  BOTTOM w0.203: v2(132.52,143.46) 132.62,143.36 132.62,143.03 132.81,142.83 PU4601.32
  BOTTOM w0.254: v2(132.52,143.46) 132.52,143.63 131.54,144.62 PR4629.1
PWR_VCORE_PROG2: length 3.1
  BOTTOM w0.203: PU4601.31 132.41,142.72 132.08,143.05 132.08,143.23
  BOTTOM w0.254: PR4628.1 130.78,144.45 v2(131.36,143.87) 131.44,143.87 132.08,143.23
PWR_VCORE_PWM: length 72.8
  TOP w0.254: v2(130.53,137.54) 130.53,138.03 v1(130.43,138.13)
  L3 w0.254: v1(130.43,138.13) 131.83,139.52 131.83,143.82 129.34,146.31 121.63,146.31 118.75,149.18 105.35,149.18 103.86,147.69 98.79,147.69 98.07,148.41 80.42,148.41 74.23,142.22 74.15,142.22 v1(74.02,142.09)
  BOTTOM w0.203: PU4601.22 131.5,138.63 131.45,138.58 130.89,138.58 v1(130.43,138.13)
  BOTTOM w0.254: PR4707.2 74.08,142.15 v1(74.02,142.09)
PWR_VCORE_PWM_R: length 1.6
  BOTTOM w0.254: PU4701.1 75.92,140.73 75.92,141.5 75.55,141.88 PR4707.1
PWR_VCORE_RTN: length 7.6
  BOTTOM w0.203: PU4601.18 133.21,136.95
  BOTTOM w0.254: 133.21,136.95 v2(132.67,136.4) 132.24,135.97 131.83,135.97 PR4659.2 131.22,135.36 131.22,133.61 PC4637.1 130.71,133.1 PC4642.1 130.71,132.03 130.97,131.78 PR4668.2
PWR_VCORE_SNB: length 2.9
  TOP w0.508: PC4706.1 77.75,135.89 77.57,135.71 v2(77.57,135.28) 78.58,135.28 PR4709.2
PWR_VCORE_SW: length 2.4
  TOP w0.508: PR4709.1 77.54,133.2 v2(77.51,133.22) 77.27,133.22 v1(76.92,133.57)
PWR_VCORE_VCC: length 4.6
  BOTTOM w0.203: PR4610.2 133.06,145.48 PC4607.1 132.39,144.64 133.07,144.64 v2(133.21,144.5) 133.21,144.05 133.63,143.63 133.63,143 133.61,142.98 PU4601.34
PWR_VCORE_VCC_R: length 4.7
  BOTTOM w0.305: PU4701.3 76.93,142.3 PC4708.1
  BOTTOM w0.381: PC4708.1 76.94,143.79 76.91,143.82 ; v2(76.99,143.89) 76.91,143.82 ; 76.91,143.82 75.59,143.82 PR4704.1
PWR_VCORE_VIN: length 15
  TOP w0.508: PR4612.2 135.56,133.73 PC4606.1 135.56,133.85 134.73,134.68 134.73,137.42 136.27,138.96 136.27,141.31 135.34,142.24 134.17,142.24 v1(133.15,143.26) v2(132.74,143.66)
  BOTTOM w0.203: PU4601.33 133.21,143.19 v1(133.15,143.26)
PWR_VCORE_VR: length 153
  TOP w0.254: v1(151.92,136.25) 151.89,136.25 151.4,136.74 150.76,136.74 v1(149.25,138.25) ; v1(152.99,119.79) 153.42,119.36 160.45,119.36 160.73,119.08 160.73,118.29 160.23,117.78 160.23,112.8 159.74,112.32 159.74,111.96 158.42,110.64 158.42,110.54 158.21,110.33 158.21,108.42 156.17,106.38 153.35,106.38 152.67,105.7 152.67,105.12 153.01,104.78 154.1,104.78 154.71,104.17 154.71,95.63 156.75,93.6 157,93.6 157.76,92.84 157.76,92.43 159.46,90.73 160.1,90.73 162.46,88.37 162.46,87.07 161.75,86.36 161.75,82.81 162.25,82.3 162.25,79.94 171.68,70.51 171.68,66.35 175.24,62.79 175.24,58.88 174.25,57.89 174.25,55.68 174.56,55.37 175.8,55.37 176.64,56.21 185.98,56.21 187.01,57.24 194.55,57.24 195.76,56.03 v2(197.28,56.03) 198.02,56.03 PR4671.1
  L3 w0.254: v1(151.92,136.25) 151.92,136.22 152.01,136.13 152.01,134.86 151.98,134.84 151.98,120.79 v1(152.99,119.79) ; v1(149.25,138.25) 149.25,139.8 147.81,141.25 v1(147.25,141.25)
  L4 w0.254: v1(137.34,142.47) 144.68,142.47 145.9,141.25 v1(147.25,141.25)
  BOTTOM w0.203: PU4601.1 136.87,141.83 137.34,142.3 v1(137.34,142.47)
  BOTTOM w0.254: v1(137.34,142.47) 137.64,142.47 138.69,143.52 PR4614.1
PWR_VCORE_VRHOT#: length 2.7
  BOTTOM w0.203: PU4601.38 135.21,142.83 135.68,143.3
  BOTTOM w0.254: PR4607.2 136.4,144.3 135.89,143.79 135.89,143.51 135.68,143.3
PWR_VDDQ:
  vias: v2(110.42,38.43) v3(114.33,41.2) v3(115.17,41.21) v3(116.06,41.21) v3(116.92,41.21) v3(117.83,41.21) v3(118.7,41.2)
PWR_VDDQ_BOOT: length 4.3
  TOP w0.203: v1(118.57,30.84) 118.34,30.84 117.81,30.3 v2(117.71,30.3)
  TOP w0.381: v1(118.57,30.84) 118.72,30.84 119.21,30.35 119.21,29.77 119.64,29.34 PR5105.1
  BOTTOM w0.203: v1(118.57,30.84) 118.47,30.84 118.28,30.64 PU5102.27
PWR_VDDQ_BOOTA: length 1.1
  TOP w0.508: PR5105.2 120.32,30.91 120.32,30.96 120.42,31.06 PC5102.2
PWR_VDDQ_BOOTB: length 1
  BOTTOM w0.203: PU5102.25 118.78,31.44 118.82,31.4 v1(118.86,31.4)
  vias: v2(118.27,31.47)
PWR_VDDQ_CS: length 3.3
  TOP w0.254: v2(111.89,31.01) PR5102.2 112.8,29.41 112.91,29.41 112.96,29.37 113.03,29.37 v1(113.13,29.29)
  BOTTOM w0.203: v1(113.13,29.29) 113.13,29.26 113.35,29.04 PU5102.10
PWR_VDDQ_EN: length 143
  TOP w0.254: v1(130.54,31.68) 130.55,31.68 131.01,31.23 136.79,31.23 v2(137.46,31.9) 138.08,32.51 148.08,32.51 155.04,39.47 v1(155.04,40.23)
  L4 w0.254: v1(114.99,27.13) 114.99,27.38 115.24,27.64 116.8,27.64 117.1,27.34 117.1,27.1 117.25,26.95 120.75,26.95 121.08,27.28 126.52,27.28 128.81,29.57 128.81,30.28 130.21,31.68 v1(130.54,31.68) ; v1(149.05,59.76) 149.27,59.54 150.77,59.54 160.28,50.03 160.28,44.25 157.5,41.46 155.42,41.46 155.04,41.08 v1(155.04,40.23)
  BOTTOM w0.203: v1(114.99,27.13) 114.99,27.15 115.3,27.47 PU5102.6
  BOTTOM w0.254: v1(149.05,59.76) 149.11,59.76 149.48,60.14 150.5,60.14 151.31,60.95 151.5,60.95 154.3,60.95 157.05,63.7 158.02,63.7 158.78,64.46 158.78,64.88 158.78,64.89 158.78,67 159.02,67.24 159.02,67.25 161.15,69.38 161.15,75.52 162.21,76.58 164.24,76.58 165.53,77.88 165.53,79.22 166.49,80.18 166.49,92.36 166.99,92.85 166.99,92.88 167.01,92.9 167.01,94.01 166.02,95 164.35,95 164.2,95.15 162.54,95.15 160.02,97.66 160.02,102.9 PR5114.1 164.01,106.88 164.01,107.41 PG5122.2
PWR_VDDQ_FB: length 4.2
  TOP w0.254: PR5103.2 116.36,27.44 116.59,27.21 v1(116.59,27.13)
  TOP w0.381: PR5103.2 115.82,28.55 v2(115.82,29.01) 115.63,29.2 PR5104.1
  BOTTOM w0.203: v1(116.59,27.13) 116.59,27.48 116.5,27.57 PU5102.3
PWR_VDDQ_PG: length 53.3
  TOP w0.254: v1(113.71,27.1) 113.71,27.52 113.52,27.71 PR5101.2 ; PG5114.2 82.63,34.9 v2(82.63,33.04) v1(82.63,30.66)
  L4 w0.254: v1(113.71,27.1) 113.05,27.76 112.4,27.76 111.99,27.36 77.73,27.36 76.97,28.12 76.97,30.26 77.99,31.28 82.01,31.28 v1(82.63,30.66)
  BOTTOM w0.203: PU5102.8 114.15,28.07 114.04,27.95
  BOTTOM w0.254: 114.04,27.95 113.71,27.62 v1(113.71,27.1)
PWR_VDDQ_PH:
  vias: v2(114.82,33.84) v4(113.92,34.01)
PWR_VDDQ_SNB:
  vias: v2(112.16,35.19)
PWR_VDDQ_TON: length 7.6
  TOP w0.254: PR5106.2 115.27,32.26 114.79,31.78 v2(114.79,31.44) 114.75,31.4 114.75,27.85 114.34,27.45 v1(114.34,27.1)
  BOTTOM w0.203: v1(114.34,27.1) 114.34,27.14 114.43,27.23 114.43,27.26 114.9,27.73 PU5102.7
PWR_VDDQ_VCC: length 1.4
  BOTTOM w0.203: v1(112.63,28.9) 112.89,28.64 PU5102.9
  vias: v2(113.59,28.27)
PWR_VDDQ_VDDQ: length 21
  L4 w0.254: v1(117.65,27.46) 120.48,27.46 122.34,29.32 v1(122.34,33.59)
  BOTTOM w0.203: PU5102.2 116.9,27.68 117.12,27.46 v1(117.65,27.46)
  BOTTOM w0.254: v1(119.53,41.21) 119.53,41.03 121.54,39.02 121.54,38.43 121.88,38.09 122.33,38.09 123.4,37.02 123.4,34.47 123.32,34.4 123.32,34.35 123.17,34.2 123.13,34.2 122.56,33.63 122.38,33.63 v1(122.34,33.59)
  vias: v2(121.17,42.64)
PWR_VDDQ_VLDOIN: length 28.1
  L3 w0.508: v1(118.54,30.2) 118.54,29.81 116.99,28.26 112.2,28.26 111.86,28.6 111.86,30.2 111.43,30.63 v1(111.08,30.63)
  BOTTOM w0.508: v1(111.08,30.63) 110.6,30.63 110.42,30.81 110.42,32.76 111.09,33.44 111.09,36.5 111,36.59 111,36.65 108.99,38.66 108.99,39.55 108.85,39.69 108.85,39.7 108.2,40.35 108.11,40.44 108.11,41.19 108.55,41.62 112.42,41.62 112.8,41.24 v1(112.8,41.17)
  vias: v2(118.77,29.29)
PWR_VDDQ_VTTREF: length 2.9
  TOP w0.254: v1(117.99,28) 117.99,28.24 117.61,28.62 v2(117.61,28.89) 118.21,28.89 PC5123.1
  BOTTOM w0.203: PU5102.1 117.91,28.07 117.98,28 v1(117.99,28)
Q501_G: length 6.3
  TOP w0.102: R506.2 107.87,37.95 107.58,38.24 106.98,38.24 106.66,37.92 v2(106.66,37.85) 106.66,37.68 106.79,37.56 v1(107.19,37.56)
  BOTTOM w0.102: v1(107.19,37.56) 107,37.56 106.36,38.2 Q501.D 106.36,38.48 106.71,38.83 106.71,40.5 107.03,40.82 Q502.G
Q2510_G: length 7.1
  BOTTOM w0.102: Q2510.G 163.93,81.54 C2517.1 163.58,82.77 D2502.A 162,82.77 161.36,83.41 159.97,83.41 R2567.2
Q5503_B: length 2.6
  TOP w0.102: R5554.2 141.74,130.1 v2(141.57,129.92) Q5502.B
Q5503_C: length 2
  TOP w0.102: v2(142.58,128.8) Q5502.C 142.58,126.79 R5546.1
Q5503_E: length 2.5
  TOP w0.102: R5551.1 v2(139.53,127.74) 140.08,127.74 140.43,127.39 Q5502.E
Q5504_B: length 3.5
  TOP w0.102: R5553.2 150.61,131.98 Q5501.B 152.06,133.02 v2(152.06,133.22)
Q5504_C: length 4.2
  TOP w0.102: Q5501.C 153.27,131.03 153.77,130.54 153.77,128.79 v2(153.35,128.37) 152.78,127.8 R5548.1
Q5505_E: length 2.8
  TOP w0.102: Q5501.E 152.16,128.95 v2(152.26,128.95) 152.92,128.95 R5550.1
Q6205_Q: length 2.8
  BOTTOM w0.203: v2(96.51,32.15) 96.51,31.87 96.8,31.58 R6503.2
  BOTTOM w0.381: R6503.2 96.8,30.86 97.71,29.95 Q6503.D
Q6407_B: length 61.3
  TOP w0.102: v1(39.37,78.82) 39.75,79.2 39.75,79.45 40.14,79.83 40.14,80.37 Q6407.1 40.89,81.96 R6405.1
  L3 w0.102: v1(12.93,65.05) 13.87,65.05 14.74,65.91 14.74,66.08 15.9,67.24 16.11,67.24 16.21,67.33 16.22,67.33 16.47,67.58 16.47,67.6 16.49,67.61 16.49,67.84 16.8,68.15 16.8,68.5 18.23,69.93 18.23,71.07 18.6,71.44 18.71,71.44 20.1,72.83 20.1,74.2 20.09,74.22 20.09,74.74 20.88,75.54 22.28,75.54 22.55,75.8 24.75,75.8 24.76,75.79 25.11,75.79 26.11,76.79 27.33,76.79 27.59,76.53 28.11,76.01 29.32,76.01 29.7,75.62 31.43,75.62 31.49,75.68 35.87,75.68 36.19,76 38.02,76 39.37,77.35 v1(39.37,78.82)
  BOTTOM w0.102: v1(12.93,65.05) 12.73,64.85 12.73,64.29 14,63.01 14.1,63.01 15.4,61.72 16.87,61.72 17.98,60.62 19.48,60.62 20.38,59.72 22.74,59.72 23.61,58.85 24.18,58.85 25.2,57.84 25.2,55.84 24.86,55.49 v2(24.84,55.49) 24.84,55.18 23.63,53.97 Q6408.C
Q6407_C: length 2.3
  TOP w0.102: R6413.2 40.8,78.21 v2(41.46,78.87) 41.23,79.1 Q6407.3
Q9301_G: length 5.5
  TOP w0.102: R9301.2 157.99,139.24 v2(158.69,138.53) 158.84,138.39 159.91,138.39 160.17,138.66 Q9301.2 Q9301.5
REGOUT:
  vias: v1(49.27,85.69) v2(48.69,86.01)
RESET_OUT#: length 354.5
  TOP w0.102: U2401.73 38.34,63.29 38.05,63.58 37.69,63.58 37.43,63.31 37.43,62.97 36.33,61.86 36.33,61.24 37.31,60.25 37.72,60.25 v1(38.37,59.6)
  L3 w0.102: v1(141.42,79.84) 140.95,79.84 140.46,79.35 140,79.35 138.56,80.79 138.56,80.93 138.27,81.22 133.87,81.22 133.72,81.37 127.88,81.37 125.37,83.88 124.54,83.88 124.13,84.3 120.16,84.3 119.82,83.95 116.17,83.95 115.34,84.79 113.07,84.79 113.04,84.82 113.03,84.82 112.99,84.86 112.98,84.86 111.15,86.68 111.15,86.84 v1(110.75,87.24) ; v1(157,139.63) 157,139.81 156.38,140.42 155.95,140.42 155.9,140.37 153.23,140.37 151.71,138.86 151.71,138.67 149.45,136.4 146.79,136.4 143.51,133.12 143.51,119.43 v1(144.25,118.7)
  L4 w0.102: v1(152.61,99.37) 152.51,99.37 151.34,100.54 151.34,101.08 149.88,102.54 149.88,106.34 145.55,110.68 145.55,112.82 145.82,113.1 145.82,117.99 145.42,118.39 144.55,118.39 v1(144.25,118.7) ; v1(38.37,59.6) 37.55,59.6 33.73,55.78 33.73,54.78 29.86,50.91 29.86,48.3 30.38,47.78 30.38,47.41 30.41,47.34 30.46,47.11 30.46,46.18 30.41,46.13 30.41,44.26 30.96,43.71 63.66,43.71 63.67,43.7 79.17,43.7 79.21,43.74 81.09,43.74 81.49,44.14 81.66,44.14 92.55,44.14 92.79,43.9 93.15,43.9 93.24,44 94.8,44 95.05,44.26 96.73,44.26 99.18,46.71 103.64,46.71 104.5,45.84 106.93,45.84 107.76,46.67 123.5,46.67 125.15,45.02 132.14,45.02 133.25,43.9 155.23,43.9 156.17,44.84 156.17,47.29 156.04,47.42 156.04,49.55 149.47,56.11 145.67,56.11 121.34,80.45 121.34,81.64 120.94,82.04 119.83,82.04 119.6,82.27 115.41,82.27 114.52,83.16 114.52,83.31 114.52,83.6 114.22,83.91 112.69,83.91 110.32,86.29 110.32,86.8 v1(110.75,87.24)
  BOTTOM w0.102: v1(157,139.63) 157,139.51 156.59,139.11 156.59,137.98 156.47,137.85 C2614.1 156.13,137.59 155.98,137.44 R2616.2 ; v1(144.25,118.7) 144.25,118.43 143.46,117.64 143.46,117.55 143.45,117.54 143.45,116.75 143.45,116.75 143.49,115.66 143.49,112.91 Q2602.G ; v1(152.61,99.37) 152.32,99.37 151.16,98.21 151.16,98.18 150.38,97.41 150.27,97.41 146.19,93.33 v2(146.19,91.85) 146.19,89.7 146.76,89.14 146.76,89.13 146.94,88.94 146.94,87.71 147.86,86.79 147.86,83.63 146.94,82.71 146.94,81.97 146.28,81.32 145.71,81.32 RN1703.3 145.5,81.11 145.24,81.11 145.2,81.06 144.6,81.06 144.36,81.29 ED1705.2 143.46,80.95 143.96,80.46 143.96,79.43 143.82,79.29 143.11,79.29 143.01,79.39 143.01,79.6 142.97,79.64 142.97,79.72 142.85,79.84 v1(141.42,79.84) ; v1(110.75,87.24) 110.36,87.63 CPU1.BP31
REXT1: length 3
  TOP w0.102: R5804.1 55.44,113.95 v2(54.99,114.41) 54.92,114.41 54.5,114.82 U5802.20
RING2_HPMIC1: length 11.6
  TOP w1.016: HPMIC1.3 5.49,8.87 13.66,8.87 14.27,9.48 14.75,9.48
  vias: v2(15.67,9.19)
RSET: length 2.7
  TOP w0.203: v1(44.94,86.44) 45.09,86.28 U3101.31
  BOTTOM w0.254: v1(44.94,86.44) 44.94,86.94 44.74,87.13 v2(44.73,87.13) 43.93,87.13 R3102.1
RSMRST_PWRGD#: length 325
  TOP w0.102: v1(20.97,61.1) 21.18,60.89 R4030.2 ; v2(38.84,37.77) 38.84,37.41 v1(39.06,37.19) 39.45,37.19 R4033.2
  L2SGND w0.102: v1(20.97,61.1) 20.97,61.03 20.6,60.66 20.6,58.64 18.8,56.84 18.8,52.68 19.76,51.72 19.76,50.33 19.32,49.88 19.32,46.23 19.32,46.23 19.32,46.12 22.02,43.42 22.02,42.22 23.04,41.2 24.29,41.2 25.69,42.6 v1(25.85,42.6)
  L3 w0.102: v1(102.2,45.31) 102.03,45.31 100.59,43.87 99.68,43.87 99.49,44.06 98.64,44.06 96.78,42.2 91.95,42.2 91.74,42.41 84.13,42.41 83.37,41.64 v1(83.37,41.58) 83.06,41.89 81.45,41.89 80.35,40.78 74.51,40.78 71.56,37.83 67.28,37.83 v1(66.99,37.54) 66.38,38.15 65.08,38.15 64.88,38.35 62.08,38.35 61.73,38 61.73,36.03 60.65,34.95 57.88,34.95 56.43,33.5 40.59,33.5 39.6,34.49 39.6,36.65 v1(39.06,37.19) 39.06,37.69 38.42,38.32 35.86,38.32 34.45,36.91 30.75,36.91 29.85,37.81 29.85,39.93 27.48,42.3 26.16,42.3 v1(25.85,42.6) ; v1(115.9,142.95) 116.13,143.18 118.94,143.18 120.63,141.49 122.11,141.49 125.32,138.28 126.01,138.28 126.72,137.57 126.72,135.27 126.32,134.86 126.32,131.3 v1(127.5,130.12)
  L4 w0.089: v1(177.1,66.19) 176.76,66.19 174.05,68.91 173.32,68.91 172.91,69.32
  L4 w0.102: 172.91,69.32 160.87,81.36 160.87,83.57 161.29,84 161.29,86.71 150.88,97.12 150.88,99.56 148.58,101.86 148.58,106.05 144.42,110.21 144.42,112.11 143.23,113.3 143.23,117 131.52,128.7 131.52,129.62 130.31,130.84 128.22,130.84 v1(127.5,130.12)
  BOTTOM w0.089: v1(83.37,41.58) 83.11,41.33 D4002.K
  BOTTOM w0.102: v1(177.1,66.19) 176.33,65.43 174.3,65.43 173.6,66.13 170.94,66.13 170.22,65.41 170.22,63.47 170.1,63.35 168.38,61.6 168.38,59.99 163.33,54.95 157.46,54.95 156.63,54.12 147.72,54.12 147.29,54.55 145.4,54.55 144.93,55.02 111.32,55.02 111.32,55.02 110.98,55.02 110.12,54.16 109.81,54.16 109.77,54.11 104.24,54.11 101.93,51.8 101.93,51.63 101.93,51.63 101.93,46.11 102.2,45.84 v1(102.2,45.31) ; v1(115.9,142.95) 115.35,143.5 115.35,143.82 114.71,144.46 R4029.2 ; R4031.2 v1(66.99,37.54)
