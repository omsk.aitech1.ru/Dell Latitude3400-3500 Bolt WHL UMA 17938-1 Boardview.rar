# Allegro board 17938-1.1228WZS1107.brd (continued)
## Nets (continued)
1D0V_S5: C1112.1 C1114.1 C1115.1 C1116.1 C1117.1 C1118.1 C1119.1 C1120.1 C1121.1 C1128.1 C1129.1 C2212.1 C2214.1 C2215.1 C2216.1 C2217.1 C2223.1 C4006.1 C4013.1 C4035.1 C4036.1 CPU1.BP14 CPU1.BP20 CPU1.BP22 CPU1.BR12 CPU1.BR14 CPU1.BR15 CPU1.BR20 CPU1.BT12 CPU1.BT18 CPU1.BT19 CPU1.BT22 CPU1.BU12 CPU1.BU14 CPU1.BU15 CPU1.BU18 CPU1.BU19 CPU1.BU22 CPU1.BV15 CPU1.BV16 CPU1.BV18 CPU1.BV19 CPU1.BV20 CPU1.BV22 CPU1.BW16 CPU1.BW18 CPU1.BW19 CPU1.BW20 CPU1.BW22 CPU1.BY16 CPU1.BY20 CPU1.CA12 CPU1.CA14 CPU1.CA16 CPU1.CA18 CPU1.CA19 CPU1.CA20 CPU1.CB12 CPU1.CB14 CPU1.CB15 CPU1.CC12 EC2201.1 PG5201.2 PG5202.2 PG5203.2 PG5204.2 PG5205.2 PG5206.2 PG5207.2 PG5208.2 PG5209.2 PG5211.2 PG5224.2 PG5225.2 PG5226.2 PG5227.2 R2202.1 R2203.1 R2205.1 R2402.1 U4002.1 U4002.2 U4002.9 U4006.1 U4006.2 U4006.9
1D0V_VCCA_XTAL: C2219.1 C2231.1 CPU1.CP5 R2202.2
1D0V_VCCAMPHYPLL: C2208.1 C2209.1 CPU1.BV2 R2205.2
1D0V_VCCDSW: C2213.1 CPU1.BT24
1D0V_VCCPRIM_MPHY: C2220.1 CPU1.BV12 CPU1.BV14 CPU1.BW12 CPU1.BW14 CPU1.BY12 CPU1.BY14 R2203.2
1D2V_S3: C804.1 C1130.1 C1131.1 C1132.1 C1136.1 C1137.1 C1138.1 C1139.1 C1140.1 C1141.1 C1142.1 C1202.1 C1203.1 C1204.1 C1205.1 C1206.1 C1208.1 C1209.1 C1210.1 C1214.1 C1215.1 C1216.1 C1217.1 C1218.1 C1219.1 C1220.1 C1221.1 C1303.1 C1304.1 C1305.1 C1306.1 C1307.1 C1308.1 C1309.1 C1310.1 C1315.1 C1316.1 C1317.1 C1318.1 C1319.1 C1320.1 C1321.1 C1322.1 C4008.1 C4043.1 CPU1.AD36 CPU1.AH32 CPU1.AH36 CPU1.AM36 CPU1.AN32 CPU1.AW32 CPU1.AY36 CPU1.BE32 CPU1.BH36 CPU1.R32 CPU1.Y36 DM1.12 DM1.33 DM1.54 DM1.75 DM1.96 DM1.111 DM1.112 DM1.117 DM1.118 DM1.123 DM1.124 DM1.129 DM1.130 DM1.135 DM1.136 DM1.141 DM1.142 DM1.147 DM1.148 DM1.153 DM1.154 DM1.159 DM1.160 DM1.163 DM1.178 DM1.199 DM1.220 DM1.241 DM2.12 DM2.33 DM2.54 DM2.75 DM2.96 DM2.111 DM2.112 DM2.117 DM2.118 DM2.123 DM2.124 DM2.129 DM2.130 DM2.135 DM2.136 DM2.141 DM2.142 DM2.147 DM2.148 DM2.153 DM2.154 DM2.159 DM2.160 DM2.163 DM2.178 DM2.199 DM2.220 DM2.241 EC1202.1 EC1203.1 EC1303.1 EC8902.1 EC8904.1 EC8906.1 EC8909.1 EC8910.1 EC8911.1 EC8912.1 EC8913.1 EC8914.1 EC8915.1 FC1102.1 FC1103.1 FC8914.1 FC8915.1 FC8977.1 FC8978.1 FC8979.1 PG5103.2 PG5105.2 PG5106.2 PG5107.2 PG5108.2 PG5109.2 PG5110.1 PG5116.1 R505.1 R1215.1 R1312.1 RN1201.1(A) RN1301.1(A) U4003.1 U4003.2 U4003.9
1D2V_VCCSFR_OC: C803.1 C4010.1 CPU1.BL27 CPU1.BM26 U4003.6 U4003.7 U4003.8
1D05V_PWR: PC5201.1 PC5203.1 PC5205.1 PC5206.1 PC5208.1 PC5217.1 PG5201.1 PG5202.1 PG5203.1 PG5204.1 PG5205.1 PG5206.1 PG5207.1 PG5208.1 PG5209.1 PG5211.1 PG5223.2 PG5224.1 PG5225.1 PG5226.1 PG5227.1 PL5201.2
1D05V_S5_PWRGD: PU5201.1 R4029.1
1D8V_AVDD2: C2710.2 HDA27.33 R2725.2
1D8V_EMMC: C6319.1 C6321.1 R6325.1 R6326.1 R6327.1 R6328.1 R6329.1 R6330.1 R6331.1 R6332.1 R6333.1 R6334.1 R6343.1 U6301.C6 U6301.M4 U6301.N4 U6301.P3 U6301.P5
1D8V_S0: C4015.1 R2709.1 R2725.1 R6327.2 R6403.1 U4004.8 U4004.9
1D8V_S0_CT1: C4011.1 U4004.10
1D8V_S5: PG5301.2 R1104.2 R1515.1 R2462.2 R2497.2 R6369.1 R7428.2 U4004.6 U4004.7
1D8V_VCCPRIM: C1122.1 C2210.1 C2211.1 CPU1.CC15 CPU1.CC18 CPU1.CC19 CPU1.CD15 CPU1.CD16 CPU1.CD18 CPU1.CD19 CPU1.CP17 CPU1.CP23 R1104.1 R1512.1 R1738.1 R1821.1 R2053.1 R2111.1 R2113.1 R2115.1 R2117.1 RN2001.1(A) RN2001.2(A)
1D24V_VCCDPHY: CPU1.BY23 CPU1.BY24 CPU1.CA23 CPU1.CA24
1D24V_VCCDPHY_EC: C2218.1 CPU1.CP25
2D5V_S3: C1207.1 C1231.1 C1311.1 C1313.1 DM1.257 DM1.259 DM2.257 DM2.259 PR5121.1 PR5122.1
3D3V_AUX_S5: AFTP6402.1 C6401.1 PG4532.2 PR4505.1 PWR1.1 R1726.2 R1737.1 R2505.1
3D3V_CAMERA: F5504.1 R5501.2 U5502.13 U5502.14
3D3V_CAMERA_CT1: C5539.1 U5502.12
3D3V_CAMERA_S0: AFTP5511.1 C5503.1 F5504.2 LCD1.23
3D3V_EMMC: C6322.1 C6324.1 R6322.1 U6301.E6 U6301.F5 U6301.J10 U6301.K9
3D3V_GSEN2: C7003.1 C7004.1 R7004.2 R7006.2 U7001.9 U7001.10
3D3V_LAN_CT2: C4017.1 U4001.10
3D3V_LAN_S5: C3103.1 C3110.1 C3117.1 C3121.1 C3124.1 C4014.1 LED2.A R3103.2 R4047.2 U3101.11 U3101.23 U3101.32
3D3V_LAN_S5_R: R4047.1 U4001.8 U4001.9
3D3V_LCDVDD_R: R5523.2 R5559.2 R9304.1 U5501.1
3D3V_LCDVDD_R_C: PMBD1.6 R9304.2 R9336.2
3D3V_LCDVDD_S0: AFTP5523.1 AFTP5524.1 C5530.1 C5536.1 C5538.1 C5541.1 C5599.1 D5505.A FC8971.1 LCD1.35 LCD1.36 LCD1.37 R5523.1 R5547.2 R5559.1 R9305.1
3D3V_LCDVDD_S0_C: PMBD1.8 R9305.2 R9331.2
3D3V_MUX: C7115.2 C7116.2 C7117.2 C7118.2 C7119.1 L7101.2 R7101.1 R7140.1 R7142.1 R7145.1 R7147.1 R7152.1 R7171.1 R7174.1 R7175.1 R7189.1 R7190.1 U7101.6 U7101.20 U7101.28
3D3V_MUX2: C7120.1 R7126.2 U7102.13
3D3V_MUX_VCC: C7165.2 R7175.2 U7101.1
3D3V_RTC: C2503.1 D2501.3 Q2507.S R2472.2 R2708.1
3D3V_RTC_AUX_S5: Q2507.D R1730.1 R2204.1 R2476.2 R2506.2 RN1801.1(A) RN1801.2(A)
3D3V_RTC_SYS: D2501.1 R2505.2 R2517.1
3D3V_S0: AFTP4001.1 AFTP4002.1 C1228.1 C1328.1 C1329.1 C2432.1 C2601.1 C2602.1 C4004.1 C5809.2 C5810.1 C5811.1 C5812.1 C5813.1 C9104.1 DBG1.10 DM1.255 DM2.255 EC8950.1 EC8951.1 EC8952.1 EC8953.1 FC8901.1 FC8902.1 FC8904.1 IOBD1.14 IOBD1.15 PMBD1.12 PR4609.1 Q1801.2 Q1801.5 Q2414.G Q2601.2 Q2601.5 Q5702.2 Q5702.5 Q5703.C Q5801.2 Q5801.5 Q6504.2 Q6504.5 R402.2 R507.1 R1204.2 R1208.2 R1211.2 R1216.1 R1302.2 R1306.2 R1310.2 R1606.1 R1617.1 R1820.1 R1822.1 R1823.1 R1825.1 R1826.1 R1827.1 R2008.1 R2010.1 R2043.1 R2044.1 R2045.1 R2046.1 R2048.1 R2049.1 R2059.1 R2064.1 R2065.1 R2066.1 R2430.2 R2467.2 R2489.2 R2603.1 R2604.1 R2715.1 R3109.1 R4005.1 R4048.1 R5501.1 R5517.1 R5518.1 R5550.2 R5557.2 R5561.1 R5564.2 R5805.1 R5807.1 R5809.1 R5811.1 R5813.1 R5815.1 R5817.1 R5820.1 R5821.1 R5822.1 R5834.1 R6124.2 R6302.1 R6322.2 R6348.1 R6349.1 R6411.1 R6415.1 R6502.1 R7004.1 R7010.1 R9150.1 R9211.2 R9301.1 R9313.1 RN401.1(A) RN401.2(A) RN401.3(A) RN401.4(A) RN1810.1(A) RN1810.2(A) RN2601.3(B) RN2601.4(B) RN2602.1(A) RN2602.2(A) RN9301.1(A) RN9301.2(A) U2402.5 U2601.1 U4001.13 U4001.14 U5502.1 U5502.2 U5802.5 U5802.21 U5802.30 U5802.51 U5802.57 U9103.8 VGABD1.3 VGABD1.4
3D3V_S0_C: PMBD1.5 R9313.2 R9328.2
3D3V_S5: C2416.1 C2421.1 C5505.1 C6102.1 C6503.1 C9106.1 C9108.1 D4302.2 D7202.A FC8917.1 FC8918.1 FC8919.1 FC8920.1 L7101.1 PC4509.1 PC4510.1 PC4511.1 PC4512.1 PC4513.1 PC4525.1 PC5124.1 PG4530.2 PG5302.2 PL4501.2 PR4431.1 PR4432.2 PR4435.1 PR4450.2 PR4472.1 PR5101.1 PR5112.1 PR5301.1 PU5101.5 PU5101.9 Q2416.2 Q2416.5 Q6502.S Q9201.S R506.1 R1721.1 R1739.2 R1910.1 R2068.1 R2434.1 R2442.1 R2446.1 R2495.1 R2514.1 R2520.1 R2607.1 R3618.2 R4010.1 R4031.1 R4304.1 R4378.1 R6102.1 R6125.1 R6404.2 R6611.1 R7126.1 R7216.1 R7424.1 R7427.1 R9149.1 R9212.1 RN2405.3(B) RN2405.4(B) RN2406.3(B) RN2406.4(B) U2502.5 U4001.1 U4001.2 U4001.6 U4001.7 U4007.5 U4302.2 U5501.5 U6101.5 U9103.1 WWAN1.1 WWAN1.2 WWAN1.3 WWAN1.4 WWAN1.5
3D3V_S5_PCH: R405.1 R406.1 R1103.1 R1502.1 R1504.1 R1506.1 R1508.1 R1510.1 R1513.1 R1522.1 R1551.1 R1554.1 R1837.1 R1922.1 R2041.1 R2047.1 R2060.1 R2061.1 R2062.1 R2515.1 R2516.2 R2519.1 R2521.1 R6609.1 R6877.2 R9148.1 RN1601.1(A) RN1601.2(A) RN1601.3(A) RN1601.4(A) RN1807.1(A) RN1807.2(A) RN1807.3(A) RN1807.4(A) RN1811.1(A) RN1811.2(A)
3D3V_S5_PCH_R: Q401.2 Q401.3 R406.2
3D3V_SPIVCC1: BIOS1.8 BIOS2.8 C2501.1 C2502.1 R2515.2
3D3V_SSD: C6304.1 C6305.1 C6306.1 C6307.1 C6308.1 C6317.1 C6318.1 FC8911.1 R6302.2 R6349.2 R9314.1 SSD1.2 SSD1.4 SSD1.12 SSD1.14 SSD1.16 SSD1.18 SSD1.70 SSD1.72 SSD1.74
3D3V_SSD_C: PMBD1.7 R9314.2 R9327.2
3D3V_TP_CT2: C5540.1 U5502.10
3D3V_TPM: C9109.1 C9112.1 C9113.1 R9119.2 R9149.2 R9150.2 U9103.22
3D3V_VCCDSW: C2224.1 C2230.1 CPU1.BR24 CPU1.BT23 R1520.1 R1524.1 R1707.1 R2516.1 RN1704.1(A) RN1704.2(A) RN1704.3(A) RN1704.4(A) U2502.1
3D3V_VCCPRIM: C1113.1 C1123.1 C2202.1 C2203.1 C2204.1 C2205.1 C2206.1 C2207.1 C2225.1 C2226.1 C2227.1 C2228.1 CPU1.BP23 CPU1.BT20 CPU1.BV23 CPU1.BW23 CPU1.CB16 CPU1.CB22 CPU1.CB23 CPU1.CC22 CPU1.CC23 CPU1.CD22 CPU1.CD23 CPU1.CP29 R1103.2 R1701.1 R1731.1
3D3V_VCCPRTC: C2221.1 C2222.1 C2229.1 CPU1.BR23 R2204.2
3D3V_WLAN: AFTP6113.1 C6104.1 C6105.1 C6106.1 FC8972.1 FC8980.1 R6114.1 R6115.1 R6124.1 R6125.2 U6101.1 WLAN1.2 WLAN1.4 WLAN1.72 WLAN1.74
+DC_IN: C4301.1 C4302.1 EL4301.2 EL4302.2 PU4301.1 PU4301.2 PU4301.3 Q4305.2 R4307.1 R4376.1 R4380.1
+DC_IN_C: AFTP4303.1 D4301.K DCIN1.6 DCIN1.7 DCIN1.8 EC4301.1 EC4302.1 EC4312.1 EC4313.1 EL4301.1 EL4302.1
+RTC_CELL_VBAT: C2428.1 R2451.2 R2472.1 R2476.1 R2496.2 U2401.122
+RTC_VCC: AFTP6615.1 D2501.2 IOBD1.13 Q2505.G R2504.1
+SDC_IN: C4343.1 C7401.1 PG4401.1 PR4401.1 PR4434.2 PU4302.1 PU4302.2 PU4302.3 Q4348.S Q7401.S R4318.1 R4370.1 R7406.1 R7407.2 R7434.1 U7418.1 U7418.2 U7418.3
+SDC_IN_SW: C4343.2 PU4302.4 R4318.2 R4334.2 R4368.1
+SDC_IN_SW_R1: Q4349.3 R4334.1
+V_VREF_PATH1: C1222.2 R1209.1
+V_VREF_PATH2: C1323.2 R1309.1
AC_DIS: Q4304.B R4312.1 R4481.2 U2401.69
AC_IN#_G: R4376.2 R4377.1 U4302.5
AC_PRESENT: CPU1.BU35 D1701.A EC1707.1 Q1702.3 RN1704.7(B)
ACOK#: PQ4415.2 PQ4415.3 PR4427.2
ACOK_IN_M: D1701.K D4305.K D4309.K PQ4415.6
AD_IA: PC4432.1 PR4412.1 R2421.1
AD_OFF_L: Q4304.C Q4305.1
AD_OFF_R: C4301.2 PU4301.4 Q4305.3 R4307.2 R4308.1
ALERT#: R2603.2 U2601.6
ALWON: R4009.2 U2401.121
AMBER_LED_BAT: EC6402.1 Q6403.C R6407.1
AUD_AGND: C2702.1 C2703.2 C2706.2 C2707.2 C2710.1 C2711.2 C2715.2 C2902.2 EC2701.1 EC2702.1 EC2703.1 EC2704.1 EC2705.1 EC2905.2 EC2906.2 EC2907.2 EC2908.2 HDA27.19 HDA27.31 HPMIC1.MS R2702.2 R2704.1 R2705.1 R2914.2
AUD_HP1_JACK_L: HDA27.25 R2908.1 R2913.2 R2922.2
AUD_HP1_JACK_L1: EC2907.1 R2907.1 R2908.2
AUD_HP1_JACK_R: HDA27.26 R2910.1 R2912.2 R2921.2
AUD_HP1_JACK_R1: EC2908.1 R2909.1 R2910.2
AUD_HPJD_N: HDA27.12 R2710.2 R2711.2
AUD_PC_BEEP: C2735.2 HDA27.11
AUD_PC_BEEP_C: C2735.1 D2703.3 R2735.1
AUD_PORTA_L_HPMIC1: ED2910.1 HPMIC1.1 R2907.2
AUD_PORTA_R_HPMIC1: ED2910.2 HPMIC1.2 R2909.2
AUD_RING: EC2905.1 HDA27.13 R2906.1 RN2901.4(B)
AUD_SENSE: C2902.1 R2711.1 R2923.2
AUD_SLEEVE: EC2906.1 HDA27.14 R2911.1 RN2901.3(B)
AUD_SPK_L+: EC2902.1 HDA27.35 R2926.1
AUD_SPK_L+_C: AFTP2902.1 R2926.2 SPK1.3
AUD_SPK_L-: EC2901.1 HDA27.36 R2927.1
AUD_SPK_L-_C: AFTP2901.1 R2927.2 SPK1.4
AUD_SPK_R+: EC2904.1 HDA27.38 R2924.1
AUD_SPK_R+_C: AFTP2904.1 R2924.2 SPK1.1
AUD_SPK_R-: EC2903.1 HDA27.37 R2925.1
AUD_SPK_R-_C: AFTP2903.1 R2925.2 SPK1.2
AUD_VREF: C2702.2 HDA27.22
AUX_EN_WOWL: CPU1.BT30 R1718.2
AUX_EN_WOWL_R: Q6102.S R1718.1 R2409.2
AUX_ON: R2466.2 U2401.3
BAT1_LED#: Q2416.4 R2452.1 RN2405.1(A) U2401.106
BAT2_LED#: Q2416.1 R2453.2 RN2405.2(A) U2401.1
BAT_AMBER: LED1.1 R6407.2
BAT_WHITE: LED1.2 R6406.2
BATT_WHITE_LED#: Q2416.6 Q6401.D Q6406.4 R2453.1 R6409.2
BATT_WHITE_LED#_Q: Q6404.B Q6406.3 R6409.1
BEEP: R2739.1 U2401.45
BKLT_CTRL: D5503.3 RN5502.3(A) RN5503.2(A)
BKLT_IN_EC: R2435.1 U2401.67
BLON_OUT_C: AFTP5518.1 LCD1.30 RN5503.6(B)
BLUETOOTH_EN: AFTP6112.1 CPU1.CP14 R6108.2
BLUETOOTH_EN_R: R6108.1 R6115.2 WLAN1.54
BMON22: PR4493.2 R2483.1
BOARD_ID: C2408.2 R2443.2 R2444.1 U2401.111
BOARD_ID1: CPU1.CG12 R2009.1 R2010.2
BOT_MUX_N: EL7106.2 R7334.2
BOT_MUX_N_L: EL7106.1 U7102.9
BOT_MUX_N_R: ED7313.2 JUSB1.B7 R7333.1 R7334.1
BOT_MUX_P: EL7106.3 R7335.2
BOT_MUX_P_L: EL7106.4 U7102.8
BOT_MUX_P_R: ED7314.2 JUSB1.B6 R7332.1 R7335.1
BREATH_LED#: R2467.1 U2401.70 U2402.1
BT+: AFTP4312.1 AFTP4313.1 AFTP4314.1 AFTP4402.1 BATT1.1 BATT1.2 BATT1.3 D4304.K EC4307.1 EC4308.1 PC4427.1 PC4446.1 PC4447.1 PC4448.1 PG4422.2 PR4452.1 PR4478.2 PU4412.5 PU4412.6 PU4412.7 PU4412.8
BT_PCMFRM_RSTN: R1913.1 R6122.1 WLAN1.10
BT_PCMOUT_CLKREQ0: R1912.1 R6121.1 WLAN1.14
BT_PWR_IN+: PMBD1.20 R4402.1
BT_PWR_IN-: PMBD1.18 R4401.1
BT_USB20_CON_N: AFTP6111.1 EL6101.1 R6105.1 WLAN1.5
BT_USB20_CON_P: AFTP6114.1 EL6101.4 R6104.1 WLAN1.3
BT_USB20_N: CPU1.CC3 EL6101.2 R6105.2
BT_USB20_P: CPU1.CC4 EL6101.3 R6104.2
C10_GATE: R4010.2 R4034.2 R4040.2 R4048.2 U4007.2
CAD_SNK_MUX: R7189.2 U7101.29
CAM_EN: CPU1.CE9 R5557.1 U5502.3
CAP_LED: AFTP6541.1 KB1.4 R6513.2
CAP_LED#: Q2414.S R2489.1 U2401.93
CAP_LED#_R: Q2414.D Q6505.B
CAP_LED_Q: C6506.1 Q6505.C R6513.1
CARD1_USB20_CON_N: ED6601.1 EL6601.3 IOBD1.5 R6604.2
CARD1_USB20_CON_P: ED6601.6 EL6601.2 IOBD1.6 R6605.2
CARD1_USB20_N: CPU1.CG8 EL6601.4 R6604.1
CARD1_USB20_P: CPU1.CG9 EL6601.1 R6605.1
CBN: C2708.1 HDA27.28
CBP: C2708.2 HDA27.30
CCD_USB20_CON_N: ED5502.1 EL5501.2 LCD1.20
CCD_USB20_CON_P: ED5502.6 EL5501.3 LCD1.19
CCD_USB20_N: CPU1.CC1 EL5501.1
CCD_USB20_P: CPU1.CC2 EL5501.4
CCG4_FLIP#: R7127.1 R7128.1 U7201.24
CCG4_I2C_INT#: R7215.2 U2401.32 U7201.8
CCG4_I2C_SCL: Q2417.6 RN7201.3(B) U7201.10
CCG4_I2C_SDA: Q2417.3 RN7201.4(B) U7201.9
CCG4_ID_1: R7212.2 R7214.1 U7201.2
CEXT: C5863.1 U5802.17
CFG0: CPU1.T4 R602.1
CFG0_DP_MUX: R5815.2 U5802.59
CFG1: CPU1.R4 TP623.1
CFG3: CPU1.R3 R1517.1
CFG4: CPU1.J4 R1518.1
CFG19: CPU1.N4 TP640.1
CFG_RCOMP: CPU1.AB5 R601.1
CHG_AMBER_LED#: Q2416.3 Q6406.1 R2452.2 R6408.1
CHG_AMBER_LED#_Q: Q6403.B Q6406.6 Q6407.2 R6405.2 R6408.2
CHGR_PSYS_IMVP: PR4442.2 PR4671.2
CLK_ITE8010: R2460.1 WWAN1.14
CLK_PCIE_LAN_REQ#: CPU1.CF30 R1826.2 U3101.12
CLK_PCIE_NVME_REQ#: CPU1.CE30 R1822.2 SSD1.52
CLK_PCIE_SD_REQ#: CPU1.CE31 R1823.2
CLK_PCIE_WLAN_REQ#: AFTP6109.1 CPU1.CE32 R1827.2 WLAN1.53
CLK_TP_SIO: EC6503.1 RN6501.4(B) RN6502.1(A) U2401.78
CLKIN_XTAL_LCP: C1809.1 CPU1.CM3 R1804.1 R1817.1
CMP_VIN0: R2470.2 U2401.20
CMP_VIN0_R: C2612.1 C2613.1 R2470.1 R2608.2 R2610.1
CMP_VOUT0: R2602.2 R2607.2 R2615.2 U2401.85
CNV_BRI_DT: CPU1.CJ20 R2058.2
CNV_BRI_DT_R: R2058.1 WLAN1.36
CNV_BRI_RSP: CPU1.CK20 R6123.1 RN2001.4(B)
CNV_BRI_RSP_R: R6123.2 WLAN1.22
CNV_RGI_DT: CPU1.CG19 R2057.2
CNV_RGI_DT_R: R1515.2 R1516.1 R2057.1 WLAN1.32
CNV_RGI_RSP: CPU1.CH19 R6120.1 RN2001.3(B)
CNV_RGI_RSP_R: R6120.2 WLAN1.34
CNV_WR_CLK_DN: CPU1.CN31 WLAN1.21
CNV_WR_CLK_DP: CPU1.CP31 WLAN1.23
CNV_WR_DN0: CPU1.CR30 WLAN1.15
CNV_WR_DN1: CPU1.CM30 WLAN1.9
CNV_WR_DP0: CPU1.CP30 WLAN1.17
CNV_WR_DP1: CPU1.CN30 WLAN1.11
CNV_WT_CLK_DN: CPU1.CP34 WLAN1.71
CNV_WT_CLK_DP: CPU1.CN34 WLAN1.73
CNV_WT_DN0: CPU1.CN32 WLAN1.65
CNV_WT_DN1: CPU1.CP33 WLAN1.59
CNV_WT_DP0: CPU1.CM32 WLAN1.67
CNV_WT_DP1: CPU1.CN33 WLAN1.61
CNV_WT_RCOMP: CPU1.CP32 CPU1.CR32 R2101.1
CNVI_EN#: CPU1.CR26 R6110.2
CNVI_EN#_R: Q6102.G R6101.1 R6110.1
CPU_DP1_CTRL_CLK: CPU1.CC8 Q5702.4 RN401.5(B)
CPU_DP1_CTRL_DATA: CPU1.CC9 Q5702.1 RN401.6(B)
CPU_DP1_HPD: CPU1.CN6 Q5703.E R5782.1
CPU_DP2_CTRL_CLK: CPU1.CH4 RN401.7(B)
CPU_DP2_CTRL_DATA: CPU1.CH3 RN401.8(B)
CPU_DP2_HPD: CPU1.CM6 Q401.6 R403.2 R404.1 R405.2
CPU_DP_HPD_MUX: R7206.1 U7201.11
CPU_DP_HPD_R: R7118.2 R7176.2 R7202.2 R7206.2 R7219.1 U5802.48
CPU_POPIRCOMP: CPU1.BP27 R304.1
CPU_SMB_SCL_THM: Q2601.4 RN2602.4(B) U2601.8
CPU_SMB_SDA_THM: Q2601.1 RN2602.3(B) U2601.7
CPVDD: C2704.1 C2705.2 HDA27.29 R2709.2
CPVEE: C2709.1 HDA27.27
CRT_AUX_CPU_N: R5822.2 R5825.1 R5831.1 VGABD1.14
CRT_AUX_CPU_N_R: R5831.2 R5845.1
CRT_AUX_CPU_P: R5823.2 R5824.1 R5830.1 VGABD1.13
CRT_AUX_CPU_P_R: R5830.2 R5844.1
CRT_DDI_TX_N0: R5826.1 R5841.1 VGABD1.7
CRT_DDI_TX_N1: R5829.1 R5843.1 VGABD1.10
CRT_DDI_TX_P0: R5827.1 R5840.1 VGABD1.8
CRT_DDI_TX_P1: R5828.1 R5842.1 VGABD1.11
CRT_DP_HPD: R5605.2 U5802.38
CRT_DP_HPD_R: AFTP5602.1 R5605.1 VGABD1.18
CTL1: R3601.2 U3601.6
CTL2: R3606.2 U3601.7
CTL3: R3602.2 U3601.8
DAT_ITE8010: R2455.1 WWAN1.13
DAT_TP_SIO: EC6501.1 RN6501.3(B) RN6502.2(A) U2401.79
DBC_EN_R: AFTP5522.1 LCD1.34 R5504.2
DBC_PANEL_EN: CPU1.CA31 R2043.2 R5504.1
DC_IN_OFF: Q4349.6 R4369.2 R4470.2
DCBATOUT: AFTP4403.1 AFTP4407.1 EC8923.1 EC8924.1 EC8932.1 EC8955.1 EC8956.2 EC8962.2 EC8963.1 F5503.2 FC4534.1 FC8921.1 FC8922.1 FC8923.1 FC8924.1 FC8925.1 FC8926.1 FC8927.1 FC8928.1 FC8929.1 FC8930.1 FC8931.1 FC8932.1 FC8933.1 FC8934.1 FC8935.1 FC8936.1 FC8937.1 FC8938.1 FC8939.1 FC8940.1 FC8941.1 FC8942.1 FC8943.1 FC8944.1 FC8945.1 FC8946.1 FC8947.1 FC8948.1 FC8949.1 FC8950.1 FC8951.1 FC8952.1 FC8953.1 FC8954.1 FC8955.1 FC8956.1 FC8957.1 FC8958.1 FC8959.1 FC8960.1 FC8961.1 FC8962.1 FC8963.1 FC8964.1 FC8965.1 FC8966.1 FC8967.1 FC8968.1 FC8969.1 FC8970.1 FC8981.1 FC8982.1 FC8983.1 FC8984.1 FC8985.1 FC8986.1 FC8987.1 FC8988.1 FC8989.2 PC4406.1 PC4407.1 PC4408.1 PC4409.1 PC4410.1 PC4411.1 PC4412.1 PC4413.1 PC4414.1 PC4418.1 PC4434.1 PC4437.1 PC4443.1 PC4501.1 PC4502.1 PC4503.1 PC4504.1 PC4505.1 PC4519.1 PC4522.1 PC4523.1 PD4401.2 PG4415.2 PG4419.2 PG5210.1 PG5212.1 PG5214.1 PL4702.1 PL4703.1 PL4803.1 PL4804.1 PR4477.1 PR4509.1 PR4511.1 PR4612.1 PU4405.5 PU4405.6 PU4405.7 PU4405.8 PU4413.1 PU4413.2 PU4413.3 PU4501.2 PU4501.3 PU4501.4 PU4501.5 PU4502.2 PU4502.3 PU4502.4 PU4502.5 R5010.1 R5011.1 R5115.1 R5116.1 R5118.1 R5551.2 R9309.1 R9316.1 R9319.1 R9320.1
DCBATOUT_C1: PMBD1.1 R9316.2 R9329.2
DCBATOUT_C6: PMBD1.16 R9309.2 R9335.2
DCBATOUT_C7: PMBD1.15 R9319.2 R9326.2
DCBATOUT_C8: PMBD1.19 R9320.2 R9324.2
DCBATOUT_LCD: AFTP5525.1 AFTP5526.1 C5512.1 C5513.1 C5514.1 C5528.1 D5504.A FC8974.1 LCD1.39 LCD1.40 R5556.2 R5558.2 R9303.1
DCBATOUT_LCD_C: PMBD1.4 R9303.2 R9333.2
DCBATOUT_LCD_PG: Q5505.1 R5546.2
DCBATOUT_LCD_PWRGD: C5531.1 D5504.K R5554.1 R5555.1
DCBATOUT_LCD_R: F5503.1 R5556.1 R5558.1 R9302.1
DCBATOUT_LCD_R_C: PMBD1.2 R9302.2 R9332.2
DDR4_DRAMRST#: C501.1 DM1.108 DM2.108 ED1217.1 ED1217.2 ED1302.1 ED1302.2 R504.2
DMIC_CLK_EDP: AFTP5510.1 EC5504.1 LCD1.22 RN5504.2(A) RN5505.1(A)
DMIC_DATA_EDP: AFTP5509.1 EC5503.1 LCD1.21 RN5504.1(A) RN5505.2(A)
DMIC_PCH_CLK: CPU1.CP24 RN5505.4(B)
DMIC_PCH_DATA: CPU1.CN24 RN5505.3(B)
DMIC_SCL_CODEC: R2738.1 RN5504.3(B)
DMIC_SCL_CODEC_R: HDA27.3 R2738.2
DMIC_SDA_CODEC: HDA27.2 RN5504.4(B)
DOCK_USB_EN_A: U7102.16 U7201.18
DOCK_USB_EN_B: U7102.10 U7201.13
DP2_AUX_C_N: R7101.2 R7104.2 U7101.25
DP2_AUX_C_P: R7102.2 R7103.2 U7101.24
DP2_AUX_CPU_N: C5854.1 CPU1.AD4 R5845.2
DP2_AUX_CPU_P: C5862.1 CPU1.AD3 R5844.2
DP2_DDI_TX_C_N2: C5806.2 R5856.1
DP2_DDI_TX_C_N2_R: R5856.2 U5802.13
DP2_DDI_TX_C_N3: C5808.2 R5858.1
DP2_DDI_TX_C_N3_R: R5858.2 U5802.16
DP2_DDI_TX_C_P2: C5805.2 R5855.1
DP2_DDI_TX_C_P2_R: R5855.2 U5802.12
DP2_DDI_TX_C_P3: C5807.2 R5857.1
DP2_DDI_TX_C_P3_R: R5857.2 U5802.15
DP2_DDI_TX_N0: C5804.1 CPU1.AC4 R5832.2
DP2_DDI_TX_N1: C5802.1 CPU1.AC1 R5839.2
DP2_DDI_TX_N2: C5806.1 CPU1.AE4
DP2_DDI_TX_N3: C5808.1 CPU1.AE1
DP2_DDI_TX_P0: C5803.1 CPU1.AC3 R5833.2
DP2_DDI_TX_P1: C5801.1 CPU1.AC2 R5838.2
DP2_DDI_TX_P2: C5805.1 CPU1.AE3
DP2_DDI_TX_P3: C5807.1 CPU1.AE2
DP2_DDI_TX_R_N0: C5804.2 R5859.1
DP2_DDI_TX_R_N0_R: R5859.2 U5802.7
DP2_DDI_TX_R_N1: C5802.2 R5861.1
DP2_DDI_TX_R_N1_R: R5861.2 U5802.10
DP2_DDI_TX_R_P0: C5803.2 R5854.1
DP2_DDI_TX_R_P0_R: R5854.2 U5802.6
DP2_DDI_TX_R_P1: C5801.2 R5860.1
DP2_DDI_TX_R_P1_R: R5860.2 U5802.9
DP2_DDI_TX_RE_C_N0: R7178.2 U7101.10
DP2_DDI_TX_RE_C_N1: R7180.2 U7101.13
DP2_DDI_TX_RE_C_N2: R7182.2 U7101.16
DP2_DDI_TX_RE_C_N3: R7184.2 U7101.19
DP2_DDI_TX_RE_C_P0: R7177.2 U7101.9
DP2_DDI_TX_RE_C_P1: R7179.2 U7101.12
DP2_DDI_TX_RE_C_P2: R7181.2 U7101.15
DP2_DDI_TX_RE_C_P3: R7183.2 U7101.18
DP2_DEMUX_OUT2_D0N: R5841.2 U5802.39
DP2_DEMUX_OUT2_D0N_R: R5826.2 R5832.1
DP2_DEMUX_OUT2_D0P: R5840.2 U5802.40
DP2_DEMUX_OUT2_D0P_R: R5827.2 R5833.1
DP2_DEMUX_OUT2_D1N: R5843.2 U5802.36
DP2_DEMUX_OUT2_D1N_R: R5829.2 R5839.1
DP2_DEMUX_OUT2_D1P: R5842.2 U5802.37
DP2_DEMUX_OUT2_D1P_R: R5828.2 R5838.1
DP2_HPD_CPU: Q401.5 R404.2 U5802.3
DPEQ0_A1: R7171.2 R7172.1 U7101.14
DPEQ1: R7147.2 R7170.1 U7101.2
EC_D_INHIB: C6405.1 D6403.A Q6408.B R6404.1 R6414.1 U2401.96
EDP_AUX_CON_N: C5521.2 LCD1.3
EDP_AUX_CON_P: C5526.2 LCD1.2
EDP_AUX_CPU_N: C5521.1 CPU1.AH4 FC5501.1
EDP_AUX_CPU_P: C5526.1 CPU1.AH3 FC5502.1
EDP_DISP_UTIL: CPU1.AM7 TP401.1
EDP_FHD_DET#: CPU1.CL36 R2068.2 R5565.2
EDP_FHD_DET#_R: LCD1.10 R5565.1
EDP_HPD: CPU1.CM7 RN5502.1(A) RN5503.4(A)
EDP_HPD_CONN: AFTP5521.1 LCD1.33 RN5503.5(B)
EDP_RCOMP_CPU: CPU1.AM6 R401.2
EDP_TX_CON_N0: C5525.2 LCD1.6
EDP_TX_CON_N1: C5523.2 LCD1.9
EDP_TX_CON_P0: C5524.2 LCD1.5
EDP_TX_CON_P1: C5522.2 LCD1.8
EDP_TX_CPU_N0: C5525.1 CPU1.AG4 FC5503.1
EDP_TX_CPU_N1: C5523.1 CPU1.AG2 FC5505.1
EDP_TX_CPU_P0: C5524.1 CPU1.AG3 FC5504.1
EDP_TX_CPU_P1: C5522.1 CPU1.AG1 FC5506.1
EDP_VDD_EN: CPU1.CG11 D5502.1
EMMC_CLK: CPU1.CP16 R6336.1 R6367.1
EMMC_CLK_R: R6367.2 U6301.M6
EMMC_CMD: CPU1.CR16 R6334.2 R6366.1
EMMC_CMD_R: R6366.2 U6301.M5
EMMC_D0: CPU1.CR20 R6325.2 R6358.1
EMMC_D0_R: R6358.2 U6301.A3
EMMC_D1: CPU1.CM20 R6326.2 R6359.1
EMMC_D1_R: R6359.2 U6301.A4
EMMC_D2: CPU1.CN19 R6328.2 R6360.1
EMMC_D2_R: R6360.2 U6301.A5
EMMC_D3: CPU1.CM19 R6329.2 R6361.1
EMMC_D3_R: R6361.2 U6301.B2
EMMC_D4: CPU1.CN18 R6330.2 R6362.1
EMMC_D4_R: R6362.2 U6301.B3
EMMC_D5: CPU1.CR18 R6331.2 R6363.1
EMMC_D5_R: R6363.2 U6301.B4
EMMC_D6: CPU1.CP18 R6332.2 R6364.1
EMMC_D6_R: R6364.2 U6301.B5
EMMC_D7: CPU1.CM18 R6333.2 R6365.1
EMMC_D7_R: R6365.2 U6301.B6
EMMC_RCLK: CPU1.CM16 R6335.1 R6368.1
EMMC_RCLK_R: R6368.2 U6301.H5
EMMC_RCOMP: CPU1.CK15 R2108.1
EMMC_RESET#: Q6302.D R2125.2 R6337.1 R6343.2 U6301.K5
EMMC_RST_N: CPU1.CN16 R2125.1
EQ0: R7142.2 R7143.1 U7101.38
EQ1: R7140.2 R7141.1 U7101.35
ESPI_ALERT#: CPU1.BV28 R1821.2
ESPI_CLK: EC1801.1 R1805.2 U2401.57
ESPI_CLK_CON: DBG1.2 TP6801.1
ESPI_CS#: CPU1.CA28 U2401.58
ESPI_CS#_CON: DBG1.5 TP6803.1
ESPI_IO0: RN1806.8(B) U2401.59
ESPI_IO0_CON: DBG1.9 TP6807.1
ESPI_IO1: RN1806.7(B) U2401.60
ESPI_IO1_CON: DBG1.8 TP6806.1
ESPI_IO2: RN1806.6(B) U2401.61
ESPI_IO2_CON: DBG1.7 TP6805.1
ESPI_IO3: RN1806.5(B) U2401.62
ESPI_IO3_CON: DBG1.6 TP6804.1
ESPI_RESET#: CPU1.CA27 U2401.53
ESPI_RST#_CON: DBG1.4 TP6802.1
EXT_PWR_GATE#: CPU1.CC37 R1731.2
FALL_INT2: Q7001.2 Q7001.3 R7010.2
FAN1_PWM: EC2601.1 R2614.1 RN2601.2(A) U2401.47
FAN1_TACH: D2403.A R2430.1 U2401.40
FAN_PWM1_C: AFTP2602.1 FAN1.4 R2614.2
FAN_TACH1: D2403.K EC2602.1 R2613.1 RN2601.1(A)
FAN_TACH1_C: AFTP2601.1 FAN1.3 R2613.2
FFS_INT1: CPU1.CG22 U7001.12
FFS_INT2: CPU1.CH12 Q7001.5 R2044.2 R7011.1 U7001.11
FFS_INT2_Q: HDD1.9 HDD2.12 Q7001.6 R7014.2
FLT_NXP3290: R7414.2 U7403.A4
FP1_USB20_CON_N: ED9202.6 FP1.3 R9209.1
FP1_USB20_CON_P: ED9202.1 FP1.4 R9210.1
FP1_USB20_N: CPU1.CG5 R9209.2
FP1_USB20_P: CPU1.CG6 R9210.2
FP_3D3V: C9201.1 C9202.1 ED9202.5 FP1.1 Q9201.D R2458.1 R9211.1
FP_EN#: C9203.1 Q9201.G Q9202.D R9212.2
FPR_SCAN#: FP1.7 R2458.2 U2401.42
GPD11/LANPHYPC: CPU1.BU34 R1721.2
GPD_7: CPU1.BV35 R1524.2
GPP_E23_STRAP: CPU1.CN4 TP402.1
GPP_H1_SFRM: CPU1.CJ32 R1913.2
GPP_H2_CLKREQ0: CPU1.CH29 R1912.2
GPP_H21: CPU1.CF25 R1522.2
GPP_H23: CPU1.CM26 R1513.2
GPPC_H18_VCCIO_LPM: CPU1.CN27 R4034.1
GPU_THM_SMBCLK: Q5801.3 R2459.2 R2460.2 U2401.12
GPU_THM_SMBDAT: Q5801.6 R2447.2 R2455.2 U2401.11
GSENSOR_CS: R7006.1 U7001.2
GSENSOR_SDO: R7007.2 U7001.3
H_CPUPWRGD: CPU1.AR2 ED301.2 R1714.1
H_PECI: C2405.1 R2437.1 U2401.94
HDA_BITCLK_CODEC: EC1901.2 HDA27.5 R1920.1
HDA_BITCLK_CPU: CPU1.BN37 R1920.2
HDA_CODEC_SDIN0: HDA27.7 R2724.2
HDA_RST_N_CPU: CPU1.BL35 TP1901.1
HDA_SDIN0_CPU: CPU1.BN35 R2724.1
HDA_SDOUT_CODEC: EC1903.1 HDA27.4 R1921.1
HDA_SDOUT_CPU: CPU1.BN36 R1512.2 R1909.2 R1921.2
HDA_SPKR_R: D2703.1 R2740.2
HDA_SYNC_CODEC: HDA27.9 R1908.1
HDA_SYNC_CPU: CPU1.BN34 R1908.2
HDD2_SATA_RX_CON_N: C6030.2 ED6001.4 ED6001.7 HDD1.16 HDD2.5
HDD2_SATA_RX_CON_P: C6031.2 ED6001.5 ED6001.6 HDD1.15 HDD2.6
HDD2_SATA_TX_CON_N: C6029.2 ED6001.2 ED6001.9 HDD1.18 HDD2.3
HDD2_SATA_TX_CON_P: C6028.2 ED6001.1 ED6001.10 HDD1.19 HDD2.2
HDD_DET#: CPU1.CG20 HDD1.6 R2047.2
HDD_DEVSLP: CPU1.CP8 R6002.1
HDD_DEVSLP_R: HDD1.13 HDD2.8 R6002.2
HDD_SATA_RX_N11: C6030.1 CPU1.BN10
HDD_SATA_RX_P11: C6031.1 CPU1.BN8
HDD_SATA_TX_N11: C6029.1 CPU1.BN4
HDD_SATA_TX_P11: C6028.1 CPU1.BN3
HDMI_DDI_TX_CMC_N0: C5781.2 EL5703.1 R5770.1 R5775.1
HDMI_DDI_TX_CMC_N1: C5779.2 EL5702.1 R5768.1 R5773.1
HDMI_DDI_TX_CMC_N2: C5777.2 EL5701.1 R5705.1 R5766.1
HDMI_DDI_TX_CMC_N3: C5724.2 C5783.2 EL5704.1 R5772.1 R5777.1
HDMI_DDI_TX_CMC_P0: C5782.2 EL5703.2 R5769.1 R5776.1
HDMI_DDI_TX_CMC_P1: C5780.2 EL5702.2 R5767.1 R5774.1
HDMI_DDI_TX_CMC_P2: C5778.2 EL5701.2 R5759.1 R5765.1
HDMI_DDI_TX_CMC_P3: C5724.1 C5784.2 EL5704.2 R5771.1 R5778.1
HDMI_DDI_TX_CON_N0: ED5702.4 ED5702.7 EL5703.4 ER5703.2 HDMI1.9 R5770.2
HDMI_DDI_TX_CON_N1: ED5701.5 ED5701.6 EL5702.4 ER5702.2 HDMI1.6 R5768.2
HDMI_DDI_TX_CON_N2: ED5701.2 ED5701.9 EL5701.4 ER5701.2 HDMI1.3 R5766.2
HDMI_DDI_TX_CON_N3: ED5702.1 ED5702.10 EL5704.4 ER5704.2 HDMI1.12 R5772.2
HDMI_DDI_TX_CON_P0: ED5702.5 ED5702.6 EL5703.3 ER5703.1 HDMI1.7 R5769.2
HDMI_DDI_TX_CON_P1: ED5701.4 ED5701.7 EL5702.3 ER5702.1 HDMI1.4 R5767.2
HDMI_DDI_TX_CON_P2: ED5701.1 ED5701.10 EL5701.3 ER5701.1 HDMI1.1 R5765.2
HDMI_DDI_TX_CON_P3: ED5702.2 ED5702.9 EL5704.3 ER5704.1 HDMI1.10 R5771.2
HDMI_DDI_TX_N0: C5777.1 CPU1.AL5
HDMI_DDI_TX_N1: C5779.1 CPU1.AJ5
HDMI_DDI_TX_N2: C5781.1 CPU1.AF6
HDMI_DDI_TX_N3: C5783.1 CPU1.AE5
HDMI_DDI_TX_P0: C5778.1 CPU1.AL6
HDMI_DDI_TX_P1: C5780.1 CPU1.AJ6
HDMI_DDI_TX_P2: C5782.1 CPU1.AF5
HDMI_DDI_TX_P3: C5784.1 CPU1.AE6
HDMI_HPD_B: Q5703.B R5781.1
HDMI_HPD_CON: ED5703.5 ED5703.6 HDMI1.19 R5764.2 R5781.2
HDMI_PLL_GND: Q5701.D R5705.2 R5759.2 R5773.2 R5774.2 R5775.2 R5776.2 R5777.2 R5778.2
HDMI_SCL_CON: ED5703.1 ED5703.10 HDMI1.15 Q5702.3 R5755.2
HDMI_SCL_R: D5701.2 R5755.1
HDMI_SDA_CON: ED5703.2 ED5703.9 HDMI1.16 Q5702.6 R5751.2
HDMI_SDA_R: D5701.1 R5751.1
HOST_DEBUG_TX: DBEC1.5 R2480.1 R6801.1 U2401.81
HOST_DEBUG_TX_CON: DBG1.11 R6801.2
HPDIN: R7176.1 R7190.2 U7101.32
HW_ACAV_IN: D6403.K PG4408.2 PQ4415.5 R4482.1 U2401.128
HW_ACAV_IN0: Q4349.2 R4481.1 R4482.2
HW_ACAVIN_NB: D4305.A D4309.A R4311.2 R4315.2 R4378.2 R4380.2 R4381.2 R4471.2 U2401.24 U4302.1
HW_ACAVIN_NB0: Q4349.5 R4470.1 R4471.1
I2C0_SCL_TCH_PAD: CPU1.CN11 EC6504.1 Q6504.1 Q9301.1 R2066.2 R6505.1 R9321.1
I2C0_SCL_TCH_PNL: AFTP5504.1 CPU1.CJ12 LCD1.15 R5518.2
I2C0_SDA_TCH_PAD: CPU1.CM11 EC6502.1 Q6504.4 Q9301.4 R2065.2 R6506.1 R9322.1
I2C0_SDA_TCH_PNL: AFTP5505.1 CPU1.CK12 LCD1.16 R5517.2
I2C1_SCL_R: AFTP6528.1 Q6504.6 R6505.2 RN6503.4(B) TP1.6
I2C1_SDA_R: AFTP6527.1 Q6504.3 R6506.2 RN6503.3(B) TP1.7
I2C_CLK: Q5801.4 R5834.2 U5802.1
I2C_CLK_PD: R7114.2 RN7202.3(B) U7201.17
I2C_CLK_PD_MUX: R7114.1 U7101.21
I2C_CTL_EN: R5812.2 R5821.2 U5802.2
I2C_DATA_PD: R7116.2 RN7202.4(B) U7201.16
I2C_DATA_PD_MUX: R7116.1 U7101.22
I2C_SDA: Q5801.1 R5817.2 U5802.60
I2CEN: C7166.2 R7173.1 R7174.2 U7101.17
I_ADP: C2435.1 R2421.2 U2401.110
I_BATT: C2431.1 R2483.2 U2401.114
IC_DELAY: C4344.1 U4302.4
ICSP_CLK: DBEC1.2 U2401.101
ICSP_CLR: DBEC1.6 R2414.1 U2401.87
ICSP_DAT: DBEC1.3 U2401.102
ILIM_HI: R3604.2 U3601.16
ILIM_LO: R3603.2 U3601.15
ILIM_SEL: R3605.2 U3601.4
IN_AUX_N: C5854.2 U5802.25
IN_AUX_P: C5862.2 U5802.24
INPUT3VSEL: CPU1.BT27 R1520.2 R1521.1
INT#_ITE8010: R2438.1 WWAN1.12
IO_DB_DET#: AFTP6609.1 CPU1.CM14 R6602.1
IO_DB_DET#_EC: R5563.1 R6610.1 R6611.2 U2401.34
IO_DB_DET#_GPPG5: CPU1.CH35 R6608.1
IO_DB_DET#_R: IOBD1.2 R6602.2 R6608.2 R6609.2 R6610.2
IR_CAM_DET#: AFTP5506.1 CPU1.CM22 LCD1.18 R2046.2
ISOLATE#: R3109.2 R3113.1 U3101.20
IST_TRIG: CPU1.CP36 TP620.1
ITP_PMODE: CPU1.W4 R604.2
JACK_PLUG: ED2911.1 HPMIC1.5 R2923.1
JACK_PLUG_DET: ED2912.2 HPMIC1.6 R2914.1
JGND: AFTP4302.1 DCIN1.1 DCIN1.2 DCIN1.3 EC4301.2 EC4302.2 EC4312.2 EC4313.2 EL4303.1 EL4304.1
JIO3_PCIE_WAKE#: AFTP6115.1 D1702.2 D2404.2 R1806.2 WLAN1.55
KB_BL_CTRL#: C6507.1 KBBL1.4 Q6501.D
KB_DET#: AFTP6567.1 CPU1.CM12 KB1.30 R2045.2
KB_LED_BL_DET: CPU1.CK36 R6507.1 R6508.1
KB_LED_DET_C: C6508.1 KBBL1.2 R6507.2
KB_LED_PWM: Q6501.G U2401.44
KBC_BEEP_R: D2703.2 R2739.2
KBC_PWRBTN#: FP1.2 Q6408.E R2432.1 RN6401.2(A)
KBC_PWRBTN#_C: AFTP6404.1 EC6403.1 ED6401.1 G6401.1 G6402.1 PWR1.2 RN6401.3(B)
KSI0: AFTP6548.1 KB1.22 RN2403.5(B) U2401.98
KSI1: AFTP6547.1 KB1.24 RN2403.7(B) U2401.99
KSI2: AFTP6545.1 KB1.26 RN2404.5(B) U2401.6
KSI3: AFTP6550.1 KB1.23 RN2403.6(B) U2401.7
KSI4: AFTP6544.1 KB1.27 RN2404.6(B) U2401.104
KSI5: AFTP6546.1 KB1.25 RN2403.8(B) U2401.105
KSI6: AFTP6543.1 KB1.28 RN2404.7(B) U2401.107
KSI7: AFTP6542.1 KB1.29 RN2404.8(B) U2401.108
KSO0: AFTP6557.1 KB1.13 RN2410.5(B) U2401.2
KSO1: AFTP6558.1 KB1.15 RN2412.8(B) U2401.14
KSO2: AFTP6556.1 KB1.14 RN2412.7(B) U2401.15
KSO3: AFTP6555.1 KB1.16 RN2409.5(B) U2401.16
KSO4: AFTP6551.1 KB1.20 RN2407.3(B) U2401.37
KSO5: AFTP6549.1 KB1.21 RN2407.4(B) U2401.38
KSO6: AFTP6553.1 KB1.18 RN2409.7(B) U2401.39
KSO7: AFTP6552.1 KB1.19 RN2409.8(B) U2401.50
KSO8: AFTP6554.1 KB1.17 RN2409.6(B) U2401.46
KSO9: AFTP6563.1 KB1.7 R2449.2 R2450.1 U2401.68
KSO10: AFTP6566.1 KB1.5 RN2411.3(B) U2401.72
KSO11: AFTP6565.1 KB1.6 RN2411.4(B) U2401.74
KSO12: AFTP6559.1 KB1.12 RN2412.6(B) U2401.75
KSO13: AFTP6562.1 KB1.9 RN2410.7(B) U2401.76
KSO14: AFTP6564.1 KB1.8 RN2410.6(B) U2401.77
KSO15: AFTP6561.1 KB1.10 RN2410.8(B) U2401.86
KSO16: AFTP6560.1 KB1.11 RN2412.5(B) U2401.92
L_BKLT_CTRL: CPU1.CH11 D5503.1
L_BKLT_EN: CPU1.CK11 R2427.2 R2435.2 R2436.1 R2438.2
L_BKLT_EN_L: D2401.2 R2427.1
LAN_CABLE_DETECT_R_#: R3104.1 U3101.26
LAN_CLK_CPU_N: CPU1.BD3 U3101.16
LAN_CLK_CPU_P: CPU1.BC3 U3101.15
LAN_LED0: Q3201.S R3203.1 U3101.27
LAN_LED0_Q: Q3201.D R3202.1 R3203.2
LAN_LED0_R: LED2.K R3202.2
LAN_MDI0_N: ED3201.2 ED3201.9 U3101.2 XF3202.8
LAN_MDI0_P: ED3201.1 ED3201.10 U3101.1 XF3202.7
LAN_MDI1_N: ED3201.5 ED3201.6 U3101.5 XF3202.12
LAN_MDI1_P: ED3201.4 ED3201.7 U3101.4 XF3202.11
LAN_MDI2_N: ED3202.2 ED3202.9 U3101.7 XF3201.12
LAN_MDI2_P: ED3202.1 ED3202.10 U3101.6 XF3201.11
LAN_MDI3_N: ED3202.5 ED3202.6 U3101.10 XF3201.8
LAN_MDI3_P: ED3202.4 ED3202.7 U3101.9 XF3201.7
LAN_PCIE_RX_C_N: C3107.2 U3101.18
LAN_PCIE_RX_C_P: C3102.2 U3101.17
LAN_PCIE_RX_N: C3107.1 CPU1.BP5
LAN_PCIE_RX_P: C3102.1 CPU1.BP6
LAN_PCIE_TX_N: C3109.1 CPU1.BR2
LAN_PCIE_TX_N_C: C3109.2 U3101.14
LAN_PCIE_TX_P: C3104.1 CPU1.BR1
LAN_PCIE_TX_P_C: C3104.2 U3101.13
LAN_WAKE#: CPU1.BU32 R1707.2
LANWAKE#: R2428.2 U2401.35
LANXIN: C3125.1 U3101.28 X3101.1
LANXOUT: C3116.1 U3101.29 X3101.3
LCD_BRIGHTNESS: AFTP5519.1 LCD1.31 RN5503.7(B)
LCD_CBL_DET#: AFTP5517.1 CPU1.CN14 LCD1.29 R2060.2
LCD_TST: D5503.2 RN5503.1(A) U2401.26
LCD_TST_C: AFTP5520.1 LCD1.32 RN5503.8(B)
LCD_VCC_TEST_EN: D5502.2 U2401.113
LCDVDD_EN: D5502.3 RN5502.4(A) U5501.4
LCDVDD_PG: Q5504.1 R5548.2
LCDVDD_PWRGD: C5535.1 D5505.K R5552.1 R5553.1
LDO1_CAP: C2703.1 HDA27.21 R2702.1
LDO2_CAP: C2711.1 HDA27.32
LDO3_CAP: C2722.1 HDA27.6
LID_CL_SIO#: D2402.K FP1.6 RN2406.2(A) RN6401.1(A) U2401.66 U2402.2
LID_CLOSE#_C: AFTP6401.1 EC6401.1 ED6401.2 PWR1.3 RN6401.4(B)
LINE1-L_C: C2907.2 R2922.1
LINE1-L_R: C2908.2 R2921.1
LINE1_L: C2907.1 HDA27.18
LINE1_R: C2908.1 HDA27.17
LINE1_VREFO: D2901.3 HDA27.24
LINE1_VREFO_D1: D2901.1 R2912.1
LINE1_VREFO_D2: D2901.2 R2913.1
LOM_CABLE_DETECT#: CPU1.CK34 R3104.2
LOM_TCT: C3203.1 XF3201.9 XF3201.10 XF3202.9 XF3202.10
LPS_SW: C7401.2 R7401.2 R7403.1 R7407.1 U7418.4
LPS_SW_A: Q7406.3 R7401.1
LPS_SW_C: Q7401.G R7406.2 R7408.1
LPS_SW_D: Q7406.6 R7408.2
LPS_SW_R: Q7401.D R7403.2
M2_PCIE_LED#: D6401.2 R6411.2 SSD1.10
M2_SSD_PEDET: CPU1.CP10 R6348.2 SSD1.69
M_A_A0: CPU1.AC37 DM1.144
M_A_A1: CPU1.AC36 DM1.133
M_A_A2: CPU1.AC34 DM1.132
M_A_A3: CPU1.AC35 DM1.131
M_A_A4: CPU1.AA35 DM1.128
M_A_A5: CPU1.AB35 DM1.126
M_A_A6: CPU1.AA37 DM1.127
M_A_A7: CPU1.AA36 DM1.122
M_A_A8: CPU1.AB34 DM1.125
M_A_A9: CPU1.W36 DM1.121
M_A_A10: CPU1.Y31 DM1.146
M_A_A11: CPU1.W34 DM1.120
M_A_A12: CPU1.AA34 DM1.119
M_A_A13: CPU1.AC32 DM1.158
M_A_A14: CPU1.AC31 DM1.151
M_A_A15: CPU1.AB32 DM1.156
M_A_A16: CPU1.Y32 DM1.152
M_A_ACT_N: CPU1.V35 DM1.114
M_A_ALERT_N: CPU1.W37 DM1.116
M_A_BA0: CPU1.W32 DM1.150
M_A_BA1: CPU1.AB31 DM1.145
M_A_BG0: CPU1.V34 DM1.115
M_A_BG1: CPU1.W35 DM1.113
M_A_CKE0: CPU1.U36 DM1.109
M_A_CKE1: CPU1.U37 DM1.110
M_A_CLK0: CPU1.V31 DM1.137
M_A_CLK1: CPU1.T31 DM1.138
M_A_CLK#0: CPU1.V32 DM1.139
M_A_CLK#1: CPU1.T32 DM1.140
M_A_CS#0: CPU1.AE32 DM1.149
M_A_CS#1: CPU1.AF32 DM1.157
M_A_DIMA_ODT0: CPU1.AE31 DM1.155
M_A_DIMA_ODT1: CPU1.AF31 DM1.161
M_A_DQ0: CPU1.A26 DM1.70
M_A_DQ1: CPU1.D26 DM1.83
M_A_DQ2: CPU1.D28 DM1.84
M_A_DQ3: CPU1.C28 DM1.66
M_A_DQ4: CPU1.B26 DM1.71
M_A_DQ5: CPU1.C26 DM1.67
M_A_DQ6: CPU1.B28 DM1.80
M_A_DQ7: CPU1.A28 DM1.79
M_A_DQ8: CPU1.B30 DM1.3
M_A_DQ9: CPU1.D30 DM1.4
M_A_DQ10: CPU1.B33 DM1.17
M_A_DQ11: CPU1.D32 DM1.21
M_A_DQ12: CPU1.A30 DM1.8
M_A_DQ13: CPU1.C30 DM1.7
M_A_DQ14: CPU1.B32 DM1.16
M_A_DQ15: CPU1.C32 DM1.20
M_A_DQ16: CPU1.J22 DM1.28
M_A_DQ17: CPU1.H25 DM1.42
M_A_DQ18: CPU1.G22 DM1.29
M_A_DQ19: CPU1.H22 DM1.24
M_A_DQ20: CPU1.F25 DM1.37
M_A_DQ21: CPU1.J25 DM1.38
M_A_DQ22: CPU1.G25 DM1.41
M_A_DQ23: CPU1.F22 DM1.25
M_A_DQ24: CPU1.D22 DM1.49
M_A_DQ25: CPU1.C22 DM1.46
M_A_DQ26: CPU1.C24 DM1.58
M_A_DQ27: CPU1.D24 DM1.62
M_A_DQ28: CPU1.A22 DM1.50
M_A_DQ29: CPU1.B22 DM1.45
M_A_DQ30: CPU1.A24 DM1.63
M_A_DQ31: CPU1.B24 DM1.59
M_A_DQ32: CPU1.H37 DM1.216
M_A_DQ33: CPU1.H34 DM1.215
M_A_DQ34: CPU1.K34 DM1.228
M_A_DQ35: CPU1.K35 DM1.225
M_A_DQ36: CPU1.H36 DM1.211
M_A_DQ37: CPU1.H35 DM1.212
M_A_DQ38: CPU1.K36 DM1.224
M_A_DQ39: CPU1.K37 DM1.229
M_A_DQ40: CPU1.N36 DM1.237
M_A_DQ41: CPU1.N34 DM1.233
M_A_DQ42: CPU1.R37 DM1.245
M_A_DQ43: CPU1.R34 DM1.249
M_A_DQ44: CPU1.N37 DM1.232
M_A_DQ45: CPU1.N35 DM1.236
M_A_DQ46: CPU1.R36 DM1.246
M_A_DQ47: CPU1.R35 DM1.250
M_A_DQ48: CPU1.G31 DM1.183
M_A_DQ49: CPU1.G32 DM1.186
M_A_DQ50: CPU1.H29 DM1.169
M_A_DQ51: CPU1.H28 DM1.173
M_A_DQ52: CPU1.G28 DM1.174
M_A_DQ53: CPU1.G29 DM1.170
M_A_DQ54: CPU1.H31 DM1.182
M_A_DQ55: CPU1.H32 DM1.187
M_A_DQ56: CPU1.L31 DM1.194
M_A_DQ57: CPU1.L32 DM1.195
M_A_DQ58: CPU1.N29 DM1.208
M_A_DQ59: CPU1.N28 DM1.207
M_A_DQ60: CPU1.L28 DM1.191
M_A_DQ61: CPU1.L29 DM1.190
M_A_DQ62: CPU1.N31 DM1.204
M_A_DQ63: CPU1.N32 DM1.203
M_A_DQS_DN0: CPU1.C27 DM1.74
M_A_DQS_DN1: CPU1.D31 DM1.11
M_A_DQS_DN2: CPU1.H24 DM1.32
M_A_DQS_DN3: CPU1.C23 DM1.53
M_A_DQS_DN4: CPU1.J35 DM1.219
M_A_DQS_DN5: CPU1.P34 DM1.240
M_A_DQS_DN6: CPU1.G30 DM1.177
M_A_DQS_DN7: CPU1.L30 DM1.198
M_A_DQS_DP0: CPU1.D27 DM1.76
M_A_DQS_DP1: CPU1.C31 DM1.13
M_A_DQS_DP2: CPU1.G24 DM1.34
M_A_DQS_DP3: CPU1.D23 DM1.55
M_A_DQS_DP4: CPU1.J34 DM1.221
M_A_DQS_DP5: CPU1.P35 DM1.242
M_A_DQS_DP6: CPU1.H30 DM1.179
M_A_DQS_DP7: CPU1.N30 DM1.200
M_A_PARITY: CPU1.W31 DM1.143
M_B_A0: CPU1.AG36 DM2.144
M_B_A1: CPU1.AG35 DM2.133
M_B_A2: CPU1.AF34 DM2.132
M_B_A3: CPU1.AG37 DM2.131
M_B_A4: CPU1.AE35 DM2.128
M_B_A5: CPU1.AF35 DM2.126
M_B_A6: CPU1.AE37 DM2.127
M_B_A7: CPU1.AC29 DM2.122
M_B_A8: CPU1.AE36 DM2.125
M_B_A9: CPU1.AB29 DM2.121
M_B_A10: CPU1.AG34 DM2.146
M_B_A11: CPU1.AC28 DM2.120
M_B_A12: CPU1.AB28 DM2.119
M_B_A13: CPU1.AK35 DM2.158
M_B_A14: CPU1.AJ35 DM2.151
M_B_A15: CPU1.AK34 DM2.156
M_B_A16: CPU1.AJ34 DM2.152
M_B_ACT_N: CPU1.W28 DM2.114
M_B_ALERT_N: CPU1.Y29 DM2.116
M_B_BA0: CPU1.AJ37 DM2.150
M_B_BA1: CPU1.AJ36 DM2.145
M_B_BG0: CPU1.W29 DM2.115
M_B_BG1: CPU1.Y28 DM2.113
M_B_CKE0: CPU1.T28 DM2.109
M_B_CKE1: CPU1.T29 DM2.110
M_B_CLK0: CPU1.AF29 DM2.137
M_B_CLK1: CPU1.AE29 DM2.138
M_B_CLK#0: CPU1.AF28 DM2.139
M_B_CLK#1: CPU1.AE28 DM2.140
M_B_CS#0: CPU1.AL37 DM2.149
M_B_CS#1: CPU1.AL35 DM2.157
M_B_DIMB_ODT0: CPU1.AL36 DM2.155
M_B_DIMB_ODT1: CPU1.AL34 DM2.161
M_B_DQ0: CPU1.AN35 DM2.8
M_B_DQ1: CPU1.AN34 DM2.3
M_B_DQ2: CPU1.AR35 DM2.16
M_B_DQ3: CPU1.AR34 DM2.21
M_B_DQ4: CPU1.AN37 DM2.4
M_B_DQ5: CPU1.AN36 DM2.7
M_B_DQ6: CPU1.AR36 DM2.17
M_B_DQ7: CPU1.AR37 DM2.20
M_B_DQ8: CPU1.AU35 DM2.24
M_B_DQ9: CPU1.AU34 DM2.28
M_B_DQ10: CPU1.AW35 DM2.41
M_B_DQ11: CPU1.AW34 DM2.29
M_B_DQ12: CPU1.AU37 DM2.38
M_B_DQ13: CPU1.AU36 DM2.25
M_B_DQ14: CPU1.AW36 DM2.37
M_B_DQ15: CPU1.AW37 DM2.42
M_B_DQ16: CPU1.AJ29 DM2.191
M_B_DQ17: CPU1.AJ30 DM2.190
M_B_DQ18: CPU1.AM32 DM2.207
M_B_DQ19: CPU1.AM31 DM2.208
M_B_DQ20: CPU1.AM30 DM2.203
M_B_DQ21: CPU1.AM29 DM2.204
M_B_DQ22: CPU1.AJ31 DM2.194
M_B_DQ23: CPU1.AJ32 DM2.195
M_B_DQ24: CPU1.AR31 DM2.215
M_B_DQ25: CPU1.AR32 DM2.211
M_B_DQ26: CPU1.AV30 DM2.228
M_B_DQ27: CPU1.AV29 DM2.225
M_B_DQ28: CPU1.AR30 DM2.216
M_B_DQ29: CPU1.AR29 DM2.212
M_B_DQ30: CPU1.AV32 DM2.224
M_B_DQ31: CPU1.AV31 DM2.229
M_B_DQ32: CPU1.BA35 DM2.50
M_B_DQ33: CPU1.BA34 DM2.46
M_B_DQ34: CPU1.BC35 DM2.63
M_B_DQ35: CPU1.BC34 DM2.58
M_B_DQ36: CPU1.BA37 DM2.49
M_B_DQ37: CPU1.BA36 DM2.45
M_B_DQ38: CPU1.BC36 DM2.59
M_B_DQ39: CPU1.BC37 DM2.62
M_B_DQ40: CPU1.BE35 DM2.71
M_B_DQ41: CPU1.BE34 DM2.67
M_B_DQ42: CPU1.BG35 DM2.83
M_B_DQ43: CPU1.BG34 DM2.80
M_B_DQ44: CPU1.BE37 DM2.70
M_B_DQ45: CPU1.BE36 DM2.66
M_B_DQ46: CPU1.BG36 DM2.79
M_B_DQ47: CPU1.BG37 DM2.84
M_B_DQ48: CPU1.BA32 DM2.232
M_B_DQ49: CPU1.BA31 DM2.237
M_B_DQ50: CPU1.BD31 DM2.245
M_B_DQ51: CPU1.BD32 DM2.249
M_B_DQ52: CPU1.BA30 DM2.236
M_B_DQ53: CPU1.BA29 DM2.233
M_B_DQ54: CPU1.BD29 DM2.250
M_B_DQ55: CPU1.BD30 DM2.246
M_B_DQ56: CPU1.BG31 DM2.173
M_B_DQ57: CPU1.BG32 DM2.169
M_B_DQ58: CPU1.BK32 DM2.183
M_B_DQ59: CPU1.BK31 DM2.182
M_B_DQ60: CPU1.BG29 DM2.170
M_B_DQ61: CPU1.BG30 DM2.174
M_B_DQ62: CPU1.BK30 DM2.187
M_B_DQ63: CPU1.BK29 DM2.186
M_B_DQS_DN0: CPU1.AP35 DM2.11
M_B_DQS_DN1: CPU1.AV34 DM2.32
M_B_DQS_DN2: CPU1.AL31 DM2.198
M_B_DQS_DN3: CPU1.AU31 DM2.219
M_B_DQS_DN4: CPU1.BB35 DM2.53
M_B_DQS_DN5: CPU1.BF34 DM2.74
M_B_DQS_DN6: CPU1.BC31 DM2.240
M_B_DQS_DN7: CPU1.BH31 DM2.177
M_B_DQS_DP0: CPU1.AP34 DM2.13
M_B_DQS_DP1: CPU1.AV35 DM2.34
M_B_DQS_DP2: CPU1.AL30 DM2.200
M_B_DQS_DP3: CPU1.AU30 DM2.221
M_B_DQS_DP4: CPU1.BB34 DM2.55
M_B_DQS_DP5: CPU1.BF35 DM2.76
M_B_DQS_DP6: CPU1.BC30 DM2.242
M_B_DQS_DP7: CPU1.BH30 DM2.179
M_B_PARITY: CPU1.AE34 DM2.143
M_VREF_CA_DIMMA: C1229.1 DM1.164 R1206.1 RN1201.3(B) RN1201.4(B)
M_VREF_CA_DIMMB: C1301.1 DM2.164 R1305.1 RN1301.3(B) RN1301.4(B)
MASK_SATA_LED#: Q6401.G R6403.2 U2401.56
MCT: C3202.1 RN3201.5(B) RN3201.6(B) RN3201.7(B) RN3201.8(B)
MCT0: RN3201.1(A) XF3201.3
MCT1: RN3201.2(A) XF3201.4
MCT2: RN3201.3(A) XF3202.3
MCT3: RN3201.4(A) XF3202.4
MDO0+: AFTP3204.1 RJ1.1 XF3202.6
MDO0-: AFTP3201.1 RJ1.2 XF3202.5
MDO1+: AFTP3202.1 RJ1.3 XF3202.2
MDO1-: AFTP3208.1 RJ1.6 XF3202.1
MDO2+: AFTP3205.1 RJ1.4 XF3201.2
MDO2-: AFTP3207.1 RJ1.5 XF3201.1
MDO3+: AFTP3209.1 RJ1.7 XF3201.6
MDO3-: AFTP3206.1 RJ1.8 XF3201.5
ME_FWP: AFTP6803.1 MESW1.3 R6878.1 U2401.80
ME_FWP_R: AFTP6802.1 MESW1.2 R1909.1 R6878.2
ME_SUS_PWR_ACK_R: CPU1.BV34 R1708.1 R1738.2
MEC_XTAL1_R: C2425.2 U2401.123 X2401.1
MEC_XTAL2: C2424.2 R2461.2 U2401.125 X2401.2
MEM_SMBCLK: CPU1.CK14 Q1801.3 RN1807.7(B)
MEM_SMBDATA: CPU1.CH15 Q1801.6 RN1807.8(B)
MESW1_B: AFTP6801.1 MESW1.1 R6804.1 R6877.1
MIC2_VREFO: HDA27.23 RN2901.1(A) RN2901.2(A)
MIC_CAP: C2715.1 HDA27.15
MODEL_ID: C2407.2 R2441.1 R2442.2 U2401.109
MSATA_DEVSLP_R: R6301.2 SSD1.38
MUX_CRT_AUX_CPU_N: R5825.2 U5802.29
MUX_CRT_AUX_CPU_P: R5824.2 U5802.28
MUX_HPD_PD: R7118.1 U7101.23
MUX_SAI: R7127.2 U7102.14
MUX_SAO: R7129.2 U7102.15
MUX_SBI: R7128.2 U7102.12
MUX_SBO: R7130.2 U7102.11
NB_MUTE#: R2712.1 R2717.2 U2401.119
NC_AUX_EN_WOWL_EC: R2403.1 R2409.1 U2401.41
NCT7718_DXN: C2606.2 C2607.2 Q2603.E U2601.3
NCT7718_DXP: C2606.1 C2607.1 Q2603.B Q2603.C U2601.2
NRB_BIT: CPU1.CE29 R1502.2
NUVOTON_PP: TP9104.1 U9103.4
NXP3290_FO: R7402.1 U7201.23 U7403.C4
NXP3290_ILIM: R7418.1 U7403.A3
NXP3290CAP: C7405.1 U7403.D4
ODD_SATA_RX_CON_N: AFTP6003.1 C6010.2 ODD1.4
ODD_SATA_RX_CON_P: AFTP6004.1 C6011.2 ODD1.5
ODD_SATA_RX_N12: C6010.1 R1616.1
ODD_SATA_RX_P12: C6011.1 R1609.1
ODD_SATA_TX_CON_N: AFTP6002.1 C6013.2 ODD1.2
ODD_SATA_TX_CON_P: AFTP6001.1 C6014.2 ODD1.1
ODD_SATA_TX_N12: C6013.1 R1610.1
ODD_SATA_TX_P12: C6014.1 R1611.1
OUT1_CA_DET: R5818.1 U5802.43
OUT2_CA_DET: R5819.1 U5802.33
PANEL_BKEN: D2401.3 RN5502.2(A) RN5503.3(A)
PANEL_BKEN_EC: D2401.1 U2401.117
PANEL_MONITOR: R5545.1 U2401.97
PANEL_PWRGD_R: C5529.1 Q5504.3 Q5505.3 R5545.2 R5547.1 R5549.2
PBAT_CHG_SMBCLK: EC4309.1 ED4306.3 PU4401.22 RN2402.3(B) RN4302.2(A) U2401.9
PBAT_CHG_SMBDAT: EC4310.1 ED4305.3 PU4401.21 RN2402.4(B) RN4302.3(A) U2401.8
PBAT_PRES1#: AFTP4309.1 BATT1.6 RN4302.5(B)
PBAT_PRES#: EC4306.2 ED4304.3 PR4409.2 R2415.1 RN4302.4(A) U2401.29
PBAT_SMBCLK1: AFTP4311.1 BATT1.4 RN4302.7(B)
PBAT_SMBDAT1: AFTP4310.1 BATT1.5 RN4302.6(B)
PC10: R5807.2 R5808.2 U5802.56
PC11: R5811.2 U5802.55
PC20: R5809.2 R5810.2 U5802.54
PC21: R5813.2 R5814.2 U5802.53
PCH_BATLOW#: CPU1.BV36 RN1704.8(B)
PCH_ESPI_CLK: CPU1.BV32 R1805.1
PCH_ESPI_IO0: CPU1.CA29 RN1806.1(A)
PCH_ESPI_IO1: CPU1.BY29 RN1806.2(A)
PCH_ESPI_IO2: CPU1.BY27 RN1806.3(A)
PCH_ESPI_IO3: CPU1.BV27 RN1806.4(A)
PCH_JTAG_TCK: CPU1.W6 R318.1
PCH_JTAG_TDI: CPU1.U5 R312.1
PCH_JTAG_TDO: CPU1.W5 R313.1
PCH_JTAG_TMS: CPU1.P5 R314.1
PCH_PLTRST#: CPU1.BJ35 R1713.2
PCH_POPIRCOMP: CPU1.BW25 R305.1
PCH_RSMRST#: EC1712.1 R1702.2 R6414.2 U2401.27
PCH_SMBCLK: AFTP1202.1 DM1.253 DM2.253 Q1801.4 RN1810.3(B) U7001.1 VGABD1.16
PCH_SMBDATA: AFTP1201.1 DM1.254 DM2.254 Q1801.1 RN1810.4(B) U7001.4 VGABD1.17
PCH_TPAN_VDD_EN: CPU1.CC30 R5562.1
PCH_WAKE#: CPU1.BU30 D1702.3 R2428.1 RN1704.6(B)
PCIE_LAN_WAKE#: D1702.1 D2404.1 R3103.1 U3101.21
PCIE_RCOMPN: CPU1.CE6 R1604.1
PCIE_RCOMPP: CPU1.CE5 R1604.2
PCIE_WAKE#: D2404.3 R2495.2 U2401.4
PD4403_A: PD4404.A PQ4408.B
PD4403_K: PD4404.K PR4452.2 PR4477.2
PD_SWD_CLK: TP7201.1 U7201.1
PD_VBUS_C_CTRL1: Q7405.2 Q7406.5 U7201.15
PD_VBUS_C_CTRL1_A: Q7404.3 Q7405.1
PD_VBUS_C_CTRL1_R: Q7405.5 Q7405.6 R7426.2 R7429.1
PD_VBUS_C_EN_A: Q7405.3 Q7407.5 Q7407.6 R7425.2 R7432.1
PD_VBUS_C_EN_B: Q7407.3 R7422.1 R7427.2 R7433.2 U7419.A3
PD_VBUS_DISCHG: Q7408.G R7415.1 U7201.12
PD_VBUS_DISCHG_N1: Q7408.D R7410.2
PD_VCCD: C7202.1 U7201.22
PD_XRES: C7213.1 R7211.1 U7201.7
PDB_R: HDA27.40 R2712.2
PECI_CPU: CPU1.AR1 R2437.2
PEQ: R5805.2 R5816.2 U5802.8
PIRQA#: CPU1.CC32 R2053.2 R9152.2
PLTRST#_CPU: AFTP6108.1 C1701.1 ED1701.2 R1713.1 R1715.1 R2616.1 R6370.2 SSD1.50 U3101.19 U9103.17 WLAN1.52 WWAN1.19
PLTRST#_CPU_D: Q6301.D Q6302.G R6369.2
PLTRST#_CPU_G: Q6301.G R6370.1
PM_LAN_ENABLE: R2466.1 U4001.5
PM_RSMRST#: CPU1.BP30 CPU1.BR36 Q1701.3 Q1702.2 R1702.1 RN1703.4(B)
PM_RSMRST#_M: Q1702.5 Q1702.6 R1737.2
PMBD_SCL_R: PMBD1.9 Q9301.6 R9321.2 RN9301.4(B)
PMBD_SDA_R: PMBD1.10 Q9301.3 R9322.2 RN9301.3(B)
POWER_SW_IN#: C2426.1 R2432.2 R2451.1 U2401.127
PQ3802_1: Q4302.B R4302.1 R4309.2
PQ4348_D: Q4348.D R4368.2 R4469.1
PQ4405_2: PQ4405.2 PR4462.1 PR4463.1
PQ4405_3: PQ4405.3 PR4476.1
PQ4405_5: PC4438.1 PQ4405.5 PR4474.2
PQ4405_6: PC4438.2 PQ4405.6 PR4450.1
PQ4408_C: PQ4408.C PR4462.2 PR4475.1
PQ4408_E: PQ4408.E PR4436.1 PR4473.2
PQ4417_D: PQ4417.D PR4431.2 PR4498.2
PQ4417_G: PQ4417.G PR4430.1
PQ4418_2: PQ4418.2 PR4498.1 PR4499.1
PQ4418_3: PQ4418.3 PR4433.1
PQ4418_5: PC4449.1 PQ4418.5 PR4497.2
PQ4418_6: PC4449.2 PQ4418.6 PR4432.1
PRIM_PWRGD: R4030.1 U2401.30
PROCHOT: Q2408.G R2417.1 U2401.83
PROCHOT#_CPU: ED2403.2 PQ4416.3 PR4433.2 PR4476.2 PR4603.2 PR4607.1 Q2408.D R301.2 R302.1
PROCHOT#_CPU_R: CPU1.Y4 R302.2
PROJECT_ID0: CPU1.CH23 R2113.2 R2114.1
PROJECT_ID1: CPU1.CK19 R2111.2 R2112.1
PROJECT_ID2: CPU1.CG17 R2117.2 R2118.1
PROJECT_ID3: CPU1.CN20 R2115.2 R2116.1
PS_ID: D4302.3 R4304.2 R4305.2 U2401.36
PS_ID_R: AFTP4304.1 DCIN1.4 EC4311.1 ED4303.1 Q4301.D R4309.1
PS_ID_R1: Q4301.S R4305.1
PSID_DISABLE#_R_C: Q4301.G Q4302.C R4303.2
PTP_DIS#: AFTP6526.1 TP1.3 U2401.90
PU4348_G: Q4348.G R4369.1 R4370.2 R4469.2
PULSAR_38P4M_REFCLK: R1804.2 WLAN1.64
PURE_HW_SHUTDOWN#: C2610.1 D4001.K Q2602.D R2615.1 R4014.2
PWR_1D05V_BST: PC5204.1 PU5201.20
PWR_1D05V_EN: PC5215.1 PR5210.2 PU5201.2
PWR_1D05V_FB: PC5212.2 PR5202.2 PR5204.1 PU5201.5
PWR_1D05V_FB_A: PC5212.1 PG5223.1 PR5202.1
PWR_1D05V_PFM#: PR5203.1 PU5201.3
PWR_1D05V_PH: PC5204.2 PL5201.1 PU5201.10 PU5201.11 PU5201.16 PU5201.17 PU5201.18
PWR_1D05V_SS: PC5213.1 PU5201.22
PWR_1D05V_TON: PR5201.2 PU5201.6
PWR_1D8V: PC5304.1 PC5305.1 PC5306.1 PG5301.1 PG5303.2 PU5301.3 PU5301.4
PWR_1D8V_EN: PC5303.1 PR5308.2 PU5301.8
PWR_1D8V_FB: PC5304.2 PR5304.2 PR5305.1 PU5301.2
PWR_1D8V_FB_A: PG5303.1 PR5304.1
PWR_1D8V_PG: PR5210.1 PR5301.2 PU5301.7
PWR_1D8V_VIN: PC5302.1 PG5302.1 PU5301.5 PU5301.9
PWR_2D5V: PC5111.1 PC5112.1 PC5113.1 PR5119.1 PR5121.2 PR5122.2 PU5101.3 PU5101.4
PWR_2D5V_EN: PC5127.1 PR5109.1 PR5117.1 PU5101.8
PWR_2D5V_FB: PC5111.2 PR5119.2 PR5120.1 PU5101.2
PWR_2D5V_PG: PG5122.1 PR5112.2 PU5101.7
PWR_3D3V_BOOT: PR4501.1 PU4501.1
PWR_3D3V_BOOT_A: PC4506.1 PR4501.2
PWR_3D3V_EN: PC4508.1 PR4508.1 PR4509.2 PU4501.11
PWR_3D3V_EN1: PC4532.1 PR4514.1 PR4516.2 PU4501.12
PWR_3D3V_FB: PC4533.1 PU4501.13
PWR_3D3V_FB2: PC4533.2 PR4506.2
PWR_3D3V_LDO: PC4507.1 PG4532.1 PU4501.16 PU4501.17
PWR_3D3V_PH: PC4506.2 PL4501.1 PU4501.6 PU4501.19 PU4501.20
PWR_3D3V_VOUT: PG4530.1 PR4506.1 PU4501.14
PWR_5V_BOOT: PR4502.1 PU4502.1
PWR_5V_BOOT_A: PC4521.1 PR4502.2
PWR_5V_EN: PC4530.1 PR4511.2 PR4512.1 PU4502.11
PWR_5V_EN1: PC4531.1 PR4504.2 PR4513.1 PU4502.12
PWR_5V_FB: PC4526.1 PR4551.1 PU4502.13
PWR_5V_FB_A: PC4526.2 PR4507.1
PWR_5V_LDO: PC4520.1 PG4528.1 PU4502.15
PWR_5V_PH: PC4521.2 PL4502.1 PU4502.6 PU4502.19 PU4502.20
PWR_5V_VCC: PC4524.1 PU4502.16 PU4502.17
PWR_5V_VOUT: PG4527.1 PR4507.2 PU4502.14
PWR_BD_DET#: AFTP6408.1 CPU1.CR14 PWR1.6 R2061.2
PWR_CHG_ACIN: PR4484.2 PR4485.1 PU4401.19
PWR_CHG_ACOK: PG4408.1 PR4426.1 PR4429.2 PR4463.2 PR4499.2 PU4401.24
PWR_CHG_ADP/ACIN: PR4434.1 PR4437.1 PU4401.16
PWR_CHG_AIN: PD4408.3 PR4404.1 PR4465.2
PWR_CHG_AIN_R: PC4420.2 PR4404.2 PR4406.1 PR4437.2 PR4484.1
PWR_CHG_AMON: PR4412.2 PU4401.29
PWR_CHG_ASGATE: PR4490.2 TP4401.1
PWR_CHG_ASGATE22: PC4442.2 PR4445.1
PWR_CHG_ASGATE/NTC: PR4490.1 PR4491.2 PU4401.13
PWR_CHG_BATGONE: PC4430.1 PR4409.1 PU4401.25
PWR_CHG_BGATE: PC4429.1 PR4443.1 PU4412.4
PWR_CHG_BGATE/HG2: PC4445.2 PR4443.2 PU4401.32
PWR_CHG_BGATE_22: PD4409.K PR4464.1 PR4495.1
PWR_CHG_BGATE_22_R: PC4443.2 PR4494.1 PR4495.2 PU4413.4
PWR_CHG_BOOT1: PR4402.2 PU4401.12
PWR_CHG_BOOT2: PC4423.1 PU4401.4
PWR_CHG_BT1_R: PC4436.2 PR4402.1
PWR_CHG_BT2_R: PC4423.2 PR4444.2
PWR_CHG_CMRSC: PC4442.1 PR4438.1 PR4439.2
PWR_CHG_COMP: PC4433.1 PR4411.1 PU4401.28
PWR_CHG_COMP_R: PC4431.1 PR4411.2
PWR_CHG_CSIN: PC4415.1 PC4417.2 PR4489.2 PU4401.14
PWR_CHG_CSIN_R: PG4402.2 PR4423.1
PWR_CHG_CSIN_RR: PR4423.2 PR4489.1
PWR_CHG_CSIP: PC4415.2 PC4416.2 PR4488.2 PU4401.15
PWR_CHG_CSIP_R: PG4401.2 PR4422.1
PWR_CHG_CSIP_RR: PR4422.2 PR4488.1
PWR_CHG_CSON: PC4425.2 PC4426.2 PR4487.1 PU4401.1
PWR_CHG_CSON_R: PG4406.2 PR4425.1
PWR_CHG_CSON_RR: PR4425.2 PR4487.2
PWR_CHG_CSOP: PC4424.2 PC4425.1 PR4486.1 PU4401.2
PWR_CHG_CSOP_R: PG4405.2 PR4424.1
PWR_CHG_CSOP_RR: PR4424.2 PR4486.2
PWR_CHG_DCIN: PC4419.1 PR4403.1 PU4401.17
PWR_CHG_DCIN_R: PD4401.3 PD4407.K PR4403.2
PWR_CHG_HG1_R: PR4414.2 PU4403.4
PWR_CHG_HG2_R: PR4420.2 PU4405.4
PWR_CHG_LGATE1: PU4401.9 PU4404.4
PWR_CHG_LGATE2: PR4446.1 PU4406.4
PWR_CHG_LGATE2/ASGATE: PR4445.2 PR4446.2 PU4401.7
PWR_CHG_NGATE: PC4439.2 PR4453.2 PR4480.1 PU4401.3
PWR_CHG_NTC: PR4491.1 PR4492.1
PWR_CHG_OTGEN: PR4417.2 PR4449.2 PR4451.1 PU4401.20
PWR_CHG_OTGPG: PR4447.1 PR4448.2 PU4401.26 TP4411.1
PWR_CHG_PHASE1: PC4436.1 PL4401.1 PL4402.1 PR4416.1 PU4401.10 PU4403.1 PU4403.2 PU4403.3 PU4404.5 PU4404.6 PU4404.7 PU4404.8
PWR_CHG_PHASE2: AFTP4405.1 PG4423.1 PL4401.2 PL4402.2 PR4441.1 PU4405.1 PU4405.2 PU4405.3 PU4406.5 PU4406.6 PU4406.7 PU4406.8
PWR_CHG_PHASE2_R: PR4441.2 PR4444.1 PU4401.6
PWR_CHG_PROCHOT#: PQ4416.2 PR4435.2 PU4401.23
PWR_CHG_PROCHOT#_R: PQ4416.5 PQ4416.6 PR4472.2
PWR_CHG_PROG: PC4441.1 PR4410.2 PR4493.1 PU4401.27
PWR_CHG_PSYS: PR4413.1 PR4442.1 PU4401.30
PWR_CHG_SNB: PC4435.1 PR4416.2
PWR_CHG_UGATE1: PR4414.1 PU4401.11
PWR_CHG_UGATE2: PR4420.1 PR4438.2 PU4401.5
PWR_CHG_VBAT1: PC4440.2 PC4445.1 PR4478.1 PU4401.31
PWR_CHG_VBATIN: AFTP4401.1 PG4406.1 PG4422.1 PR4407.2 PU4412.1 PU4412.2 PU4412.3 R4402.2 R9338.2
PWR_CHG_VBATIN_R: AFTP4404.1 AFTP4406.1 PG4405.1 PG4415.1 PG4423.2 PR4407.1 PR4480.2 PU4413.5 PU4413.6 PU4413.7 PU4413.8 R4401.2 R9337.2
PWR_CHG_VDDP: PC4421.1 PR4405.1 PU4401.8
PWR_DCBATOUT_1D05V: PC5209.1 PC5210.1 PC5211.1 PC5214.1 PC5216.1 PG5210.2 PG5212.2 PG5214.2 PR5201.1 PU5201.7 PU5201.8 PU5201.9
PWR_DCBATOUT_VCCGTA: PC4802.1 PC4803.1 PC4804.1 PC4805.1 PC4814.1 PC4815.1 PC4816.1 PC4817.1 PL4803.2 PL4804.2 PT4807.1 PU4801.8 PU4801.9 PU4801.10 PU4801.11 PU4801.33 PU4802.8 PU4802.9 PU4802.10 PU4802.11 PU4802.33 R9308.1
PWR_DCBATOUT_VCCGTA_C: PMBD1.3 R9312.2 R9330.2
PWR_DCBATOUT_VCCSA: AFTP5001.1 PC5002.1 PC5003.1 PC5004.1 PU5002.5 PU5002.6 PU5002.7 PU5002.8 R5010.2 R5011.2 R9318.1
PWR_DCBATOUT_VCCSA_C: PMBD1.17 R9318.2 R9323.2
PWR_DCBATOUT_VCORE: PC4701.1 PC4702.1 PC4703.1 PC4704.1 PL4702.2 PL4703.2 PT4702.1 PU4701.8 PU4701.9 PU4701.10 PU4701.11 PU4701.33 R9312.1
PWR_DCBATOUT_VCORE_C: PMBD1.14 R9308.2 R9334.2
PWR_DCBATOUT_VDDQ: PC5115.1 PC5119.1 PC5122.1 PD5101.K PR5106.1 PU5102.21 PU5102.22 PU5102.23 PU5102.24 PU5102.34 R5115.2 R5116.2 R5118.2 R9317.1
PWR_DCBATOUT_VDDQ_C: PMBD1.13 R9317.2 R9325.2
PWR_LED#: Q6402.S R6412.1 U2402.4
PWR_LED#_C: AFTP6407.1 PWR1.4 R6410.2
PWR_LED#_Q: Q6402.D Q6405.B R6412.2
PWR_LED#_R: EC6405.1 Q6405.C R6410.1
PWR_VCCGT_BOOTA: PR4826.2 PU4801.5
PWR_VCCGT_BOOTA_RC: PC4808.1 PR4826.1
PWR_VCCGT_BOOTB: PR4810.2 PU4802.5
PWR_VCCGT_BOOTB_RC: PC4811.1 PR4810.1
PWR_VCCGT_BOOTRA: PC4808.2 PU4801.7
PWR_VCCGT_BOOTRB: PC4811.2 PU4802.7
PWR_VCCGT_COMP: PC4610.2 PR4626.2 PU4601.4
PWR_VCCGT_COMP1: PC4612.1 PC4651.1 PR4626.1
PWR_VCCGT_FB: PR4630.2 PR4633.2 PR4636.2 PU4601.5
PWR_VCCGT_FB1: PC4614.1 PR4630.1
PWR_VCCGT_FB2: PC4615.2 PC4618.2 PC4619.1 PR4631.1 PR4633.1 PR4665.2
PWR_VCCGT_FB_RC: PC4618.1 PR4636.1
PWR_VCCGT_FCCM#: PR4806.2 PR4812.2 PU4601.11
PWR_VCCGT_FCCM#_RA: PR4806.1 PU4801.2
PWR_VCCGT_FCCM#_RB: PR4812.1 PU4802.2
PWR_VCCGT_IMON: PC4604.2 PR4608.2 PU4601.2
PWR_VCCGT_ISEN1: PC4625.1 PR4669.2 PR4821.1 PR4824.2 PU4601.9
PWR_VCCGT_ISEN2: PC4626.1 PR4669.1 PR4670.1 PR4822.2 PR4823.1 PU4601.10
PWR_VCCGT_ISUMN: AFTP4603.1 PC4625.2 PC4626.2 PC4630.2 PC4633.1 PR4642.2 PR4643.2 PR4645.2 PR4646.2 PR4647.1 PR4809.2 PR4815.2
PWR_VCCGT_ISUMN_GA: PG4809.1 PR4809.1 PR4822.1
PWR_VCCGT_ISUMN_GB: PG4815.1 PR4815.1 PR4824.1
PWR_VCCGT_ISUMN_P_1: PC4628.2 PC4653.2 PC4654.2 PR4647.2
PWR_VCCGT_ISUMN_P_2: AFTP4604.1 PR4641.2 PR4646.1
PWR_VCCGT_ISUMN_RC: PC4623.1 PR4645.1
PWR_VCCGT_ISUMNB: PC4623.2 PR4642.1 PU4601.8
PWR_VCCGT_ISUMP: PC4628.1 PC4630.1 PC4653.1 PC4654.1 PR4641.1 PR4643.1 PR4808.1 PR4816.1 PU4601.7
PWR_VCCGT_ISUMP_GA: PG4808.1 PR4808.2 PR4821.2
PWR_VCCGT_ISUMP_GB: PG4813.1 PR4816.2 PR4823.2
PWR_VCCGT_NTC: PR4616.1 PU4601.3
PWR_VCCGT_NTC1: PR4616.2 PR4617.1 PR4621.2
PWR_VCCGT_PWMA: PR4802.2 PU4601.12
PWR_VCCGT_PWMA_RA: PR4802.1 PU4801.1
PWR_VCCGT_PWMB: PR4811.2 PU4601.13
PWR_VCCGT_PWMB_RA: PR4811.1 PU4802.1
PWR_VCCGT_RTN: PC4619.2 PC4622.1 PR4639.1 PR4666.2 PU4601.6
PWR_VCCGT_SNB1: PC4810.1 PR4805.2
PWR_VCCGT_SNB2: PC4813.1 PR4814.2
PWR_VCCGT_SWA: PG4808.2 PL4801.1 PR4805.1 PU4801.16 PU4801.17 PU4801.18 PU4801.19 PU4801.20 PU4801.21 PU4801.22 PU4801.23 PU4801.24 PU4801.25 PU4801.26
PWR_VCCGT_SWB: PG4813.2 PL4802.1 PR4814.1 PU4802.16 PU4802.17 PU4802.18 PU4802.19 PU4802.20 PU4802.21 PU4802.22 PU4802.23 PU4802.24 PU4802.25 PU4802.26
PWR_VCCGT_VCCDA: PC4809.1 PR4825.1 PU4801.3
PWR_VCCGT_VCCDB: PC4812.1 PR4813.1 PU4802.3
PWR_VCCSA_BST: PR5001.2 PU5001.2
PWR_VCCSA_BST_RC: PC5005.1 PR5001.1
PWR_VCCSA_COMP: PC4624.1 PR4640.1 PU4601.24
PWR_VCCSA_COMP_RC: PC4601.1 PR4640.2
PWR_VCCSA_DRVH: PU5001.1 PU5002.4
PWR_VCCSA_DRVL: PU5001.5 PU5003.4
