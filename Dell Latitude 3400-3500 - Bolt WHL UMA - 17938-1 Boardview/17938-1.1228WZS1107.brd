# Allegro board 17938-1.1228WZS1107.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
V0.85A_VID0: length 9.5
  TOP w0.102: v1(115.24,83.26) 115.24,80.07 117.96,77.35 117.96,76.81 TP2201.1
  BOTTOM w0.076: CPU1.CB36 115.35,83.55 115.24,83.44 v1(115.24,83.26)
V0.85A_VID1: length 4.4
  BOTTOM w0.076: CPU1.CB35 115.26,84.96 115.13,84.83 115.13,84.52 115.1,84.43 115.1,84.19 115.12,84.13 115.12,83.77 114.85,83.49 114.85,82.91 114.98,82.78
  BOTTOM w0.102: TP2202.1 115.78,81.98 114.98,82.78
V3D3_STB: length 4.2
  TOP w0.127: R2708.2 20.84,14.81 21.31,14.81 22.31,13.82 v2(22.31,13.76) 22.31,13.67 22.31,13.67 22.41,13.57 HDA27.16
VBUS_P_CTRL: length 30.4
  TOP w0.102: U7201.14 38.1,111.16 37.98,111.04 37.98,111 v1(37.95,110.98) ; U7403.B4 42.63,121.98 v2(42.37,121.72) R7405.2 41.05,120.4 v1(40.64,120.4)
  L4 w0.102: v1(40.64,120.4) 40.06,119.81 37.85,119.81 37.21,119.18 37.21,119.15 36.93,118.86 36.93,114.56 38.25,113.24 38.25,111.27 v1(37.95,110.98)
  BOTTOM w0.102: v1(37.95,110.98) 37.76,110.78 37.39,110.78 36.82,110.21 36.19,110.21 36.09,110.11 33.33,110.11 32.76,110.68 27.6,110.68 27.48,110.55 27.48,110.07 27.24,109.83 26.52,109.83 26.27,109.58 Q7404.2
VBUS_P_CTRL_R: length 4.4
  BOTTOM w0.102: 26.76,111.56 26.92,111.4 Q7404.6 ; 26.76,111.56 26.27,111.07 Q7404.5 ; 26.76,111.56 26.76,111.91 R7430.1 27.5,113.6 R7423.2
VCC3PD:
  vias: v2(54.1,126.68)
VCCCORE_SENSE: length 79.2
  L3 w0.127: v1(144.41,141.62) 144.36,141.62 143.92,141.17 143.92,140.74 144.12,140.54 144.12,136.48 140.92,133.28 140.92,130.21 139.9,129.19 139.58,129.19 v1(139.47,129.08)
  L4 w0.127: v1(97.81,108.14) 97.14,107.48 97.14,104.69 97.44,104.39 97.44,103.51 v1(97.97,102.97)
  BOTTOM w0.127: CPU1.AN6 97.78,102.97 v1(97.97,102.97) ; v1(139.47,129.08) 139.43,129.08 138.92,128.58 138.38,128.58 137.53,127.73 126.58,127.73 126,127.14 123.57,127.14 118.21,121.78 118.21,120.58 117.95,120.32 113.4,120.32 112.53,121.18 108.24,121.18 105.77,121.18 104.61,120.03 102.98,120.03 101.58,118.62 101.58,118.32 ; 101.58,118.32 101.58,112.56 100.45,111.43 99.11,111.43 98.28,110.59 98.28,109.48 R707.2 98.05,108.38 v1(97.81,108.14) ; 101.58,118.32 v2(101.43,118.32) ; PR4665.1 143.94,141.74 144.07,141.62 v1(144.41,141.62)
VCCDSW_ON: length 172.4
  TOP w0.102: U2401.88 37.04,69.29 v1(35.94,70.38)
  BOTTOM w0.102: v1(35.94,70.38) 36.39,69.94 41.81,69.94 41.87,70 44.08,70 44.67,69.41 44.82,69.41 49.38,64.86 73.4,64.86 78.01,69.47 122.41,69.47 124.31,67.57 146.86,67.57 149.73,64.7 153.08,64.7 153.34,64.96 153.34,68.39 155.06,70.11 156.34,70.11 157.05,70.82 157.05,72.67 153.29,76.43 153.29,77.85 153.04,78.1 153.04,82.25 154.49,83.69 154.74,83.69 155.4,84.35 156.83,84.35 157.64,85.16 157.64,87.68 157.28,88.04 157.28,89.16 157.15,89.28 157.15,90.86 157.36,91.06 159.51,91.06 160.58,92.13 160.58,95.07 v2(160.11,95.55) 159.83,95.55 C2525.1 159.06,96.26 158.78,95.99 158.78,95.35 R2520.2 158.09,93.88 D2503.2
VCCGT_SENSE: length 109.9
  TOP w0.127: v1(80.19,105.97) 80.19,105.96 R807.2 ; v1(69.04,102.45) 68.86,102.06 68.86,102.05 68.9,101.93 68.91,101.93 68.93,101.87 69.08,101.87 72.8,105.59 72.8,111.94 70.42,114.31 70.42,125.18 v1(72.93,127.69)
  L4 w0.127: v1(129.75,129.92) 129.67,129.85 129.67,128.76 129.25,128.35 119.49,128.35 118.14,127 112.65,127 111.8,126.15 110.3,126.15 108.78,124.63 105.52,124.63 104.96,125.19 74.53,125.19 72.77,126.95 72.77,127.53 v1(72.93,127.69)
  BOTTOM w0.127: v1(129.75,129.92) 129.54,130.13 129.54,130.76 129.72,130.94 129.85,130.94 PR4667.1 ; v2(71.75,101.78) 71.75,101.66 ; 71.75,101.66 71.49,101.66 70.94,102.21 69.27,102.21 v1(69.04,102.45) ; 71.75,101.66 73.23,101.66 73.79,102.21 73.79,103.48 76.91,106.6 78.33,106.6 78.69,106.96 79.61,106.96 79.84,106.74 79.84,106.33 v1(80.19,105.97) 80.16,105.94 CPU1.E3
VCCPD_VBUS_ACK: length 37.7
  TOP w0.102: PR4430.2 13.52,129.96 v1(12.97,130.5) ; v1(36.92,119.95) 36.93,119.97 37.29,120.32 37.29,120.4 R7424.2 38.33,121.44 38.76,121.44 39.04,121.71 39.32,121.71 39.53,121.92 39.53,121.92 U7419.A2
  BOTTOM w0.102: v1(36.92,119.95) 36.88,119.95 36.78,120.05 36.06,120.05 35.6,120.5 31.26,120.5 30.93,120.83 29.3,120.83 29.17,120.96 29.02,120.96 28.98,120.99 27.47,120.99 27.43,120.96 27.29,120.96 26.5,120.17 25.32,120.17 24.41,121.08 20.65,121.08 20.22,121.51 20.22,123.43 20.62,123.83 20.62,125.92 18.88,127.66 17.26,127.66 16.68,128.25 16.68,129.78 16.51,129.95 16.08,129.95 15.34,130.68 13.16,130.68 v1(12.97,130.5)
VCCRTCEXT: length 1.4
  TOP w0.254: C2201.1 109.65,93.07 v1(109.65,92.38)
  BOTTOM w0.254: CPU1.BP24 110.04,92 v1(109.65,92.38)
VCCSA_SENSE: length 86.2
  TOP w0.127: 131.63,128.26 130.99,128.26 129.66,126.93 126.13,126.93 122.9,123.7 122.9,119.84 123.54,119.2 v1(123.54,119.04) ; 131.63,128.26 132.14,128.26 133,129.11 v1(133,129.26) ; 131.63,128.26 v2(131.63,128.4) ; v1(105.34,102.85) 105.34,102.83 104.69,102.18 R810.2 ; PR4601.2 127.03,140.29 126.8,140.29 v1(126.06,139.55)
  L4 w0.089: 110.3,104.15 110.3,104.13 110.33,104.1 110.33,102.63 110.06,102.36 108.47,102.36 107.87,101.76 106.04,101.76 105.83,101.97 105.83,102.27 105.34,102.76 v1(105.34,102.85)
  L4 w0.127: v1(123.54,119.04) 123.55,119.06 123.79,119.06 124.13,118.72 124.13,118.11 123.72,117.7 117.55,117.7 114.02,114.18 114.02,111.15 112.27,109.4 110.79,109.4 109.79,108.4 109.79,106.64 110.3,106.13 110.3,104.15 ; v1(126.06,139.55) 126.27,139.75 126.8,139.75 128.12,141.07 131.38,141.07 132.54,142.24 135.76,142.24 136.58,141.42 136.58,139.36 141.32,134.63 141.32,132.97 140.03,131.69 140.03,131.69 139.96,131.61 139.26,131.61 137.46,129.81 133.68,129.81 133.13,129.26 v1(133,129.26)
  BOTTOM w0.127: CPU1.BG7 105.57,102.62 v1(105.34,102.85)
VCCST_PWRGD_R: length 14
  BOTTOM w0.102: 104.24,110.78 104.24,110.77 104.3,110.72 104.3,110.62 104.55,110.36 104.55,108.48 105.19,107.84 105.46,107.84 106.65,106.65 106.65,106.23 CPU1.BJ2 ; 104.24,110.78 v2(104.19,110.78) ; 104.24,110.78 104.24,111.76 104.17,111.84 104.17,113.08 R1719.1 104.32,113.84 104.32,114.56 104.75,114.99 C1711.1 104.55,115.85 ED1707.2 104.74,116.6 R1716.2
VCCSTG_EN_R1: length 213.3
  TOP w0.089: v1(90.18,41.5) 90.18,41.89 89.87,42.2 v2(89.68,42.2) 89.65,42.2 89,41.55 88.92,41.55 88.53,41.16 88.53,40.48 R4017.2
  TOP w0.102: v1(142.97,86.28) 142.97,86.24 142.53,85.8 141.84,85.8 141.52,85.48 U4003.4
  L3 w0.102: v1(169.73,41.58) 169.24,42.06 151.41,42.06 149.33,39.98 130.66,39.98 127.54,43.11 123.76,43.11 121.63,45.23 108.22,45.23 107.37,44.38 103.2,44.38 102.92,44.66 101.94,44.66 101.87,44.59 100.62,43.35 99.64,43.35 99.33,43.66 98.8,43.66 96.93,41.79 94.53,41.79 93.86,41.12 90.56,41.12 v1(90.18,41.5)
  L4 w0.102: v1(151.51,99.19) 151.39,99.32 151.39,99.63 149.07,101.94 149.07,106.14 144.83,110.38 144.83,112.59 143.64,113.78 143.64,117.17 137.73,123.08 v1(137.73,123.4) ; v1(142.97,86.28) 143.29,86.28 144.49,85.08 144.49,84.34 147.51,81.32 147.51,78.85 147.95,78.41 147.95,76.26 148.71,75.5 148.71,73.37 154.57,67.5 154.57,66.73 155.2,66.1 155.2,66.02 155.21,66.02 155.21,64.74 169.73,50.22 v1(169.73,41.58)
  BOTTOM w0.102: v1(137.73,123.4) 135.66,121.34 131.35,121.34 128.55,118.54 128.55,116.61 127.31,115.37 C4033.1 124.86,115.08 U4002.4 ; v1(90.18,41.5) 90.18,41.5 90.18,41.07 90.42,40.83 U4007.4 ; v1(151.51,99.19) 151.51,98.93 150.19,97.61 150.19,97.61 145.13,92.56 145.13,90.51 143.71,89.09 143.71,88.29 143.08,87.66 143.08,87.66 142.83,87.4 142.83,86.54 142.95,86.41 142.95,86.29 v1(142.97,86.28)
VCCSTU_EN_R: length 20.3
  BOTTOM w0.102: U4006.4 118.36,125.01 119.56,126.21 119.56,126.7 C4034.1 120.3,126.36 121.84,126.36 124.13,128.65 v2(129.59,128.65) 133.91,128.65 133.96,128.6 134.57,128.6 134.58,128.61 135.18,128.61 135.31,128.47 R4024.2
VDD: length 45.1
  TOP w0.254: PR4429.1 208.37,49.43 208.34,49.43 208.09,49.68 PR4449.1 207.68,49.98 207.42,50.24 206.29,50.24 206.01,50.52 v1(205.9,50.52) ; v1(201.13,47.13) 200.77,46.76 198.12,46.76 PR4448.1 ; v1(203.47,45.11) 203.46,45.1 203.46,44.95 204.83,43.59 PR4427.1 ; v1(198.47,57.7) 199.07,57.09 199.76,57.09 201.04,55.81 204.89,55.81 205.13,55.57 v2(205.67,55.57) 205.7,55.57 206.08,55.19 206.08,54.04 205.56,53.52 v1(205.56,53.39)
  L3 w0.254: v1(205.56,53.39) 205.56,53.25 206.56,52.25 206.56,51.18 v1(205.9,50.52) 205.11,49.73 205.11,48.43 204.32,47.65 203.46,47.65 203.45,47.64 201.64,47.64 v1(201.13,47.13)
  L4 w0.254: v1(201.13,47.13) 201.13,45.68 201.7,45.11 203.47,45.11 v1(203.47,45.11)
  BOTTOM w0.203: PU4401.18 205.51,50.04 205.58,50.11 205.61,50.11 205.9,50.39 v1(205.9,50.52)
  BOTTOM w0.254: v1(205.9,50.52) 206.4,50.52 PC4422.1 ; PR4405.2 198.33,52.85 198.33,53.49 198.59,53.76 198.59,55.09 198.41,55.27 197.13,55.27 196.48,55.93 196.48,56.91 196.74,57.18 197.95,57.18 v1(198.47,57.7)
VDD10: length 21.9
  TOP w0.203: U3101.3 43.51,84.14 v1(43.42,84.22) ; v1(49.21,84.39) 49.18,84.35 49.14,84.35 48.93,84.14 U3101.22 ; v1(45.57,86.44) 45.49,86.36 U3101.30 ; v1(43.41,81.66) 43.41,81.66 43.49,81.74 43.91,81.74 44.14,81.96 U3101.8
  L4 w0.406: v1(45.57,86.44) 45.57,86.23 43.57,84.24 43.44,84.24 v1(43.42,84.22)
  BOTTOM w0.254: C3120.1 48.41,83.28 C3126.1 48.76,83.89 49.21,84.35 v1(49.21,84.39)
  BOTTOM w0.305: v1(49.21,84.39) 49.34,84.39 49.8,84.85 49.8,86.4 v2(49.72,86.48) 49.03,87.17 R3101.2 47.78,87.17 C3122.1 47.43,87.17 46.16,87.17 45.57,86.58 v1(45.57,86.44) 45.74,86.44 46.15,86.02 C3119.1 ; v1(43.42,84.22) 43.42,84.21 43.84,83.79 C3115.1 43.84,83.37 C3112.1 44,82.42 C3108.1 ; C3108.1 C3123.1 ; C3108.1 43.44,81.69 43.41,81.66 v1(43.41,81.66)
VDDD: length 57.8
  TOP w0.203: RN7201.2 38.95,115.22 38.03,115.22 R7202.1
  TOP w0.254: RN7201.2 39.02,115.65 v1(39.61,116.24) 39.61,115.22 RN7201.1
  TOP w0.305: 35.22,108.83 v1(35.22,108.71) ; 35.22,108.83 35.69,109.3 RN7202.2 ; 35.22,108.83 35.22,109.69 35.51,109.97 RN7202.1 ; R7211.2 42.19,115.57 v1(42.6,115.57)
  TOP w0.508: R7212.1 46,109.52 v1(46.13,109.65) ; R7204.2 51.78,126.61 v1(51.54,126.37)
  L3 w0.508: v1(39.5,106.87) 38.83,106.2 36.27,106.2 35.22,107.25 v1(35.22,108.71) ; v1(46.13,109.65) 45.39,109.65 44.91,109.17 41.17,109.17 v1(39.5,107.5)
  L4 w0.508: v1(39.5,106.87) v1(39.5,107.5) 39.5,110.36 40.96,111.82 40.96,114.19 40.99,114.22 40.99,115.97 40.58,116.38 39.75,116.38 v1(39.61,116.24)
  BOTTOM w0.508: v1(51.54,126.37) 51.49,126.42 48.1,126.42 45.23,123.54 45.23,122.95 44.61,122.33 43,122.33 41.89,121.21 40.56,121.21 40.01,120.66 40.01,118.9 40.5,118.42 41.21,118.42 41.84,117.79 41.84,116.51 ; v1(42.6,115.57) 42.23,115.57 41.84,115.97 41.84,116.51 ; v1(39.61,116.24) 39.69,116.24 39.96,116.51 41.84,116.51
  vias: v2(39.73,106.24)
VDDI: length 4
  TOP w0.089: U6301.C2 152.25,112.7 152.25,112.14 152.48,111.91 v1(152.76,111.91)
  BOTTOM w0.254: v2(152.89,111.28) 152.76,111.41 v1(152.76,111.91) 152.25,111.91 152.03,112.13 151.88,112.13 C6323.1 C6320.1
VDDIO: length 31.2
  TOP w0.305: R7414.1 42.05,119.5 41.74,119.18 40.82,119.18 40.76,119.12 v1(40.69,119.12) 40.63,119.12 40.57,119.18 40.45,119.18 R7402.2
  TOP w0.508: v1(51.54,125.73) 52.2,125.73 R7210.2
  L4 w0.254: v1(40.49,106.86) 41.16,106.86 41.84,107.54 41.84,110.92 41.76,111 41.76,118.05 v1(40.69,119.12)
  BOTTOM w0.508: v1(51.54,125.73) 51.26,125.73 51.21,125.78 48.36,125.78 45.86,123.28 45.86,122.67 44.81,121.62 43.4,121.62 40.9,119.12 v1(40.69,119.12)
  vias: v2(40.31,107.53)
VDDQ_PWRGD: length 5.2
  TOP w0.089: PG5114.1 v2(82.48,37.26) 82.48,38.91 82.9,39.33 R4011.1
VSSCORE_SENSE: length 79.2
  L3 w0.127: v1(139.53,128.45) 139.53,128.46 141.18,130.1 141.18,133.17 144.38,136.37 144.38,140.64 144.36,140.66 v1(144.36,140.98)
  L4 w0.127: v1(97.84,107.51) 97.56,107.51 97.39,107.34 97.39,104.8 97.69,104.5 97.69,103.89 v1(97.97,103.61)
  BOTTOM w0.127: v1(97.97,103.61) 97.97,103.61 97.79,103.61 CPU1.AN5 ; 103.29,119.77 104.72,119.77 105.87,120.93 108.13,120.93 112.43,120.93 113.29,120.07 118.06,120.07 118.47,120.48 118.47,121.68 123.68,126.89 126.1,126.89 126.69,127.47 137.63,127.47 138.48,128.32 139.03,128.32 139.26,128.55 139.44,128.55 v1(139.53,128.45) ; 103.29,119.77 103.09,119.77 101.83,118.52 101.83,112.46 100.55,111.18 99.22,111.18 98.53,110.49 98.53,109.78 R708.1 98.3,108.48 98.3,107.97 v1(97.84,107.51) ; 103.29,119.77 v2(103.29,119.62) ; v1(144.36,140.98) 144.34,140.98 143.79,141.53 PR4666.1
VSSGT_SENSE: length 110.7
  TOP w0.127: v1(68.23,102.14) 68.62,101.96 68.66,101.85 68.7,101.74 68.83,101.62 69.19,101.62 73.05,105.49 73.05,112.04 70.68,114.42 70.68,125.08 72.73,127.13 v1(73.24,127.13) ; R808.1 77.05,105.69 v1(77.05,106.13)
  L4 w0.127: v1(73.24,127.13) 73.24,126.84 74.64,125.45 105.06,125.45 105.63,124.88 108.67,124.88 110.19,126.4 111.69,126.4 112.54,127.25 118.03,127.25 119.38,128.6 129.15,128.6 129.42,128.87 129.42,129.38 v1(129.21,129.58)
  BOTTOM w0.102: CPU1.D2 79.5,105.94 79.15,106.29 78.89,106.29 78.72,106.12 78.72,106.02 78.53,105.84 78.43,105.84 78.26,105.67 78.26,104.93 78.06,104.74 77.66,104.74 77.42,104.98
  BOTTOM w0.127: v1(68.23,102.14) 68.41,101.96 70.83,101.96 71.38,101.4 73.34,101.4 73.84,101.91 ; 73.84,101.91 74.04,102.11 74.04,103.37 76.8,106.13 v1(77.05,106.13) 77.42,105.75 77.42,104.98 ; 73.84,101.91 v2(73.94,101.8) ; PR4668.1 129.82,131.19 129.62,131.19 129.29,130.87 129.29,130.1 129.26,130.07 129.26,129.64 v1(129.21,129.58)
VSSSA_SENSE: length 86.9
  TOP w0.127: R809.1 105.32,101.74 v1(105.32,102.22) ; v1(124.01,119.48) 123.89,119.48 123.83,119.54 123.56,119.54 123.15,119.95 123.15,123.59 126.23,126.67 126.5,126.67 ; 126.5,126.67 v2(126.5,126.54) ; 126.5,126.67 129.76,126.67 131.1,128 132.25,128 133.06,128.82 133.39,128.82 v1(133.66,129.08) ; v1(126.07,140.18) 126.09,140.18 PR4602.2
  L4 w0.089: v1(105.32,102.22) 105.51,102.22 105.64,102.09 105.64,101.89 105.96,101.57 107.95,101.57 108.54,102.17 110.14,102.17 110.52,102.55 110.52,104.1 110.56,104.13 110.56,104.15
  L4 w0.127: v1(126.07,140.18) 126.25,140.01 126.69,140.01 128.02,141.33 131.27,141.33 132.44,142.5 135.87,142.5 136.83,141.53 136.83,139.47 141.57,134.73 141.57,132.86 140.14,131.43 140.14,131.43 140.06,131.36 139.36,131.36 137.56,129.55 133.78,129.55 133.66,129.43 133.66,129.09 v1(133.66,129.08) ; v1(124.01,119.48) 124.01,119.2 124.39,118.82 124.39,118.01 123.83,117.45 117.66,117.45 114.28,114.07 114.28,111.05 112.38,109.15 110.9,109.15 110.05,108.3 110.05,106.75 110.56,106.24 110.56,104.15
  BOTTOM w0.127: CPU1.BE7 105.27,102.22 v1(105.32,102.22)
0D6V_PWR: length 29.8
  L2SGND w0.508: v3(92.46,27.97) 93.2,27.23 108.84,27.23 v1(109.48,27.87) 116.72,27.87 117.61,28.75 121.03,28.75 v1(121.24,28.96)
  vias: v1(120.98,29.92) v2(93.5,31.77) v2(95.77,37.82)
0D6V_S0: length 89.4
  TOP w0.508: 95.96,41.81 96.47,42.32 99.25,42.32 99.7,42.77 99.7,43.29 99.53,43.46 99.53,44.59 101.14,46.2 101.35,46.2 101.36,46.22 101.89,46.22 101.9,46.2 102.2,46.2 103.85,44.56 103.85,44.53 104.39,43.99 104.53,43.99 105.06,43.47 105.06,43.45 106.32,42.19 109.22,42.19 111.98,39.42 v2(120.17,39.42) 121.21,40.46 122.37,40.46 123.8,41.9 137.21,41.9 137.8,41.3 145.98,41.3 146.82,42.14 151.08,42.14 151.99,43.05 v2(163.08,43.05) 163.64,43.61 170,43.61 170.01,43.61 170.99,43.61
  BOTTOM w0.279: v1(173.01,44.34) 172.78,44.11 DM2.258
  BOTTOM w0.305: C1223.1 95.94,40.29 C1227.1 95.31,40.91 v4(95.31,41.13) 95.34,41.13 95.95,41.74 96.28,41.74 96.58,42.04 DM1.258
  vias: v2(95.13,42.24)
1D0V_S5: length 150.9
  TOP w0.254: R2402.1 42.25,74.22 42.14,74.11 41.49,74.11 41.47,74.09 v1(40.72,74.09)
  L3 w0.305: v1(43.38,80.98) 44.29,80.06 44.29,76.92 42.15,74.78 41.43,74.78 40.74,74.09 v1(40.72,74.09)
  L4 w0.254: v3(112.22,128.3) 111.23,128.3 109.58,126.65 109.35,126.65 108.44,125.74 105.61,125.74 105.53,125.81 100.97,125.81 100.5,126.29 75.11,126.29 73.97,127.43 73.97,127.46 73.23,128.2 72.67,128.2 72.39,127.92 72.39,125.61 70.79,124 63.02,124 62.57,124.46 60.15,124.46 59.72,124.03 55.91,124.03 55,123.12 55,119.84 56.21,118.63 56.21,117.42 56.77,116.85 56.77,114.5 55.71,113.44 55.71,108.08 55.71,106.82 55.71,106.82 55.71,103.21 54.72,102.22 54.53,102.22 53.94,101.63 53.92,101.63 53.85,101.57 52.84,101.57 52.54,101.27 48.19,101.27 47.22,100.31 47.22,96.56 46.99,96.33 46.99,94.01 48.71,92.29 48.71,87.49 47.7,86.48 47.7,85.92 46.62,84.84 45.85,84.84 44.9,83.89 44.9,82.44 43.44,80.98 v1(43.38,80.98)
  BOTTOM w0.178: v1(111.67,94.91) 111.66,94.91
  BOTTOM w0.254: v1(111.01,99.11) 111.01,99.13 CPU1.BT12 ; v1(110.35,99.11) 110.35,99.12 110.64,99.49 CPU1.BR12 ; CPU1.BU14 v1(111.66,99.13) CPU1.BU12 ; CPU1.BR15 v1(111.01,97.45)
  BOTTOM w0.305: v1(112.96,94.93) CPU1.BV20 v1(112.96,94.09) ; v1(112.96,94.93) CPU1.BW20 v1(113.61,94.09) ; v1(112.96,94.93) CPU1.BV19 CPU1.BV18 v1(112.95,96.6) CPU1.BV16 v1(112.32,97.45) ; CPU1.BT18 v1(111.68,96.62) CPU1.BU18 ; v1(111.67,94.91) CPU1.BU19 ; CPU1.BP22 v1(110.36,94.09) ; v1(110.36,94.09) CPU1.BP20 ; v1(110.36,94.09) CPU1.BR20 ; v1(111.66,94.09) CPU1.BT22 ; CPU1.BY20 v1(113.61,94.93) CPU1.BW19 CPU1.BW18 v1(113.61,96.61) ; v1(112.96,94.09) CPU1.BV22 112.54,93.58 112.08,93.58 CPU1.BU22 ; v1(112.96,94.09) CPU1.BW22 ; CPU1.CC12 115.93,99.49 v1(116.21,99.13) ; v1(113.61,96.61) CPU1.BY16 ; v1(113.61,96.61) CPU1.BW16 ; CPU1.CA20 v1(114.93,94.93) CPU1.CA19 CPU1.CA18 114.86,96.6 v1(114.89,96.61) CPU1.CA16 114.86,97.39 v1(114.92,97.45) 114.92,97.47 CPU1.CB15 ; v1(112.32,97.45) CPU1.BU15 ; v1(112.32,97.45) 112.32,97.5 CPU1.BV15 ; CPU1.BT19 v1(111.01,94.93)
  vias: v1(112.31,100.79) v1(112.31,96.61) v1(114.28,99.12) v1(114.91,99.14) v2(112.66,129.42) v2(114.08,105.33) v2(115.22,94.12) v2(119.06,117.84) v2(121.1,99.32) v2(124.79,115.43) v3(113.06,128.33) v3(113.92,128.32) v3(114.99,128.27) v3(115.83,128.27) v3(116.67,128.27) v3(117.5,128.27) v3(118.34,128.35) v3(125.23,116.43) v3(125.25,117.3) v3(129.31,99.19) v3(129.57,100.1) v3(130.15,99.29) v3(130.41,100.1)
1D0V_VCCA_XTAL: length 5.4
  TOP w0.254: R2202.2 123.9,101.76 C2231.1 123.9,102.34 C2219.1 123.37,103.02 123.64,103.29 v2(123.64,103.84) 123.64,104.04 v1(123.27,104.41)
  BOTTOM w0.152: v1(123.27,104.41) 123.26,104.41 123.18,104.33 122.82,104.33 122.74,104.24 CPU1.CP5
1D0V_VCCAMPHYPLL: length 12.8
  TOP w0.254: v1(112.3,106.88) 112.25,106.88 112.01,107.12 112.01,114.51 111.57,114.95 C2209.1 112.32,115.22 ; 112.32,115.22 v2(112.37,115.16) ; 112.32,115.22 112.02,115.52 112.02,116 C2208.1 111.94,116.44 R2205.2
  BOTTOM w0.254: v1(112.3,106.88) 112.3,106.83 112.46,106.67 CPU1.BV2
1D0V_VCCDSW: length 1.9
  TOP w0.127: v2(112.17,91.85) 111.66,92.36 v1(111.66,92.41)
  TOP w0.254: v1(111.66,92.41) 111.78,92.53 C2213.1
  BOTTOM w0.203: CPU1.BT24 v1(111.66,92.41)
1D0V_VCCPRIM_MPHY: length 3.7
  BOTTOM w0.305: CPU1.BY12 113.62,99.14 v1(113.61,99.13) ; CPU1.BY14 113.61,99.13 v1(113.61,99.13) ; v1(112.96,99.13) 112.68,99.49 CPU1.BV12 ; v1(112.96,99.13) CPU1.BW12 ; v1(112.96,99.13) CPU1.BV14 ; v1(112.96,99.13) CPU1.BW14 v1(113.61,99.13)
  vias: v2(112.97,97.21)
1D2V_S3: length 299.1
  TOP w0.305: v1(86.93,45.18) 86.51,44.76 EC1303.1 ; 76.43,45.65 77.03,45.65 v1(77.09,45.7) ; v1(72.75,49.56) 72.66,49.56 C1315.1 ; v1(43.61,45.09) C1317.1
  TOP w0.381: C1140.1 82.57,46.72 v1(82.81,46.72)
  TOP w0.508: v1(153.29,45.7) 152.83,45.7 ; v1(161.8,46.89) 162.28,46.41 C1218.1 162.84,45.49 EC8915.1 162.84,45.41 162.84,43.97 162.59,43.71 153.01,43.71 152.43,44.3 152.43,45.11
  L4 w0.508: v1(161.8,46.89) 162.16,47.25 162.16,50.35 v1(160,52.51) 159.22,52.51 151.33,60.41 150.32,60.41 149.61,61.12 149.61,63.22 147.24,65.58 147.24,66.51 139.66,74.09 138.55,74.09 135.89,76.75 134.2,76.75 132.91,78.04 132.91,78.04 132.9,78.05 132.9,78.99 v1(132.7,79.19)
  BOTTOM w0.076: CPU1.AM36 96.48,84.23 96.49,84.2 96.49,83.76 96.5,83.67 96.5,83.66 96.78,83.02 v1(96.78,82.93)
  BOTTOM w0.09: CPU1.AD36 91.44,83.38 v1(91.43,83.36) ; CPU1.AH36 93.96,83.45 93.94,83.43 v1(93.94,83.35)
  BOTTOM w0.102: CPU1.Y36 88.93,83.37 v1(88.92,83.36) ; CPU1.AY36 101.51,83.33 101.55,83.29 101.55,83.24 v1(101.58,83.21)
  BOTTOM w0.127: v1(106.64,83.46) 106.64,84.31 CPU1.BH36
  BOTTOM w0.203: v1(85.64,86.42) 85.67,86.45 CPU1.R32
  BOTTOM w0.254: DM2.33 114.53,52.43 114.78,52.69 115.05,52.69 124.41,52.69 125.02,52.07 125.02,51.1 DM2.75 ; 92.33,52.62 DM1.241 ; 63.83,52.44 DM1.135 ; 68.83,52.62 68.83,52.49 ; DM2.112 134.28,41.74 133.2,40.66 R505.1 ; 65.33,52.55 DM1.141 ; v1(97.91,87.31) 97.58,86.98 CPU1.AN32 ; 70.33,52.27 70.33,52.47 ; CPU1.AH32 94.27,87.37 94.27,87.96 v1(94.27,87.96) ; 57.83,52.67 DM1.111 ; 62.33,52.47 DM1.129 ; 59.33,52.64 DM1.117 ; 60.83,52.62 DM1.123
  BOTTOM w0.279: DM1.111 v1(57.83,49.64) ; CPU1.AW32 v1(101.62,87.4) ; DM1.142 65.58,44.39 65.74,44.55 v1(65.74,44.81) ; v1(70.58,44.34) DM1.154 ; DM2.220 163.28,44.11 163.27,44.12 163.27,45.32 161.8,46.79 v1(161.8,46.89) ; DM2.124 137.28,44.18 137.3,44.2 137.3,44.55 136.88,44.97 v1(136.78,44.97) ; DM2.148 145.28,44.35 145.26,44.37 v1(145.26,44.43) ; v1(66.88,49.16) 66.44,49.16 66.09,49.51 65.33,50.21 DM1.141 ; DM1.96 v1(54.08,44.59) ; v1(138.77,44.62) 138.78,44.62 DM2.130 ; v1(59.13,45.09) 59.6,44.63 59.6,44.22 59.58,44.2 DM1.118 ; DM2.142 141.78,44.5 141.62,44.65 v1(141.62,44.69) ; DM2.54 119.78,45.85 119.65,45.97 119.65,47.4 119.65,47.41 v1(119.65,47.61) ; DM2.154 146.78,44.6 146.75,44.63 v1(146.75,44.69) ; DM1.123 60.83,47.9 60.57,47.65 v1(60.57,47.61) ; v1(82.81,46.72) 82.81,46.72 81.83,47.7 DM1.199 ; DM2.75 125.03,48.53 124.81,48.32 v1(124.43,48.32) ; DM2.163 149.03,49.48 v1(149.2,49.31) ; v1(64.08,44.88) DM1.136 ; DM2.241 168.53,52.21 168.2,52.53 160.02,52.53 v1(160,52.51) 159.98,52.53 158.4,52.53 158.03,52.16 DM2.199 ; 71.83,52.51 71.52,52.81 70.87,52.81 70.33,52.27 ; 71.83,52.51 DM1.159 71.83,49.98 71.8,49.95 71.8,49.17 72.1,48.87 72.1,48.42 72.8,47.72 v1(72.93,47.72) ; 71.83,52.51 72.09,52.78 72.63,52.78 72.83,52.58 DM1.163 72.83,49.67 72.78,49.63 72.78,49.6 v1(72.75,49.56) ; v1(140.28,44.5) 140.28,44.5 DM2.136 ; v1(64.19,49.53) 64.11,49.53 63.83,49.82 DM1.135 ; v1(91.83,48.8) 91.97,48.8 92.33,49.16 DM1.241 ; DM2.135 140.03,50.36 140.07,50.31 140.07,49.8 v1(140.21,49.67) ; v1(138.67,49.58) 138.67,49.63 138.59,49.71 138.59,49.84 138.53,49.9 DM2.129 ; DM2.178 152.78,44.13 152.72,44.18 152.72,45.23 153.19,45.7 v1(153.29,45.7) ; v1(57.55,45.01) 57.65,45.01 58.1,44.56 58.1,44.13 58.08,44.11 DM1.112 ; DM1.220 87.08,44.29 87.01,44.36 87.01,45.1 v1(86.93,45.18) ; DM2.12 109.28,44.14 109.26,44.16 109.26,46.19 108.79,46.66 v1(108.79,47.21) ; DM2.118 135.78,44.2 135.8,44.22 135.8,44.66 v1(135.32,45.13) ; 38.33,52.15 DM1.33 38.33,47.92 37.35,46.94 34.08,46.94 33.07,45.93 33.07,44.14 33.08,44.14 DM1.12 33.08,42.09 33.41,41.76 43.36,41.76 43.52,41.91 43.52,41.92 43.57,41.97 43.58,41.97 DM1.54 43.58,45.05 v1(43.61,45.09) ; DM1.129 62.33,49.9 62.35,49.88 62.35,49.45 61.93,49.03 v1(61.83,49.03) ; DM2.112 134.28,44.11 134.3,44.13 134.3,44.56 133.94,44.91 133.87,44.91 v1(133.8,44.98) ; DM1.178 76.58,44.03 76.52,44.08 76.52,45.23 76.99,45.7 v1(77.09,45.7) ; v1(146.29,47.68) 146.25,47.68 145.2,48.73 145.2,49.39 145.07,49.52 145.07,49.96 145.03,50.01 DM2.147 145.03,52.03 145.24,52.24 146.24,52.24 146.53,51.95 DM2.153 ; 70.33,52.27 69.84,52.76 69.09,52.76 68.83,52.49 DM1.147 68.83,48.96 70.79,46.99 v1(71.14,46.99) ; 70.33,52.27 DM1.153 ; DM2.160 148.28,44.4 v1(148.28,44.4) ; DM1.130 62.58,44.62 v1(62.57,44.62) ; v1(135.59,49.67) 135.59,49.9 135.53,49.97 DM2.117 ; DM1.117 59.33,49.07 59.65,48.75 v1(59.83,48.75) ; DM2.96 v1(130.28,44.59) ; v1(141.53,49.66) 141.53,49.67 DM2.141 ; v1(149.61,47.8) 149.18,47.8 148.03,48.96 DM2.159 ; v1(60.61,45.42) 60.72,45.3 60.79,45.3 61.09,45 61.09,44.2 61.08,44.18 DM1.124 ; 105.29,87.69 v1(105.27,88.03) ; DM2.111 v1(134.03,49.64) ; v1(72.08,44.37) DM1.160 ; DM2.123 137.03,48 136.78,47.76 v1(136.78,46.24) ; v1(69.08,44.4) 69.08,44.4 DM1.148
  BOTTOM w0.305: 46.89,52.58 44.96,52.58 44.74,52.35 38.53,52.35 38.33,52.15 ; 71.68,41.63 72.08,42.02 DM1.160 ; C4043.1 132.98,78.9 v1(132.7,79.19) ; CPU1.BE32 104.96,86.98 105.29,87.31 105.29,87.69 ; DM1.154 70.58,41.34 71.14,40.78 C1308.1 ; DM1.142 65.58,40.46 C1310.1 ; 81.83,52.54 DM1.199 ; DM1.75 48.83,52.68 ; DM1.178 76.58,42.41 76.53,42.37 76.53,41.95 76.32,41.74 75.91,41.74
  vias: v1(57.83,48.37) v1(59.13,45.73) v1(62.54,46.59) v1(64.27,48.24) v1(64.8,46.24) v1(66.96,46.97) v1(69.16,46.42) v1(70.59,44.97) v1(86.77,79.48) v1(86.85,77.27) v1(86.85,75.34) v1(88.82,78.92) v1(88.75,77.04) v1(90.14,80.79) v1(91.32,78.82) v1(91.34,76.51) v1(91.85,53.87) v1(92.51,89.97) v1(92.46,80.42) v1(92.54,78.33) v1(93.88,82.08) v1(93.91,80.69) v1(93.91,79.35) v1(94.33,89.94) v1(95.24,80.78) v1(95.3,79.35) v1(97.18,81.38) v1(97.34,76.3) v1(134.03,48.37) v1(135.26,45.83) v1(135.59,48.24) v1(137.74,45.6) v1(139.65,48.19) v1(141.5,46.59) v1(141.83,48.38) v1(143.49,47.83) v1(145.29,45.72) v1(147.17,48.19) v1(148.34,46.59) v2(67.03,45.01) v2(91.59,87.18) v2(91.72,90.73) v2(94.38,75.6) v2(96.11,57.99) v2(116.87,44.41) v2(149.53,51.83) v3(87.07,53.85) v3(87.07,53.01) v3(98.02,51.89) v3(98.68,51.23) v3(99.4,50.52)
1D2V_VCCSFR_OC: length 16.7
  TOP w0.305: v1(108.91,89.94) 108.91,90.24 C803.1
  TOP w0.508: 132.95,83.16 132.95,82.52 132.86,82.43 132.86,82.38 130.6,80.12 128.01,80.12 127.32,80.22 127.28,80.26 127.18,80.27 126.93,80.27 126.63,80.31 126.07,80.88 125.14,80.88 125.12,80.9 124.57,80.9 124.3,80.63 123.65,80.63 123.06,81.23 v1(120.78,81.23)
  BOTTOM w0.127: CPU1.BM26 v1(108.91,89.94) 108.75,89.94 CPU1.BL27
  vias: v2(136.86,83.9)
1D05V_PWR:
  vias: v2(114.18,131.29) v2(119.18,132.89) v3(115.01,132.92) v3(115.04,132.06) v3(115.85,132.92) v3(115.88,132.06) v3(116.71,132.92) v3(116.72,132.06) v3(120.01,132.94) v3(120.02,132.08) v3(120.85,132.89) v3(120.85,132) v3(121.69,132.89) v3(121.69,132.01)
1D05V_S5_PWRGD: length 4
  BOTTOM w0.102: PU5201.1 117.4,142.17 117.22,142.34 116.84,142.34 116.67,142.52 115.7,142.52 v2(115.25,142.97) 114.62,143.6 R4029.1
1D8V_AVDD2: length 5.9
  TOP w0.203: v2(30.66,12.1) 30.58,12.1 30.57,12.11 30.49,12.11 29.84,12.77 HDA27.33
  TOP w0.305: v2(30.66,12.1) 30.73,12.1 31.55,11.28 C2710.2
  TOP w0.508: R2725.2 32.95,12.24 32.74,12.03 C2710.2
1D8V_EMMC: length 32.8
  TOP w0.127: v1(158.51,113.21) 158.5,113.21 158.5,113.26 158.31,113.45 U6301.P3 U6301.N4 U6301.P5 158.29,114.45 v1(158.52,114.68)
  TOP w0.203: U6301.M4 U6301.N4
  TOP w0.305: U6301.C6 152.6,114.95 153.01,115.36 v1(153.01,115.75)
  L3 w0.508: v1(153.01,115.75) 153.01,115.57 152.17,114.73 152.17,113.89 153.37,112.7 157.03,112.7 157.51,113.18 158.47,113.18 158.5,113.21 v1(158.51,113.21)
  BOTTOM w0.305: R6343.1 151.31,114.99 151.56,115.24 152.5,115.24 v1(153.01,115.75) 152.62,116.13 151.46,116.13 150.06,117.53 148.38,117.53 148.16,117.32 v2(147.75,117.32) R6326.1 ; R6326.1 R6331.1 146.77,116.53 146.77,115.71 R6325.1 146.77,115.68 R6330.1 146.77,114.74 146.78,114.73 R6329.1 146.78,113.23 R6334.1 ; R6326.1 146.76,118.16 R6332.1 146.77,118.2 146.77,119.01 R6328.1 146.78,119.03 R6333.1 ; C6319.1 159.35,114.68 v1(158.52,114.68)
  BOTTOM w0.508: R6327.1 160.71,114.65 C6321.1 C6319.1
1D8V_S0: length 269.1
  TOP w0.508: v1(31.88,6.49) 31.61,6.49 R2709.1 ; R2725.1 35.36,12.24 36.14,13.02 36.14,23.17 v1(36.07,23.24) 36.07,23.51 40.09,27.53 53.04,27.53 57.48,31.97 57.48,33.11 59.67,35.29 59.67,39.92 60.72,40.97 62.73,40.97 v1(63.27,41.51)
  L3 w0.508: v1(158.07,111.35) 158.07,111.29 157.19,110.41 157.19,108.57 157.18,108.56 157.18,108.35 156.81,107.98 156.63,107.98 154.42,105.77 154.42,105.28 154.09,104.95 154.09,97.12 154.18,97.03 154.18,96.63 157.71,93.09 157.71,92.01 158.91,90.82 159.16,90.57 160.21,90.57 162.4,88.38 162.4,88.34 162.79,87.95 162.79,86.99 162.57,86.76 162.57,85.52 163.02,85.07 163.02,83.85 163.86,83 163.86,81.3 171.92,73.25 172.16,73 172.16,71.86 172.62,71.4 173.26,71.4 v1(173.38,71.53)
  L4 w0.508: v1(151.65,57.16) 158.42,50.4 158.42,43.88 157.06,42.52 132.68,42.52 132.52,42.68 125.35,42.68 122.49,45.54 108.23,45.54 107.05,44.36 103.83,44.36 103.5,44.69 102.39,44.69 101.92,44.21 101.39,44.21 100.66,43.49 99.83,43.49 99.42,43.89 98.85,43.89 98.5,43.89 97.48,42.87 95.63,42.87 95.37,42.62 93.82,42.62 93.72,42.52 92.25,42.52 91.99,42.76 82.86,42.76 82.46,42.35 79.78,42.35 79.74,42.32 64.08,42.32 v1(63.27,41.51)
  BOTTOM w0.508: v1(31.88,6.49) 32.65,6.49 33.82,7.66 33.82,8.83 35.33,10.34 35.33,20.87 35.66,21.2 35.66,23 35.91,23.24 v1(36.07,23.24) ; R6327.2 159.85,113.13 v2(158.83,112.11) v1(158.07,111.35) ; v1(151.65,57.16) 155.49,57.16 157.08,58.75 161.91,58.75 165.05,61.89 165.05,62.66 167.42,65.03 167.42,67.46 171.36,71.4 173.26,71.4 v1(173.38,71.53)
1D8V_S0_CT1: length 3.3
  TOP w0.254: C4011.1 62.39,39.31 v2(62.39,38.52) 62.39,38.49 62.87,38.02 v1(62.87,37.92)
  BOTTOM w0.203: U4004.10 61.85,38.24 61.98,38.37 62.6,38.37 62.87,38.1 v1(62.87,37.92)
1D8V_S5: length 382
  TOP w0.127: R7428.2 34.78,103.07 35.73,104.02 36.65,104.02 37.09,103.58 37.09,102.86 37.29,102.67 R1515.1 37.83,102.52 v1(38.36,101.99)
  TOP w0.203: R2497.2 17.13,68.91 16.21,68.91 15.79,68.49 15.48,68.18 15.48,67.22 16.23,66.48 16.23,65.58 15.73,65.08 15.73,64.61 v1(16.06,64.28) ; R6369.1 145.93,110.16 v2(145.69,110.4) 143.96,112.13 143.96,112.15 143.94,112.17 143.94,116.61 144.33,116.99 v1(144.45,116.99) ; v1(35.44,23.98) 35.73,23.98 39.85,28.1 v2(39.99,28.1) 51.97,28.1 56.32,32.44 56.32,33.52 57.07,34.28 57.07,35.36 56.36,36.06 56.36,38.23 56.87,38.73
  TOP w0.305: R2462.2 34.18,55.47 33.4,54.68 v1(32.83,54.68)
  L2SGND w0.203: v1(32.83,54.68) 32.83,54.57 32.07,53.81 32.07,52.87 31.87,52.68 30.25,51.06 30.25,48.21 30.51,47.96 30.51,46.88 30.5,46.86 30.5,46.53 30.43,46.46 30.43,44.27 31.55,43.16 31.94,43.16 33.25,41.84 33.25,40.93 v1(33.25,40.93)
  L3 w0.203: v1(35.44,23.98) 34.72,23.98 34.14,24.56 23.67,24.56 23.49,24.75 17.68,30.56 17.68,30.78 17.68,40.15 17.17,40.67 17.17,42.63 16.6,43.2 16.32,43.48 16.32,51.97 16.93,52.58 16.93,57.19 16.31,57.82 16.09,57.82 15.4,58.51 15.4,60.15 15.09,60.45 15.09,62.79 15.46,63.16 15.46,63.85 15.89,64.28 v1(16.06,64.28) ; v1(38.36,101.99) 39.47,101.99 41.75,104.27 41.94,104.27 46.41,108.74 46.51,108.74 46.53,108.76 47.56,108.76 47.85,109.05 47.85,110.18 48.64,110.97 48.64,115.42 50.58,117.35 50.9,117.35 51.62,118.06 51.62,120.15 51.17,120.6 51.17,121.64 51.95,122.42 51.95,122.59 52.96,123.6 60.91,123.6 63,125.68 63,128.17 62.46,128.7 62.46,134.09 65.23,136.86 69.19,136.86 70.22,135.83 71.14,135.83 73.26,137.94 73.26,143.38 79.27,149.4 98.48,149.4 99.2,148.68 103.34,148.68 104.84,150.17 119.3,150.17 122.15,147.32 136.43,147.32 139.73,144.02 139.73,136.09 137.75,134.11 137.42,134.11 137.04,133.73 137.04,131.92 138.31,130.65 138.31,122.74 144.05,116.99 v1(144.45,116.99)
  L3 w0.305: v1(33.25,40.93) 33.84,41.52 51.19,41.52 52.84,39.86 56.37,39.86 56.83,39.4 v1(57.13,39.4)
  L4 w0.203: v1(16.06,64.28) 16.82,64.28 18.21,65.67 18.21,66.52 18.47,66.77 18.47,66.92 19.29,67.74 19.29,68.88 19.36,68.94 19.36,69.33 20.15,70.12 20.15,71.65 20.15,71.66 20.15,71.99 20.43,72.27 20.76,72.27 21.9,73.41 23.58,73.41 24.62,74.45 37.11,74.45 39.92,77.25 39.92,95.72 39.62,96.02 39.62,97.77 38.36,99.03 v1(38.36,101.99)
  vias: v1(59.03,41.38) v1(59.69,41.37) v2(57.83,40.61) v2(66.71,42.08)
1D8V_VCCPRIM: length 208.1
  TOP w0.152: R1738.1 116.42,89.74 116.02,89.74 115.72,89.44 115.72,87.72 115.58,87.57 115.58,85.78 113.62,83.83 113.62,82.58 113.44,82.4 113.03,82.4 112.73,82.1 112.73,80.67 111.34,79.28 v1(111.34,78.75) 111.42,78.67 114.82,78.67 117.3,76.18 R2053.1
  L4 w0.711: 129.47,94.82 132.01,94.82 138.91,87.92 138.91,86.25 141.4,83.76 141.93,83.76 142.76,82.93 142.76,82.54 143.06,82.24 143.06,81.74 144.07,80.72 144.07,79.73 145.17,78.63 145.17,74.64 153.01,66.8 153.01,66.08 153.64,65.45 153.64,63.05 158.89,57.8 159.12,57.8 167.27,49.65 167.27,43.95 168.76,42.45 168.76,41.18 169.07,40.88 169.07,40.32 167.71,38.96 163.05,38.96 161.75,37.67 160.46,37.67 160.03,37.24 160.03,36.49 159.64,36.1 156.31,36.1 155.9,36.51 154.33,36.51 153.58,37.27 150.87,37.27 148.74,39.4 125.37,39.4 123.48,41.29 123.48,41.44 121.34,43.58 109.85,43.58 108.05,41.78 102.48,41.78 102.37,41.68 100.6,41.68 100.4,41.48 99,41.48 97.03,39.51 92.05,39.51 91.99,39.57 91.3,39.57 91.03,39.31 85.09,39.31 84.93,39.14 74.39,39.14 74.38,39.14 72.38,39.14 72.38,39.14 71.38,39.14 70.51,38.28 68.1,38.28 67.26,39.12 v3(66.22,39.12)
  BOTTOM w0.127: v1(123.01,92.88) 123,92.88 122.96,92.84 122.3,92.84 CPU1.CP23 ; v1(123.51,96.48) 123.46,96.53 123,96.53 122.97,96.56 122.35,96.56 CPU1.CP17
  BOTTOM w0.305: v1(111.34,78.75) 111.24,78.64 R1512.1
  vias: v1(116.21,97.46) v1(116.21,96.6) v1(116.2,95.76) v2(120.92,88.44) v2(123.87,88.37) v3(128.6,93.4) v3(129.47,93.4)
1D24V_VCCDPHY: length 2.7
  BOTTOM w0.305: CPU1.BY23 v1(113.61,92.41) CPU1.BY24 ; v1(114.26,91.58) 114.41,91.76 CPU1.CA24 v1(114.26,92.41) CPU1.CA23
  vias: v2(114.98,92.34)
1D24V_VCCDPHY_EC: length 5.4
  TOP w0.508: v1(124.31,90.92) 124.21,91.02 124.21,91.28 123.44,92.05 C2218.1 123.07,92.05 v2(122.3,91.29)
  BOTTOM w0.254: CPU1.CP25 123.04,91.52 123.09,91.47 123.76,91.47 v1(124.31,90.92)
2D5V_S3: length 177.2
  TOP w0.305: C1313.1 97.82,50.17 v2(97.92,50.06) ; C1313.1 97.16,49.84 v1(96.88,49.56) ; C1313.1 C1207.1 97.16,51.69 C1231.1
  TOP w0.508: C1311.1 171.07,52.14 170.41,52.8 v1(170.27,52.8)
  L3 w0.508: v1(173.6,49.94) 173.6,51.29 173.6,52.61 164.63,61.57 163.83,61.57 v1(163.73,61.47)
  L4 w0.508: v1(96.88,49.56) 96.91,49.56 96.96,49.51 98.07,49.51 98.71,48.87 98.73,48.87 100.05,47.55 v1(103.79,47.55) ; v1(172.98,72.04) 172.82,72.04 164.11,80.75 164.11,83.05 163.14,84.03 163.14,86.17 163.9,86.93 163.9,88.46 159.89,92.46 159.46,92.46 156.03,95.89 156.03,105.2 163.3,112.47 163.3,117.25 161.79,118.76 v1(161.64,118.76)
  BOTTOM w0.279: DM1.259 96.83,49.62 v1(96.88,49.56) 96.85,49.56 96.33,50.08 DM1.257
  BOTTOM w0.457: v1(170.27,52.8) 168.8,52.8 168.45,53.14 164.08,53.14 158.17,53.14 157.35,52.33 146.85,52.33 146.44,52.74 144.3,52.74 143.84,53.2 116.21,53.2 111.73,53.2 110.9,52.36 110.53,52.36 110.5,52.34 105.27,52.34 104.02,51.08 104.02,47.78 v1(103.79,47.55)
  BOTTOM w0.508: v1(172.98,72.04) 171.1,72.04 170.73,71.66 166.79,67.73 166.79,65.3 164.37,62.87 164.37,62.1 v1(163.73,61.47)
3D3V_AUX_S5: length 464.5
  TOP w0.254: v1(203.11,64.07) 203.75,64.71 207.74,64.71 209.76,66.73 211.56,66.73 212.31,65.98 212.31,62.99 AFTP6402.1 211.74,61.95 v1(211.74,60.58)
  TOP w0.305: v1(16.04,67.76) 16.04,67.68 16.11,67.62 16.11,67.14 16.74,66.51 R1726.2
  TOP w0.508: v2(27.5,97.17) 26.91,97.17 v1(26.9,97.18)
  L2SGND w0.508: v1(72.04,140.51) 72.95,141.43 74.3,141.43 74.93,142.06 74.93,143.31 77.22,145.6 85.85,145.6 86.49,144.96 91.59,144.96 92.45,145.82 92.98,145.82 93.81,144.98 97.97,144.98 98.85,144.11 106.64,144.11 108.73,146.19 118.52,146.19 120.77,143.94 128.53,143.94 129.95,145.37 140.11,145.37 140.11,145.37 140.97,145.37 141.75,146.16 143.03,146.16 143.81,145.37 147.24,145.37 147.41,145.54 148.9,145.54 148.9,145.54 153.45,145.54 155.01,147.1 157.14,147.1 157.51,146.74 v1(157.51,146.71)
  L3 w0.254: v1(16.04,67.76) 15.98,67.76 15.85,67.89 15.85,68.62 16.12,68.89 16.62,68.89 17.02,69.29 17.02,69.9 17.84,70.72 17.84,72.12 18.02,72.3 18.02,72.61 19.62,74.21 19.62,74.96 22.08,77.42 27.42,77.42 27.54,77.29 27.55,77.29 28.1,76.74 28.1,76.74 28.32,76.51 29.53,76.51 29.91,76.13 31.22,76.13 31.28,76.19 35.66,76.19 35.98,76.51 37.79,76.51 37.88,76.58 38.06,76.76 38.17,76.86 38.69,77.38 38.69,78.12 38.61,78.2 38.61,79.58 39.44,80.4 39.44,90.98 37.47,92.94 27.32,92.94 27.09,93.17 27.09,96.99 v1(26.9,97.18)
  L3 w0.508: v1(72.04,140.51) 71.61,140.08 v1(70.67,140.08) 70.67,140.44 70.16,140.95 65.56,140.95 61.94,137.33 61.94,136.12 57.79,131.97 57.79,128.96 57.26,128.43 55.78,128.43 55.42,128.79 54.7,128.79 54.25,128.34 48.39,128.34 44.95,124.89 44.85,124.89 44.84,124.88 43.69,124.88 42.23,123.42 40.44,123.42 39.17,122.15 36.73,122.15 35.49,120.91 34.57,120.91 33.43,122.05 33.43,123.01 32.96,123.48 32.71,123.48 31.46,124.73 31.46,126.34 31.91,126.79 31.91,127.32 31.33,127.89 30.86,127.89 30.48,127.51 30.48,126.95 30.36,126.83 30.36,126.81 29.99,126.44 29.98,126.44 27.49,123.95 27.49,120.45 26.34,119.31 25.07,119.31 24.51,118.75 v1(24.36,118.75) ; v1(163.86,85.95) 164.05,86.15 164.05,88.74 155.56,97.22 155.56,97.6 155.47,97.69 155.47,103.83 156.97,105.33 156.97,105.83 156.97,106.1 158.61,107.74 158.61,108.81 160.04,110.25 160.04,111.21 159.94,111.31 159.78,111.48 159.78,112.26 160.07,112.56 160.07,112.65 160.22,112.8 160.22,112.82 160.23,112.83 160.23,116.25 160.96,116.99 160.96,119.23 160.15,120.04 160.15,130.4 164.54,134.8 164.54,145.57 162.76,147.35 157.93,147.35 157.93,147.35 157.88,147.35 157.51,146.97 v1(157.51,146.71)
  L4 w0.305: v1(157.38,65.81) 157.66,66.08 157.66,67.89 148.7,76.85 148.7,78.77 148.2,79.27 148.2,81.49 145.42,84.26 145.42,85.14 v1(144.64,85.92)
  L4 w0.508: v1(24.36,118.75) 24.36,118.08 24.33,118.04 24.33,117.51 24.91,116.93 24.91,111.74 25.4,111.24 25.4,102.82 26.9,101.32 v1(26.9,97.18)
  L5SGND w0.254: v1(203.11,64.07) 202.17,63.13 201.51,63.13 200.82,63.83 189.64,63.83 187.56,61.75 184.03,61.75 177.37,68.4 175.62,68.4 172.39,71.63 172.39,72.77 163.93,81.23 163.93,85.88 v1(163.86,85.95)
  BOTTOM w0.254: PG4532.2 73.39,135.65 73.7,135.96 73.7,137.69 73.12,138.26 73.12,139.74 72.34,140.51 v1(72.04,140.51)
  BOTTOM w0.305: PWR1.1 211.24,56.62 211.08,56.47 C6401.1 210.67,56.62 210.67,59.06 211.7,60.08 211.7,60.53 v1(211.74,60.58) ; v1(144.64,85.92) 144.73,86.01 144.86,86.01 144.86,86.01 145.22,86.01 R1737.1 ; v1(157.38,65.81) 157.38,65.82 157.51,65.95 157.51,67.4 159.92,69.81 159.92,76.51 160.89,77.48 160.89,78.22 R2505.1
  BOTTOM w0.508: R2505.1 161.49,78 163.55,78 164.2,78.65 164.2,78.79 164.21,78.8 164.21,79.86 165.18,80.83 165.18,85.01 164.24,85.95 v1(163.86,85.95) ; PR4505.1 v1(70.67,140.08)
3D3V_CAMERA: length 12.4
  TOP w0.381: F5504.1 213.84,45.12 214.39,44.57 v2(214.39,43.84) 214.39,43.55 213.84,43 v1(213.62,43)
  TOP w0.508: R5501.2 209.17,39.56 207.9,40.83 v1(207.9,41)
  L3 w0.305: v1(207.9,41) 207.9,41.29 208.5,41.89 210.23,41.89 211.35,43 v1(213.62,43)
3D3V_CAMERA_CT1: length 2.8
  TOP w0.102: v2(213.77,42.44) 213.41,42.44 213.08,42.77 C5539.1 213.08,43.18 213.54,43.64 213.6,43.64 213.61,43.65 v1(213.65,43.65)
  BOTTOM w0.102: U5502.12 213.32,43.99 v1(213.65,43.65)
3D3V_CAMERA_S0: length 8.2
  TOP w0.305: v1(216.9,46.86) 216.3,47.45 C5503.1
  TOP w0.381: C5503.1 216.22,47.31 214.53,47.31 214.42,47.2 214.4,47.2 214.09,46.89 F5504.2
  TOP w0.406: F5504.2 213.01,47.07 213.01,48.1 AFTP5511.1
  BOTTOM w0.305: LCD1.23 218.32,46.05 217.51,46.86 v1(216.9,46.86)
3D3V_EMMC: length 7.9
  TOP w0.305: 155.29,116.25 155.72,116.25 155.83,116.36 155.86,116.36 155.94,116.45 U6301.K9 ; 155.29,116.25 v1(155.29,116.25) ; 155.29,116.25 155.27,116.27 155.27,116.57 155.32,116.61 155.32,116.67 155.42,116.77 155.42,116.86 U6301.J10 ; U6301.E6 153.97,114.95 154.03,115.01 v1(154.06,115.01) 154.06,114.5 U6301.F5
  BOTTOM w0.254: v2(154.84,114.89) 154.75,114.82 154.12,114.92 v1(154.06,115.01)
  BOTTOM w0.508: R6322.1 157.58,120.27 C6322.1 C6324.1 157.58,117.7 157.28,117.4 v1(156.47,117.4)
3D3V_GSEN2: length 8.4
  TOP w0.127: R7006.2 145.99,77.13 145.99,78.53 C7004.1 ; v2(146.88,78.45) 146.88,78.86 R7004.2 145.4,79.28 C7004.1 ; U7001.9 144.09,78.66 C7003.1 ; C7004.1 145.01,78.89 C7003.1 ; C7003.1 144,79.22 U7001.10
3D3V_LAN_CT2: length 2.9
  BOTTOM w0.203: 57.2,127.55 U4001.10
  BOTTOM w0.254: 57.2,127.55 57.17,127.59 56.37,127.59 56.19,127.41 C4017.1 56.19,126.9 v2(55.74,126.46)
3D3V_LAN_S5: length 59.4
  TOP w0.203: U3101.11 v1(45.49,80.57)
  TOP w0.254: v1(8.74,65.94) 9.25,66.45 12.42,66.45 12.75,66.78 13.59,66.78 13.85,66.52 15.21,66.52 v1(15.74,66)
  L2SGND w0.254: v1(42.07,79.99) 42.04,79.96 41.55,79.96 37.99,76.4 35.97,76.4 35.46,76.38 34.97,75.88 31.4,75.88 31.37,75.85 26.24,75.85 25.35,76.73 23.04,76.73 22.61,77.17 21.87,77.17 19.86,75.16 19.86,73.97 20.18,73.65 20.18,72.7 19.52,72.05 19.52,67.81 18.21,66.5 18.21,65.86 17.92,65.56 17.32,65.56 16.39,66.49 16.23,66.49 v1(15.74,66)
  BOTTOM w0.254: v1(44.35,86.13) 44.28,86.06 C3121.1 44.83,85.22 C3110.1 ; v1(49.25,85.06) 49.12,85.06 48.75,84.68 C3117.1 ; LED2.A 9.53,65.15 v1(8.74,65.94) ; C3124.1 47.04,80.82 46.71,80.49 46.71,79.82 C4014.1 46.15,79.59 C3103.1 45.82,80.9 v1(45.49,80.57) 45.41,80.57 45.36,80.53 45.28,80.4 45.12,80.24 42.32,80.24 v1(42.07,79.99)
  vias: v2(42.71,86.58) v2(44.3,92.69) v2(48.82,89.63)
3D3V_LAN_S5_R:
  vias: v1(46.56,91.87) v1(56.87,127.08) v2(45.49,91.24)
3D3V_LCDVDD_R: length 34
  TOP w0.089: R5523.2 219.26,40 219.5,40.24 219.51,40.24 220,40.74 220.45,40.74 220.6,40.59 220.6,40.42 221.16,39.86 R9304.1
  TOP w0.381: R5523.2 219.26,37.85 219.47,37.64 219.47,36.24 219.02,35.79 R5559.2 218.53,35.67 216.59,35.67 215.45,36.82 215.45,38.36 214.12,39.69 211.66,39.69 211.01,40.34 211.01,42.74 211.28,43.01 211.28,49.05 211.01,49.31 211.01,49.44 210.96,49.49 210.96,49.61 210.76,49.82 210.76,51.05 v2(209.59,52.22) 209.59,53.49 v1(209.61,53.51)
  BOTTOM w0.508: U5501.1 209.61,53.13 v1(209.61,53.51)
3D3V_LCDVDD_R_C: length 171.3
  TOP w0.102: v1(224.44,39.45) 224.31,39.57 222.43,39.57 R9304.2 ; R9336.2 161.38,145.28 v2(161.66,145.56) 162.1,145.56 v1(162.28,145.38)
  L3 w0.102: v1(220.14,44.98) 220.35,44.78 220.35,42.62 223.47,39.5 224.39,39.5 v1(224.44,39.45)
  L4 w0.089: v1(220.14,44.98) 219.38,45.75 219.38,47.91 220.9,49.42 220.9,61.37 217.61,64.66 209.76,64.66 209.44,64.99 189.93,64.99 187.34,62.39 184.24,62.39 178.82,67.81 178.66,67.81 176.46,70.01 176.46,70.26 165.51,81.21 165.51,88.53 160.38,93.65 160.23,93.65 159.95,93.65 157.52,96.08 157.52,104.32 164.66,111.47 164.66,118.07 163.83,118.91 163.83,128.01 161.52,130.31 161.52,136.97 160.78,137.71 160.78,141.05 160.99,141.26 160.99,142.36 161.56,142.93 162.61,142.93 162.83,143.15 162.83,144.08 162.28,144.63 v1(162.28,145.38)
  BOTTOM w0.102: PMBD1.6 160.97,145.27 161.2,145.04 162.06,145.04 162.27,145.25 162.27,145.37 v1(162.28,145.38)
3D3V_LCDVDD_S0: length 182.2
  TOP w0.089: C5541.1 220.61,40.96 219.92,40.96 219.42,40.46 219.09,40.46 219.07,40.48
  TOP w0.102: R9305.1 221.19,40.38 C5541.1
  TOP w0.203: v1(163.27,139.4) 161.98,138.11 160.02,138.11 160.02,138.11 153.53,138.11 AFTP5523.1 152.68,136.33 151.69,135.33 151.57,135.33 D5505.A 150.54,134.31 C5530.1 149.95,135.69 149.66,135.98 148.77,135.98 148.47,135.68 148.47,134.82 149,134.3 R5547.2
  L5SGND w0.102: v1(163.27,139.4) 163.71,138.96 163.71,122.14 162.21,120.65 162.21,117.41 159.36,114.56 159.36,111.84 159.72,111.49 159.72,105.26 158.12,103.66 158.12,94.51 162.36,90.27 162.36,88.16 164.29,86.23 164.29,81.43 176.74,68.99 177.22,68.99 184.11,62.09 187.32,62.09 189.36,64.14 201.1,64.14 201.64,63.6 201.99,63.6 202.94,64.54 219.18,64.54 219.97,65.33 221.24,65.33 222.07,64.49 222.07,61.34 220.67,59.93 220.67,49.89 220.99,49.57 220.99,42.16 220,41.17 219.29,41.17 v1(218,39.88)
  vias: v1(218.03,39.24)
3D3V_LCDVDD_S0_C: length 171.2
  TOP w0.102: v1(162.71,144.83) 162.92,144.62 162.92,144.56 162.98,144.49 v2(162.98,144.33) 163.03,144.28 163.03,143.66 R9331.2 ; R9305.2 222.14,40.38 222.71,39.8 224.16,39.8 v1(224.44,40.08)
  L3 w0.102: v1(224.44,40.08) 224.39,40.03 223.47,40.03 220.65,42.85 220.65,45.11 v1(220.14,45.62)
  L4 w0.089: v1(162.71,144.83) 163.04,144.5 163.04,142.99 162.79,142.74 161.67,142.74 161.21,142.28 161.21,141.14 161.02,140.95 161.02,137.78 161.71,137.09 161.71,130.43 164.02,128.12 164.02,118.98 164.86,118.15 164.86,111.34 157.71,104.2 157.71,96.16 160.03,93.84 160.46,93.84 165.7,88.61 165.7,81.29 176.65,70.34 176.65,70.09 178.74,68 178.9,68 184.32,62.58 187.22,62.58 189.82,65.18 209.53,65.18 209.85,64.85 217.69,64.85 221.09,61.45 221.09,49.28 220.14,48.34
  L4 w0.102: 220.14,48.34 219.64,47.83 219.64,45.92 219.94,45.62 v1(220.14,45.62)
  BOTTOM w0.102: v1(162.71,144.83) 162.54,144.83 162.38,144.67 161.15,144.67 160.57,145.25 PMBD1.8
3D3V_MUX: length 39.6
  TOP w0.203: U7101.6 22.6,101.92 v1(22.58,101.91) ; v1(23.88,108.51) 23.88,108.51 23.94,108.45 U7101.20
  TOP w0.254: R7152.1 20.63,99.76 20.24,99.38 v2(19.99,99.38) 19.82,99.55 R7147.1 19.31,100.76 19.31,101.45 19.36,101.5 19.36,101.91 19.74,102.29 19.81,102.29 v1(19.89,102.36) ; v1(20.04,108.77) 20.08,108.73 U7101.28 ; R7101.1 26.39,114.12 25.86,114.12 v1(25.81,114.07)
  L3 w0.254: v1(19.89,102.36) 19.97,102.36 20.02,102.42 22,102.42 22.51,101.91 v1(22.58,101.91)
  BOTTOM w0.254: v1(23.88,108.51) 23.68,108.51 R7174.1 ; R7174.1 22.63,108.72 C7118.2 21.32,108.72 C7119.1 20.46,108.09 C7116.2 20.08,108.11 20.08,108.34 20.04,108.39 v1(20.04,108.77) 20.04,109.27 19.43,109.87 18.21,109.87 L7101.2 17.69,109.35 R7189.1 17.69,107.78 R7190.1 17.26,107.16 17.26,106.54 17.55,106.25 18.42,106.25 R7140.1 18.08,105.58 18.08,105.12 17.58,104.62 R7142.1 17.58,104.27 18.16,103.69 R7175.1 19.63,103.69 19.94,103.37 20.01,103.21 C7115.2 20.16,102.47 20,102.47 v1(19.89,102.36) ; R7174.1 23.19,109.29 23.19,111.02 25.81,113.64 v1(25.81,114.07) ; R7171.1 R7145.1 24.23,102.9 C7117.2 22.81,102.21 22.63,102.03 22.63,101.96 v1(22.58,101.91)
3D3V_MUX2: length 3.6
  TOP w0.203: U7102.13 33.04,120.23 33.6,120.8
  TOP w0.254: 34.55,121.69 34.6,121.64 34.6,120.72 v2(34.54,120.65) 34.35,120.65 33.9,121.11 C7120.1 33.75,120.95 33.6,120.8
3D3V_MUX_VCC: length 3.6
  TOP w0.254: U7101.1 20.26,102.86 20.13,102.98 19.65,102.98 v1(19.26,102.59) 18.8,102.13 C7165.2
  BOTTOM w0.254: R7175.2 19.02,102.83 v1(19.26,102.59) 19.25,102.6 v2(19.48,103.15)
3D3V_RTC: length 233.8
  TOP w0.305: R2708.1 19.87,14.71 v2(18.8,14.71) 18.5,15.01 v1(17.63,15.01)
  L2SGND w0.305: v1(16.59,70.84) 16.13,70.84 15.24,69.95 15.24,69.24 13.54,67.54 13.54,65.28 14.58,64.24 14.58,58.68 14.78,58.48 14.86,58.01 15.63,57.24 16.02,57.24 16.44,56.82 16.44,50.48 16.77,50.15 16.77,50.14 17.03,49.88 17.03,44.92 18.18,43.77 18.18,33.99 18.93,33.23 18.93,31.12 19.69,30.36 19.69,22.96 v1(19.1,22.38)
  L4 w0.305: v1(19.1,22.38) 17.05,20.32 17.05,16.74 17.76,16.03 17.76,15.14 v1(17.63,15.01)
  BOTTOM w0.305: D2501.3 157.5,81.25 Q2507.S 156.58,80.62 156.58,79.46 C2503.1 155.53,78.41 155.53,77.42 158.63,74.32 158.63,70.17 156.99,68.53 155.71,68.53 155.03,67.85 155.03,64.42 153.74,63.13 148.65,63.13 146.1,65.68 144.23,65.68 143.52,64.96 143.08,64.96 142.04,65.99 123.66,65.99 121.76,67.9 78.87,67.9 74.18,63.2 48.47,63.2 44.99,66.68 34.5,66.68 34.14,66.32 33.56,66.32 31.75,68.14 31.48,68.14 31.12,68.14 30.93,68.32 29.32,68.32 29.11,68.54 27.27,68.54 26.59,69.22 25.56,69.22 25.2,69.57 24.3,69.57 24.3,69.57 24.2,69.57 24.02,69.75 23.8,69.75 R2472.2 23.24,69.92 22.28,69.92 22.2,69.99 20.95,69.99 19.61,71.34 18.64,71.34 18.15,70.84 v1(16.59,70.84)
3D3V_RTC_AUX_S5: length 225.4
  TOP w0.305: v1(124.02,81.27) 124.12,81.27 124.54,81.69 124.54,85.03 124.8,85.29 125.65,85.29 127.83,87.47 132.73,87.47 134.49,89.23
  L3 w0.203: v1(124.02,81.27) 124.02,81.27 123.74,81.27 123.53,81.48 121.81,81.48 121.4,81.89 120.21,81.89 119.93,81.61 115.32,81.61 114.51,82.42 v1(111.21,82.42)
  L4 w0.254: v1(143.3,65.5) 139,65.5 129.51,74.99 129.49,74.99 128.87,75.62 128.83,75.62 125.86,78.59 125.86,79.99 124.59,81.27 124.06,81.27 124.06,81.27 v1(124.02,81.27)
  BOTTOM w0.203: R1730.1 114.92,78.81 114.56,79.17 113.76,79.17 111.36,81.57 111.36,82.27 v1(111.21,82.42)
  BOTTOM w0.305: R2506.2 157.51,82.19 157.06,82.19 156.47,82.78 155.69,82.78 Q2507.D 154.94,82.11 154.94,80.98 v2(154.92,80.95) 154.94,80.93 154.94,77.34 158.19,74.09 158.19,70.34 156.81,68.96 155.53,68.96 154.56,67.99 154.56,64.56 153.56,63.56 149.02,63.56 146.23,66.35 144.15,66.35 v1(143.3,65.5) 142.37,66.42 123.84,66.42 121.94,68.33 78.58,68.33 73.89,63.63 48.75,63.63 45.17,67.22 40.35,67.22 39,68.57 31.3,68.57 31.11,68.76 29.5,68.76 29.29,68.97 27.45,68.97 26.77,69.65 25.74,69.65 25.38,70.01 24.38,70.01 24.23,70.16 R2476.2
3D3V_RTC_SYS: length 2
  BOTTOM w0.508: R2517.1 R2505.2 160.12,78.5 D2501.1
3D3V_S0: length 981.2
  TOP w0.203: U5802.51 45.91,119.63 45.74,119.46 C5810.1 45.29,119.52 45.89,120.11 v1(46.18,120.11) ; U5802.57 45.83,117.23 45.52,116.92 45.52,116.56 44.52,115.55 ; R2065.1 135.68,99.41 133.95,101.14 133.17,101.14 v1(132.81,100.78) ; U5802.30 55.04,120.04 55.34,120.34 C5812.1 ; R2430.2 27.63,56.65 27.02,56.03 27.02,55.69 v1(26.57,55.25) ; U5802.21 55.04,115.5 ; v1(47.84,114.34) 47.94,114.34 48.5,114.9 U5802.5 ; RN2601.3 29.68,54.41 29.33,54.06 v1(29.33,53.91) ; R5821.1 44.96,113.26 v1(44.78,113.08)
  TOP w0.254: v1(100.46,30.07) 100.94,30.55 100.94,34.3 101.72,35.08 103.49,35.08 104.78,36.37 104.78,39.61 105.2,40.04 105.27,40.04 105.73,40.5 105.73,40.74 ; v1(82.12,40.89) 82.07,40.84 77.47,40.84 ; R5517.1 133.44,94.51 130.23,97.72 v1(129.9,97.72) ; 77.47,40.84 R1211.2 ; 77.47,40.84 77.47,42.23 78.27,43.03 88.44,43.03 89.12,43.71 95.53,43.71 95.86,44.04 97.23,44.04 97.82,44.63 97.82,45.22 98.22,45.62 R1208.2 98.28,45.75 99.18,46.65 v1(99.18,47.47) ; RN2601.4 29.5,53.74 v1(29.33,53.91)
  TOP w0.305: R2467.2 46.11,67.18 U2402.5 47.42,67.82 C2432.1 47.42,68.75 47.37,68.79 47.37,68.93 v1(47.35,68.94) ; R2489.2 44.26,71.49 44.4,71.35 44.4,70.72 45.05,70.07 45.04,69.85 ; Q5702.5 Q5702.2 21.97,91.24 v1(21.72,91.49) ; R507.1 109.43,39.31 108,40.74 105.73,40.74 105.73,40.75 104.51,41.97 102.82,41.97 v1(101.91,42.88) 101.91,42.85 100.82,41.76 96.75,41.76 96.28,41.29 v1(96.28,41.15) ; v1(55.91,41.58) 55.91,41.68 57.98,43.75 66.87,43.75 70.56,40.06 75.01,40.06 75.75,40.79 R1211.2 ; v1(99.18,47.47) 99.19,47.49 99.19,48.59 98.63,49.15 R1204.2 97.39,49.15 97.16,48.92 R1216.1 C1228.1 ; 39.92,91.09 39.3,91.09 38.11,92.27 36.37,92.27 34.59,94.06 v2(29.7,94.06) 29.06,94.69 v1(29.06,96.52) ; 39.92,91.09 39.91,91.1 Q5801.2 Q5801.5 39.91,94.77 R5834.1 ; 39.92,91.09 R1827.1 ; v1(45.04,69.85) 45.04,69.85 ; 45.04,69.85 45.13,69.94 45.99,69.94 46.87,70.82 Q2414.G 46.19,71.2 v1(46.18,71.2) ; v1(134.29,129.03) 134.29,129.01 134.29,129.01 134.29,128.88 134.42,128.75 134.42,127.89 133.3,126.77 R2604.1 131.37,126.62 130.86,126.11 130.86,124.69 131.46,124.1 U2601.1 132.16,124.03 C2602.1 ; v1(214.47,66.35) 214.47,65.67 213.81,65.01 R9211.2 ; v1(132.81,100.78) 132.41,101.17 132.41,102.49 v1(132.49,102.57) 132.27,102.79 132.27,105.88 132.81,106.42 132.81,111.25 129.64,114.42 129.64,116.77 129.37,117.04 128.52,117.04 ; v1(153.39,135.65) 153.65,135.39 153.65,132.5 152.51,131.36 152.51,130.71 152.79,130.42 152.88,130.42 R5550.2 ; R9301.1 157.99,141.64 156.56,143.07 156.56,143.6 v1(155.65,144.5) 156.45,145.3 158.19,145.3 v1(159.55,146.67) ; C2602.1 131.73,122.68 v1(131.63,122.78) ; C2602.1 132.16,121.79 C2601.1 129.93,121.67 v2(128.52,120.26) Q2601.2 128.52,117.04 ; v1(127.84,93.45) 126.78,92.38 126.78,92.01 126.29,91.53 R2046.1 125.66,91.53 125.18,92 R2064.1 ; C5812.1 56.88,120.34 v1(57.02,120.48) 57.17,120.62 R5822.1 ; v1(48.02,74.74) 48.02,76.55 47,77.57 46.17,77.57 v1(45.5,78.25) ; 146.56,83.62 146.56,82.12 146.33,81.89 146.33,80.63 R7004.1 147.5,79.46 147.5,78.23 147.15,77.89 146.53,77.89 v1(146.46,77.81) 146.46,76.76 146.13,76.43 145.02,76.43 144.51,75.92 132.38,75.92 131.29,77.02 131,77.02 130.05,77.96 130.05,78.21 128.67,79.59 127.97,79.59 127.07,79.71 127.06,79.72 126.96,79.74 126.08,79.74 125.36,79.02 125.36,76.1 125.01,75.74 124.26,75.74 123.75,76.25 R1820.1 123.68,76.23 R2008.1 R1825.1 R1822.1 R1823.1 ; 44.52,115.55 44.52,115.55 C5811.1 44.39,115.38 43.68,114.67 R5815.1 R5817.1 43.84,113.52 v1(44.15,113.21) ; v1(151.69,46.71) 151.82,46.59 151.82,45.47 R1310.2 ; Q2601.5 128.52,117.04 ; v1(100.46,30.07) 100.38,29.99 100.38,29.49 R6502.1
  TOP w0.356: R4048.1 88.57,36.04
  TOP w0.381: R5809.1 R5813.1 43.57,120.74 43.63,120.8 v1(43.63,120.83) ; 175.44,48.4 175.44,47.96 175.43,47.95 175.43,45.94 R1302.2 175.44,45.13 R1306.2 ; 175.44,48.4 175.44,48.84 175.29,48.99 RN1810.2 174.8,49.63 174.63,49.8 174.63,49.94 174.03,50.55 173.19,50.55 172.87,50.23 ; 175.44,48.4 175.36,48.32 RN1810.1 ; v1(207.52,63.63) 207.52,62.85 v2(205.76,61.09) v1(203.52,61.09) 203.52,61.26 202.88,61.9 R2059.1 ; C1328.1 C1329.1 172.25,50.85 172.87,50.23 ; 172.87,50.23 v1(172.87,49.03) ; v1(55.84,116.03) 55.84,115.82 56.44,115.21 C5813.1 55.78,114.75 55.04,115.5 ; v1(88.32,32.16) 88.57,32.41 88.57,36.04
  TOP w0.508: R5561.1 208.62,41.51 v1(208.62,41.01) 208.81,40.83 209.4,40.83 R5501.1 ; R5811.1 R5807.1 v1(42.55,116.99)
  L2SGND w0.203: v1(43.46,28.63) 43.2,28.36 37.83,28.36 37.13,29.06 35.11,29.06 34.42,29.74 32.08,29.74 31.32,30.51 31.12,30.51 29.59,32.04 28.33,32.04 27.28,33.09 27.28,35.49 28.3,36.51 28.3,40.91 v1(26.48,42.73) 24.42,44.78 24.42,45 24.27,45.16 24.27,51.6 26.47,53.8 26.61,54.15 26.96,54.49 26.96,54.86 v1(26.57,55.25)
  L2SGND w2.032: 166.96,124.28 166.96,147.62 163.8,150.78 155.07,150.78 155.04,150.8 129.98,150.8 126.7,147.52 122.71,147.52 119.43,150.8 106.48,150.8 104.23,148.55 100.25,148.55 98.07,150.72 73.79,150.72 56.98,133.91 56.98,132.88
  L3 w0.203: v1(26.48,42.73) 26.32,42.89 26.32,48.71 27.17,49.56 27.17,51.71 29.33,53.86 v1(29.33,53.91)
  L3 w0.254: v1(127.84,93.45) 127.84,93.22 128.57,92.5 135.69,92.5 136.8,91.39 136.8,91.32 v1(136.85,91.27) ; v1(132.81,100.78) 128.95,100.78 128.4,100.23 128.4,99.21 v1(129.9,97.72)
  L3 w0.305: v1(46.18,71.2) 46.15,71.23 46.15,71.98 47.04,72.87 ; v1(48.02,74.74) 47.98,74.74 47.16,73.91 47.16,72.99 47.04,72.87 ; v1(168.03,46.56) 168.03,44.31 167.53,43.8 153.08,43.8 151.87,45.01 151.87,46.54 v1(151.69,46.71) ; v1(29.06,96.52) 29.06,97.33 36.38,104.65 41.79,104.65 46.26,109.12 46.35,109.12 46.74,109.51 46.74,110.51 46.07,111.18 44.76,111.18 44.15,111.79 v1(44.15,113.21) ; 47.04,72.87 47.09,72.87 47.4,72.57 48.23,72.57 50.54,74.88 51.43,74.88 52.02,75.47 52.02,76.14 52.73,76.85 52.83,76.95 54.2,76.95 v1(54.3,76.85) ; v1(129.36,102.73) 129.52,102.57 v1(132.49,102.57)
  L3 w0.406: v1(140.24,106.12) 140.24,107.09 v1(138.38,108.94)
  L3 w0.508: v1(163.23,136.55) 161.98,136.55 158.94,133.51 158.94,120.03 v1(158.75,119.84) ; v1(13.63,103.85) 14.05,103.43 14.05,101.53 16.61,98.97 16.61,92.51 17.62,91.49 v1(21.72,91.49)
  L4 w0.305: v1(153.39,135.65) 152.24,136.81 148.69,136.81 148.47,137.03 ; v1(96.28,41.15) 96.19,41.06 96.19,40.77 95.99,40.57 95.08,40.57 95.02,40.63 90.86,40.63 90.59,40.36 82.65,40.36 v1(82.12,40.89) 81.43,40.2 73.96,40.2 73.95,40.19 72.82,40.19 72.81,40.2 66.89,40.2 66.87,40.21 65.15,40.21 64.87,39.93 56.72,39.93 55.92,39.13 v1(55.92,38.56) ; v1(134.29,129.03) 134.29,129.03 134.39,129.03 134.57,129.21 137.7,129.21 137.75,129.26 137.77,129.26 139.4,130.89 140.29,130.89 146.38,136.98 148.42,136.98 148.47,137.03 ; v1(154.48,138.71) 154.48,138.6 154.33,138.44 154.33,138.4 154.2,138.28 154.2,138.25 153.64,137.69 153.02,137.69 152.41,138.3 150.82,138.3 150.28,138.84 149.45,138.84 149.4,138.79 149.03,138.79 148.47,138.22 148.47,137.03 ; v1(129.9,97.72) 131.93,95.68 132.43,95.68 v1(136.85,91.27) 139.06,89.05 140.26,89.05 142.19,87.12 142.19,85.94 142.66,85.47 142.66,84.62 143.86,83.42 143.86,83.08 144.12,82.82 144.12,82.8 144.12,82.18 144.54,81.76 144.87,81.76 145.78,80.85 145.78,80.41 145.61,80.24 145.61,79.71 146.46,78.86 v1(146.46,77.81) 147,77.27 147,73.72 153.65,67.07 153.65,66.34 154.28,65.71 154.28,63.31 159.15,58.44 159.99,58.44 168.63,49.8 168.63,47 168.19,46.56 v1(168.03,46.56)
  L4 w0.406: v1(100.46,30.07) 100.57,30.07 100.97,30.47 100.97,30.95 100.5,31.42 89.05,31.42 v1(88.32,32.16)
  L4 w0.508: 155.44,148.52 154.95,149.01 139.46,149.01 v1(137.56,147.11) ; 155.44,148.52 155.93,149.01 163.13,149.01 165.69,146.46 165.69,138.58 163.65,136.55 v1(163.23,136.55) ; 155.44,148.52 155.65,148.3 v1(155.65,144.5) ; v1(21.72,91.49) 22.43,92.2 25.01,92.2 27.89,95.09 27.89,95.83 28.58,96.52 v1(29.06,96.52)
  BOTTOM w0.203: R2043.1 145.88,78.39 v1(146.46,77.81) ; Q6504.5 Q6504.2 98.56,31.09 98.68,30.96 99.45,30.96 100.34,30.07 v1(100.46,30.07) ; R2049.1 128.47,100.89 127.65,100.07 R2048.1 ; PMBD1.12 159.77,146.45 v1(159.55,146.67)
  BOTTOM w0.254: v1(46.18,71.2) 46.28,71.3 47.61,71.3 48.66,72.35 55.77,72.35 56.68,73.27 65.59,73.27 66.13,72.73 DBG1.10 ; v1(45.5,78.25) 45.54,78.2 48.63,78.2 48.96,78.54 50.08,78.54 50.58,79.04 50.58,79.73 R1826.1 50.06,80.24 R3109.1
  BOTTOM w0.279: v1(172.87,49.03) 172.38,49.03 172.03,49.39 DM2.255 ; DM1.255 95.83,49.09 96.76,48.15 98.84,48.15 99.18,47.82 v1(99.18,47.47) 99.18,44.49 100.79,42.88 v1(101.91,42.88)
  BOTTOM w0.305: VGABD1.3 203.45,60.22 203.79,60.55 203.79,60.82 v1(203.52,61.09) 203.52,60.97 202.95,60.4 VGABD1.4 ; 129.63,125.91 129.26,125.91 129.09,125.74 RN2602.1 ; 129.63,125.91 131.01,125.91 132.06,124.87 R2603.1 132.06,123.22 v1(131.63,122.78) ; 129.63,125.91 129.76,125.78 RN2602.2 ; v1(45.04,69.85) 45.07,69.85 45.93,68.99 47.11,68.99 47.14,68.96 47.34,68.96 v1(47.35,68.94) ; R402.2 136.45,105.94 R5557.2 136.41,106.5 136.86,106.5 FC8904.1 137.29,106.58 139.78,106.58 v1(140.24,106.12) 140.24,105.59 139.96,105.31 Q1801.5 ; R402.2 136.6,105.31 Q1801.2 ; R402.2 136.29,105.3 R1606.1 136.29,104.39 135.81,103.92 135.81,103.82 R5518.1 135.03,103.75 134.76,104.01 132.85,104.01 132.49,103.66 v1(132.49,102.57) ; v1(163.23,136.55) 163.21,136.57 RN9301.1 160.77,135.98 160.6,135.8 160.31,135.8 160.1,136.01 RN9301.2 159.33,136.57 158,137.9 R2066.1 ; v1(196.8,39.61) IOBD1.14 ; v1(154.48,138.71) 154.48,138.56 153.9,137.98 R9150.1 ; U9103.8 152.86,144.18 C9104.1 153.73,145.04 155.12,145.04 v1(155.65,144.5) ; R2010.1 130.18,98.12 129.9,97.84 v1(129.9,97.72) ; v1(195.79,37.82) 196.07,37.82 196.3,38.06 IOBD1.15 196.3,39.4 v1(196.09,39.61) ; v1(129.36,102.73) 129.04,102.4 129.04,101.35 128.57,100.89 R2049.1
  BOTTOM w0.483: 210.15,42.85 210.14,42.84 209.18,42.84 208.97,42.62 208.97,42.6 208.62,42.25 v1(208.62,41.01) 208.54,40.93 208.54,40.59 206.58,38.63 204.9,38.63 203.58,37.31 v1(203.58,34.72)
  BOTTOM w0.508: v1(203.23,34.14) 203.58,34.49 v1(203.58,34.72) 203.53,34.77 199.7,34.77 196.62,31.7 192.05,31.7 191.54,32.21 v1(191.54,32.46) ; v1(158.75,119.84) R6322.2 161.45,120.58 162.06,121.18 162.85,121.18 163.36,121.69 165.66,121.69 166.68,122.71 v3(166.91,122.71) ; Q5703.C 16.71,105.44 16.5,105.23 16.5,104.28 16,103.78 13.7,103.78 v1(13.63,103.85) ; v1(137.56,147.11) 137.07,146.62 137.07,146.32 R4005.1 137.11,146.2 137.11,145.57 PR4609.1
  vias: v1(44.11,28.62) v1(44.75,28.63) v1(54.61,41.58) v1(55.25,41.58) v2(29.49,23.59) v2(54.99,93.71) v2(55.37,40.2) v2(197.23,38.3) v3(55.55,94.13) v3(55.55,93.17) v3(56.11,130.33) v3(56.14,129.41) v3(56.98,130.33) v3(57,129.41) v3(166.91,121.87) v3(167.39,91.85) v3(178.46,72.19) v3(179.05,71.58)
