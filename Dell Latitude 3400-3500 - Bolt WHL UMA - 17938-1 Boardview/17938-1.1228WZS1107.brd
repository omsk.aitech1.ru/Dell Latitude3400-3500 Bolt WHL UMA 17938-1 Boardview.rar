# Allegro board 17938-1.1228WZS1107.brd (continued)
## Nets (continued)
PWR_VCCSA_FB: PR4632.2 PR4637.1 PR4638.2 PU4601.25
PWR_VCCSA_FB1: PC4621.2 PR4638.1
PWR_VCCSA_FB2: PC4616.2 PC4617.2 PC4620.1 PR4601.1 PR4637.2
PWR_VCCSA_FB_RC: PC4617.1 PR4632.1
PWR_VCCSA_FCCM: PU4601.29 PU5001.7
PWR_VCCSA_IMON: PC4629.2 PR4644.1 PU4601.23
PWR_VCCSA_ISUMN: AFTP4605.1 PC4603.2 PC4605.1 PR4611.1 PR4613.1 PR4615.1 PR4618.2 PR4620.1 PR5004.2
PWR_VCCSA_ISUMN_P_1: PC4608.2 PR4613.2
PWR_VCCSA_ISUMN_P_2: AFTP4606.1 PR4611.2 PR4625.2
PWR_VCCSA_ISUMN_R: PG5001.1 PR5004.1
PWR_VCCSA_ISUMN_RC: PC4611.1 PR4615.2
PWR_VCCSA_ISUMNB: PC4611.2 PR4620.2 PU4601.28
PWR_VCCSA_ISUMP: PC4605.2 PC4608.1 PR4618.1 PR4625.1 PR5003.2 PU4601.27
PWR_VCCSA_ISUMP_R: PG5011.1 PR5003.1
PWR_VCCSA_PWM: PU4601.30 PU5001.3
PWR_VCCSA_RTN: PC4613.1 PC4616.1 PR4602.1 PR4627.2 PU4601.26
PWR_VCCSA_SW: PC5005.2 PG5011.2 PL5001.1 PU5001.8 PU5002.1 PU5002.2 PU5002.3 PU5003.5 PU5003.6 PU5003.7 PU5003.8
PWR_VCORE_BOOT: PR4705.2 PU4701.5
PWR_VCORE_BOOT_RC: PC4707.1 PR4705.1
PWR_VCORE_BOOTR: PC4707.2 PU4701.7
PWR_VCORE_COMP: PC4639.1 PR4656.1 PU4601.16
PWR_VCORE_COMP1: PC4640.1 PR4656.2
PWR_VCORE_FB: PR4657.1 PR4658.1 PR4660.1 PU4601.17
PWR_VCORE_FB1: PC4641.1 PR4657.2
PWR_VCORE_FB2: PC4642.2 PC4643.2 PC4644.1 PR4660.2 PR4663.2 PR4667.2
PWR_VCORE_FB_RC: PC4643.1 PR4658.2
PWR_VCORE_FCCM#: PR4706.2 PU4601.21
PWR_VCORE_FCCM#_R: PR4706.1 PU4701.2
PWR_VCORE_IMON: PC4638.1 PR4661.1 PU4601.14
PWR_VCORE_ISUMN: AFTP4601.1 PC4631.1 PC4634.1 PR4648.2 PR4649.2 PR4650.1 PR4651.2 PR4652.2 PR4701.2
PWR_VCORE_ISUMN_G: PG4708.1 PR4701.1
PWR_VCORE_ISUMN_P_1: PC4635.1 PC4652.1 PR4649.1
PWR_VCORE_ISUMN_P_2: AFTP4602.1 PR4650.2 PR4653.2
PWR_VCORE_ISUMN_RC: PC4632.1 PR4651.1
PWR_VCORE_ISUMNA: PC4632.2 PR4648.1 PU4601.20
PWR_VCORE_ISUMP: PC4634.2 PC4635.2 PC4652.2 PR4652.1 PR4653.1 PR4708.2 PU4601.19
PWR_VCORE_ISUMP_G: PG4707.1 PR4708.1
PWR_VCORE_NTC: PR4662.1 PU4601.15
PWR_VCORE_NTC1: PR4654.1 PR4655.2 PR4662.2
PWR_VCORE_PROG1: PR4629.1 PU4601.32
PWR_VCORE_PROG2: PR4628.1 PU4601.31
PWR_VCORE_PWM: PR4707.2 PU4601.22
PWR_VCORE_PWM_R: PR4707.1 PU4701.1
PWR_VCORE_RTN: PC4637.1 PC4642.1 PR4659.2 PR4668.2 PU4601.18
PWR_VCORE_SNB: PC4706.1 PR4709.2
PWR_VCORE_SW: PG4707.2 PL4701.1 PR4709.1 PU4701.16 PU4701.17 PU4701.18 PU4701.19 PU4701.20 PU4701.21 PU4701.22 PU4701.23 PU4701.24 PU4701.25 PU4701.26
PWR_VCORE_VCC: PC4607.1 PR4610.2 PU4601.34
PWR_VCORE_VCC_R: PC4708.1 PR4704.1 PU4701.3
PWR_VCORE_VIN: PC4606.1 PR4612.2 PU4601.33
PWR_VCORE_VR: PR4614.1 PR4671.1 PU4601.1
PWR_VCORE_VRHOT#: PR4607.2 PU4601.38
PWR_VDDQ: PC5104.1 PC5105.1 PC5106.1 PC5107.1 PG5103.1 PG5105.1 PG5106.1 PG5107.1 PG5108.1 PG5109.1 PG5111.2 PL5101.2
PWR_VDDQ_BOOT: PR5105.1 PU5102.27
PWR_VDDQ_BOOTA: PC5102.2 PR5105.2
PWR_VDDQ_BOOTB: PC5102.1 PU5102.25
PWR_VDDQ_CS: PR5102.2 PU5102.10
PWR_VDDQ_EN: PG5122.2 PR5114.1 PU5102.6
PWR_VDDQ_FB: PR5103.2 PR5104.1 PU5102.3
PWR_VDDQ_PG: PG5114.2 PR5101.2 PU5102.8
PWR_VDDQ_PH: PL5101.1 PR5110.1 PU5102.17 PU5102.18 PU5102.19 PU5102.20 PU5102.35
PWR_VDDQ_SNB: PC5118.1 PR5110.2
PWR_VDDQ_TON: PR5106.2 PU5102.7
PWR_VDDQ_VCC: PC5103.1 PR5102.1 PR5108.2 PU5102.9
PWR_VDDQ_VDDQ: PG5111.1 PR5103.1 PU5102.2
PWR_VDDQ_VLDOIN: PC5114.1 PG5110.2 PG5116.2 PU5102.28
PWR_VDDQ_VTTREF: PC5123.1 PU5102.1
Q501_G: Q501.D Q502.G R506.2
Q2510_G: C2517.1 D2502.A Q2510.G R2567.2
Q5503_B: Q5502.B R5554.2
Q5503_C: Q5502.C R5546.1
Q5503_E: Q5502.E R5551.1
Q5504_B: Q5501.B R5553.2
Q5504_C: Q5501.C R5548.1
Q5505_E: Q5501.E R5550.1
Q6205_Q: Q6503.D R6503.2
Q6407_B: Q6407.1 Q6408.C R6405.1
Q6407_C: Q6407.3 R6413.2
Q9301_G: Q9301.2 Q9301.5 R9301.2
REGOUT: C3118.1 R3101.1 U3101.24
RESET_OUT#: C2614.1 CPU1.BP31 ED1705.2 Q2602.G R2616.2 RN1703.3(B) U2401.73
REXT1: R5804.1 U5802.20
RING2_HPMIC1: ED2911.2 HPMIC1.3 R2906.2
RSET: R3102.1 U3101.31
RSMRST_PWRGD#: D4002.K R4029.2 R4030.2 R4031.2 R4033.2
RTC_3P3_EN_G: Q2510.D R2506.1
RTC_DET#: CPU1.CP22 Q2505.D R1554.2
RTC_RST#: C1806.1 CPU1.BR34 ED1802.2 G1801.2 RN1801.4(B)
RTCRST_ON: D2502.K Q2507.G R2518.1 R2567.1 U2401.31
RUNPWROK: D4002.A D4003.A ED1706.2 R1716.1 R4002.1 R4005.2 R4011.2 U2401.48
SA0_CHA_DIM0: DM1.256 R1204.1 R1205.1
SA0_CHB_DIM0: DM2.256 R1302.1 R1303.1
SA1_CHA_DIM0: DM1.260 R1208.1 R1210.1
SA1_CHB_DIM0: DM2.260 R1306.1 R1307.1
SA2_CHA_DIM0: DM1.166 R1211.1 R1212.1
SA2_CHB_DIM0: DM2.166 R1310.1 R1311.1
SATA1_ODD_PRSNT#: CPU1.CM10 R1617.2 R6004.1
SATA_LED#: CPU1.CN7 D6401.1 R1606.2
SATA_LED#_D: D6401.3 Q6401.S R6415.2
SATA_ODD_DA#_C: ODD1.16 TP6001.1
SATA_ODD_PRSNT#_R: AFTP6005.1 ODD1.7 R6004.2
SD_RCOMP: CPU1.CK33 CPU1.CM34 R1901.1
SD_READ_MODE#: AFTP6610.1 CPU1.CA30 R6601.1
SD_READ_MODE#_R: IOBD1.3 R6601.2
SIO_EXT_SMI#: CPU1.CP7 R402.1
SIO_EXT_WAKE#: CPU1.CN12 R2041.2 U2401.116
SIO_PWRBTN#: CPU1.BU28 TP1706.1 U2401.52
SIO_RCIN#: CPU1.BV29 R1820.2
SIO_SLP_A#: CPU1.BU37 TP1705.1
SIO_SLP_S0#: CPU1.BJ37 R1739.1 R4040.1 R9121.2
SIO_SLP_S3#: C1703.1 CPU1.BU36 D4003.K R4017.1 U4001.3 U4004.3 U4004.5 U4007.1
SIO_SLP_S4#: C1702.1 CPU1.BU27 PR5117.2 Q9202.G R4024.1
SIO_SLP_S5#: CPU1.BT29 TP1702.1
SLEEVE_R: ED2912.1 HPMIC1.4 R2911.2
SM_DRAMRST#_CPU: CPU1.BU31 R504.1 R505.2
SM_INTRUDER#: CPU1.BR35 R1730.2
SM_PGCNTL: CPU1.C35 Q501.G
SM_PGCNTL_Q: PU5102.5 Q502.D R507.2
SM_RCOMP_0: CPU1.BN28 R501.1
SM_RCOMP_1: CPU1.BN27 R502.1
SM_RCOMP_2: CPU1.BN29 R503.1
SMB_ALERT#: CPU1.CJ15 R1551.2
SML0_ALERT#: CPU1.CG15 R1504.2 R1806.1
SML0_SMBCLK: CPU1.CH14 RN1807.5(B)
SML0_SMBDATA: CPU1.CF15 RN1807.6(B)
SML1_SMBCLK: CPU1.CN15 Q2601.3 R2459.1 RN1811.3(B)
SML1_SMBDATA: CPU1.CM15 Q2601.6 R2447.1 RN1811.4(B)
SML1ALERT#: CPU1.CC34 R1837.2
SPI_CLK_CPU: R1842.1 R2508.2 R2513.2 R9138.1
SPI_CLK_CPU_R: CPU1.CH37 R1842.2
SPI_CLK_ROM: BIOS1.6 EC2503.1 R2508.1
SPI_CLK_ROM2: BIOS2.6 EC2504.1 R2513.1
SPI_CLK_ROM_TPM: R9138.2 U9103.19
SPI_CS2#_IC: R9130.2 R9148.2 U9103.20
SPI_CS_CPU_N0: BIOS1.1 CPU1.CG36 R2519.2
SPI_CS_CPU_N1: BIOS2.1 CPU1.CG35 R2521.2
SPI_CS_CPU_N2: CPU1.CH34 R9118.2 R9130.1
SPI_HOLD_CPU: R1510.2 R1846.1 R2503.2 R2511.2
SPI_HOLD_CPU_R: CPU1.CG34 R1846.2
SPI_HOLD_ROM: BIOS1.7 R2503.1
SPI_HOLD_ROM2: BIOS2.7 R2511.1
SPI_IRQ#_TPM2: R9119.1 R9151.1 R9152.1 U9103.18
SPI_SI_CPU: R1506.2 R1844.1 R2509.2 R2512.2 R9133.1
SPI_SI_CPU_R: CPU1.CF36 R1844.2
SPI_SI_ROM: BIOS1.5 EC2501.1 R2509.1
SPI_SI_ROM2: BIOS2.5 EC2505.1 R2512.1
SPI_SI_ROM_TPM: R9133.2 U9103.21
SPI_SO_CPU: R1843.1 R2501.1 R2502.1 R9132.1
SPI_SO_CPU_R: CPU1.CF37 R1843.2
SPI_SO_ROM: BIOS1.2 EC2502.1 R2502.2
SPI_SO_ROM2: BIOS2.2 EC2506.1 R2501.2
SPI_SO_ROM_TPM: R9132.2 U9103.24
SPI_WP_CPU: R1508.2 R1845.1 R2507.1 R2510.1
SPI_WP_CPU_R: CPU1.CF34 R1845.2
SPI_WP_ROM: BIOS1.3 R2507.2
SPI_WP_ROM2: BIOS2.3 R2510.2
SPKR: CPU1.CF35 R2740.1
SRTC_RST#: C1805.1 CPU1.BR37 ED1801.2 RN1801.3(B)
SSD2_DEVSLP: CPU1.CR8 R1619.1
SSD_CLK_CPU_N_4: CPU1.BA1 SSD1.53
SSD_CLK_CPU_P_4: CPU1.BA2 SSD1.55
SSD_DEVSLP: CPU1.CM8 R1618.1
SSD_DEVSLP_R: R1618.2 R1619.2 R6301.1
SSD_ODD_SATA_RX_N12: CPU1.BL6 R1616.2
SSD_ODD_SATA_RX_P12: CPU1.BL5 R1609.2
SSD_ODD_SATA_TX_N12: CPU1.BN2 R1610.2
SSD_ODD_SATA_TX_P12: CPU1.BN1 R1611.2
SSD_PCIE_RX_N13: CPU1.BK6 SSD1.5
SSD_PCIE_RX_N14: CPU1.BJ6 SSD1.17
SSD_PCIE_RX_N15: CPU1.BG5 SSD1.29
SSD_PCIE_RX_N16: CPU1.BE5 SSD1.43
SSD_PCIE_RX_P13: CPU1.BK5 SSD1.7
SSD_PCIE_RX_P14: CPU1.BJ5 SSD1.19
SSD_PCIE_RX_P15: CPU1.BG6 SSD1.31
SSD_PCIE_RX_P16: CPU1.BE6 SSD1.41
SSD_PCIE_TX_CON_N13: C6316.1 SSD1.11
SSD_PCIE_TX_CON_N14: C6314.1 SSD1.23
SSD_PCIE_TX_CON_N15: C6312.1 SSD1.35
SSD_PCIE_TX_CON_P13: C6315.1 SSD1.13
SSD_PCIE_TX_CON_P14: C6313.1 SSD1.25
SSD_PCIE_TX_CON_P15: C6311.1 SSD1.37
SSD_PCIE_TX_N13: C6316.2 CPU1.BM4
SSD_PCIE_TX_N14: C6314.2 CPU1.BL2
SSD_PCIE_TX_N15: C6312.2 CPU1.BL4
SSD_PCIE_TX_N16: C6303.2 CPU1.BJ4
SSD_PCIE_TX_P13: C6315.2 CPU1.BM3
SSD_PCIE_TX_P14: C6313.2 CPU1.BL1
SSD_PCIE_TX_P15: C6311.2 CPU1.BL3
SSD_PCIE_TX_P16: C6302.2 CPU1.BJ3
SSD_SATA_TX_CON_N16: C6303.1 SSD1.47
SSD_SATA_TX_CON_P16: C6302.1 SSD1.49
SSD_SCP#: SSD1.8 U2401.21
SSEQ0_A0: R7145.2 R7146.1 U7101.11
SSEQ1: R7144.1 R7152.2 U7101.3
ST_GPIO: TP9103.1 U9103.6
ST_PP: TP9101.1 U9103.7
SUS_CLK: CPU1.BT32 EC1803.2 R2461.1 R6117.1
SUSACK#_R: CPU1.BY32 R1708.2
SUSCLK_WLAN: R6117.2 WLAN1.50
SVID_ALERT#_CPU: PR4605.2 PR4623.1 R703.1 R704.2
SVID_ALERT#_CPU_R: CPU1.AA3 R703.2
SVID_ALERT#_VR: PR4623.2 PU4601.36
SVID_CLK_CPU: PR4606.2 PR4624.1 R702.2 R705.2
SVID_CLK_CPU_R: CPU1.AA1 R702.1
SVID_CLK_VR: PR4624.2 PU4601.37
SVID_DATA_CPU: PR4604.2 PR4622.1 R701.2 R706.2
SVID_DATA_CPU_R: CPU1.AA2 R701.1
SVID_DATA_VR: PR4622.2 PU4601.35
SW_PIN: R5820.2 U5802.18
SYS_LED_MASK#: Q3201.G Q6402.G Q6406.2 Q6406.5 R2465.1 R2497.1 U2401.55
SYS_PRES1#: AFTP4315.1 BATT1.7 R4301.2
SYS_PWROK: CPU1.CR10 ED1702.2 R1717.1 U2401.28
SYSPWR_PRES: R2454.1 U2401.120
T_CRIT#: R2601.1 R2604.2 U2601.4
THERM_SYS_SHDN#: Q2602.S R2601.2 R2602.1
THERMTRIP#_CPU: CPU1.BJ1 ED301.1 R308.2
TOP_MUX_N: ED7311.2 EL7105.3 JUSB1.A7 R7333.2
TOP_MUX_N_L: EL7105.4 R7131.2 U7102.17
TOP_MUX_P: ED7312.2 EL7105.2 JUSB1.A6 R7332.2
TOP_MUX_P_L: EL7105.1 R7132.2 U7102.18
TOUCH_I2C_DET#: CPU1.CC29 LCD1.12 R2062.2
TOUCH_PAD_INTR#: CPU1.CB34 R319.2
TOUCH_PANEL_INTR#: CPU1.CN3 R5533.1 R5544.2
TOUCH_PANEL_PD#: AFTP5503.1 CPU1.CC35 LCD1.14
TOUCH_REPORT_SW: AFTP5514.1 D2402.A LCD1.26
TOUCH_USB20_N: CPU1.CH5 R5512.1
TOUCH_USB20_N_R: ED5502.3 LCD1.28 R5512.2
TOUCH_USB20_P: CPU1.CH6 R5511.1
TOUCH_USB20_P_R: ED5502.4 LCD1.27 R5511.2
TP_EN#: R6504.1 RN2406.1(A) U2401.49
TP_ON#_GATE: C6503.2 Q6502.G Q6503.G R6504.2
TP_VDD: AFTP6529.1 C6505.1 Q6502.D R6502.2 R6503.1 R6511.2 RN6501.1(A) RN6501.2(A) RN6503.1(A) RN6503.2(A) TP1.8
TP_WAKE_KBC#: AFTP6525.1 R319.1 R6511.1 TP1.4 U2401.33
TPAN_VDD_EN_R: R5562.2 R5563.2 R5564.1 U5502.5
TPCLK_C: AFTP6530.1 RN6502.4(B) TP1.1
TPDATA_C: AFTP6524.1 RN6502.3(B) TP1.2
TPM_GPIO0: R9121.1 U9103.29
TPM_GPIO1: TP9102.1 U9103.30
TPM_GPIO4: R9118.1 U9103.13
TPM_ID: CPU1.CK25 R1910.2 R1911.1
TPM_SPI_IRQ#: CPU1.CF20 R9151.2
TPS2544_FAULT#: R3607.1 U3601.13
TPS70933_EN: Q7201.D R7217.2 R7218.1 U7203.4
TPS70933_EN_G: C7215.2 Q7201.G R7216.2
TS#_DIMM0_1: DM1.134 R1215.2
TS#_DIMM1_1: DM2.134 R1312.2
TS_INT#: LCD1.13 R5533.2
TYPEC_DCIN1_EN#: Q7406.2 Q7407.2 R7428.1 R7431.1 U2401.63
TYPEC_DP_AUXN: R7104.1 U5802.27
TYPEC_DP_AUXP: R7103.1 U5802.26
TYPEC_DP_N0: C7113.1 U5802.49
TYPEC_DP_N0_C: C7113.2 R7178.1
TYPEC_DP_N1: C7107.1 U5802.46
TYPEC_DP_N1_C: C7107.2 R7180.1
TYPEC_DP_N2: C7108.1 U5802.44
TYPEC_DP_N2_C: C7108.2 R7182.1
TYPEC_DP_N3: C7110.1 U5802.41
TYPEC_DP_N3_C: C7110.2 R7184.1
TYPEC_DP_P0: C7112.1 U5802.50
TYPEC_DP_P0_C: C7112.2 R7177.1
TYPEC_DP_P1: C7114.1 U5802.47
TYPEC_DP_P1_C: C7114.2 R7179.1
TYPEC_DP_P2: C7109.1 U5802.45
TYPEC_DP_P2_C: C7109.2 R7181.1
TYPEC_DP_P3: C7111.1 U5802.42
TYPEC_DP_P3_C: C7111.2 R7183.1
TYPEC_SMBCLK: Q2417.1 RN2413.4(B) U2401.91 U7102.3
TYPEC_SMBDA: Q2417.4 RN2413.3(B) U2401.89 U7102.4
U9101_2_GND: R9101.2 U9103.2
UART_2_CRXD_DTXD: CPU1.CR12 R2048.2 R6803.1
UART_2_CRXD_DTXD_CON: DBG1.14 R6803.2
UART_2_CTXD_DRXD: CPU1.CP12 R2049.2 R6802.1
UART_2_CTXD_DRXD_CON: DBG1.13 R6802.2
USB1_SBU1: AFTP7101.1 ED7307.2 JUSB1.A8 R7331.2 U7101.27
USB1_SBU2: AFTP7102.1 ED7307.1 JUSB1.B8 R7330.2 U7101.26
USB1_SSRX_C_N1: C7169.1 U7101.31
USB1_SSRX_C_N2: C7167.1 U7101.39
USB1_SSRX_C_P1: C7168.1 U7101.30
USB1_SSRX_C_P2: C7170.1 U7101.40
USB1_SSRX_CMC_N1: C7169.2 R7120.1 R7187.1
USB1_SSRX_CMC_N2: C7167.2 R7123.1 R7185.1
USB1_SSRX_CMC_P1: C7168.2 R7119.1 R7186.1
USB1_SSRX_CMC_P2: C7170.2 R7122.1 R7188.1
USB1_SSRX_CON_N1: ED7301.4 ED7301.7 JUSB1.B10 R7120.2
USB1_SSRX_CON_N2: ED7302.2 ED7302.9 JUSB1.A10 R7123.2
USB1_SSRX_CON_P1: ED7301.5 ED7301.6 JUSB1.B11 R7119.2
USB1_SSRX_CON_P2: ED7302.1 ED7302.10 JUSB1.A11 R7122.2
USB1_SSTX_C_N1: C7163.2 U7101.34
USB1_SSTX_C_N2: C7162.2 U7101.36
USB1_SSTX_C_P1: C7164.2 U7101.33
USB1_SSTX_C_P2: C7161.2 U7101.37
USB1_SSTX_CMC_N1: C7163.1 R7117.1
USB1_SSTX_CMC_N2: C7162.1 R7125.1
USB1_SSTX_CMC_P1: C7164.1 R7115.1
USB1_SSTX_CMC_P2: C7161.1 R7124.1
USB1_SSTX_CON_N1: ED7301.1 ED7301.10 JUSB1.A3 R7117.2
USB1_SSTX_CON_N2: ED7302.5 ED7302.6 JUSB1.B3 R7125.2
USB1_SSTX_CON_P1: ED7301.2 ED7301.9 JUSB1.A2 R7115.2
USB1_SSTX_CON_P2: ED7302.4 ED7302.7 JUSB1.B2 R7124.2
USB1_USB20_N: CPU1.CD3 R7134.1 U7102.2
USB1_USB20_N_R: R7131.1 R7134.2
USB1_USB20_P: CPU1.CD4 R7133.1 U7102.1
USB1_USB20_P_R: R7132.1 R7133.2
USB2_ID: CPU1.CE8 RN1602.2(A)
USB2_USB20_N: AFTP6607.1 CPU1.CE1 EL6602.4 R6606.1
USB2_USB20_N_CMC: ED6601.3 EL6602.3 IOBD1.8 R6606.2
USB2_USB20_P: AFTP6608.1 CPU1.CE2 EL6602.1 R6607.1
USB2_USB20_P_CMC: ED6601.4 EL6602.2 IOBD1.9 R6607.2
USB2_VBUSSENSE: CPU1.CC6 RN1602.1(A)
USB3_CHAR_2544_N: R3615.1 U3601.11
USB3_CHAR_2544_P: R3614.1 U3601.10
USB3_CHAR_N: EL3501.4 R3615.2 R3617.2
USB3_CHAR_P: EL3501.1 R3614.2 R3616.2
USB3_NONPS_N: R3611.2 R3617.1
USB3_NONPS_P: R3610.2 R3616.1
USB3_USB20_2544_N: R3613.1 U3601.2
USB3_USB20_2544_P: R3612.1 U3601.3
USB3_USB20_CON_N: AFTP3502.1 ED3502.1 EL3501.3 USB1.2
USB3_USB20_CON_P: AFTP3503.1 ED3502.6 EL3501.2 USB1.3
USB3_USB20_N: CPU1.CE3 R3611.1 R3613.2
USB3_USB20_P: CPU1.CE4 R3610.1 R3612.2
USB3_USB30_RX_CON_N: ED3501.1 ED3501.10 EL3503.3 R3508.1 USB1.5
USB3_USB30_RX_CON_P: ED3501.2 ED3501.9 EL3503.4 R3502.1 USB1.6
USB3_USB30_TX_CMC_N: C3521.2 EL3502.1 R3507.2
USB3_USB30_TX_CMC_P: C3520.2 EL3502.2 R3501.2
USB3_USB30_TX_CON_N: ED3501.4 ED3501.7 EL3502.3 R3507.1 USB1.8
USB3_USB30_TX_CON_P: ED3501.5 ED3501.6 EL3502.4 R3501.1 USB1.9
USB3_USB31_RX_N: CPU1.CB5 EL3503.1 R3508.2
USB3_USB31_RX_P: CPU1.CB6 EL3503.2 R3502.2
USB3_USB31_TX_N: C3521.1 CPU1.CA4
USB3_USB31_TX_P: C3520.1 CPU1.CA3
USB4_USB20_CON_N: AFTP3505.1 ED3502.3 EL3506.2 USB2.2
USB4_USB20_CON_P: AFTP3506.1 ED3502.4 EL3506.3 USB2.3
USB4_USB20_N: CPU1.CG3 EL3506.1
USB4_USB20_P: CPU1.CG4 EL3506.4
USB4_USB30_RX_C_N: C7106.2 R7155.1
USB4_USB30_RX_C_P: C7105.2 R7156.1
USB4_USB30_RX_C_R_N: R7155.2 U7101.4
USB4_USB30_RX_C_R_P: R7156.2 U7101.5
USB4_USB30_RX_CON_N: ED3503.1 ED3503.10 EL3505.3 R3504.1 USB2.5
USB4_USB30_RX_CON_P: ED3503.2 ED3503.9 EL3505.4 R3505.1 USB2.6
USB4_USB30_RX_N: C7106.1 CPU1.BW6
USB4_USB30_RX_P: C7105.1 CPU1.BW5
USB4_USB30_TX_C_N: C7104.2 R7153.1
USB4_USB30_TX_C_P: C7103.2 R7154.1
USB4_USB30_TX_C_R_N: R7153.2 U7101.7
USB4_USB30_TX_C_R_P: R7154.2 U7101.8
USB4_USB30_TX_CMC_N: C3523.2 EL3504.1 R3506.2
USB4_USB30_TX_CMC_P: C3522.2 EL3504.2 R3503.2
USB4_USB30_TX_CON_N: ED3503.4 ED3503.7 EL3504.3 R3506.1 USB2.8
USB4_USB30_TX_CON_P: ED3503.5 ED3503.6 EL3504.4 R3503.1 USB2.9
USB4_USB30_TX_N: C7104.1 CPU1.BW2
USB4_USB30_TX_P: C7103.1 CPU1.BW1
USB4_USB31_RX_N: CPU1.BY7 EL3505.1 R3504.2
USB4_USB31_RX_P: CPU1.BY6 EL3505.2 R3505.2
USB4_USB31_TX_N: C3523.1 CPU1.BY4
USB4_USB31_TX_P: C3522.1 CPU1.BY3
USB30_PS_VCC: AFTP3507.1 C3524.1 C3525.1 C3526.1 C3527.1 EC3513.1 ED3502.5 R3513.2 U3601.12 USB1.1
USB_ADT: PD4407.A PD4408.2 PD4409.A R7404.1 U7418.5 U7418.6 U7418.7 U7418.8 U7419.A1 U7419.B1 U7419.C1 U7419.D1
USB_EN#: AFTP6614.1 IOBD1.12 R2434.2 U2401.13 U3502.4
USB_OC0#: CPU1.CK6 R3512.1 R3607.2 RN1601.5(B)
USB_OC1#: CPU1.CK5 IOBD1.11 RN1601.6(B)
USB_OC1#_R: R3512.2 U3502.3
USB_OC2#: CPU1.CK8 RN1601.7(B)
USB_OC3#: CPU1.CK9 RN1601.8(B)
USB_POWERSHARE_VBUS_EN: U2401.71 U3601.5
USB_PWR_SHR_EN_L#: R3601.1 R3618.1 U2401.118
USBC1_CC1_CONN: AFTP7303.1 C7208.1 ED7315.2 JUSB1.A5 U7201.6
USBC1_CC2_CONN: AFTP7304.1 C7209.1 ED7315.1 JUSB1.B5 U7201.4
USBCOMP: CPU1.CC5 R1603.1
V_SM_VREF_CNTA: C1222.1 CPU1.F36 R1206.2
V_SM_VREF_CNTB: C1323.1 CPU1.E36 R1305.2
VCI_IN1#: R2496.1 U2401.126
VCP_VBUS: D7401.A U7403.B1 U7403.B2 U7403.C1
VCREF0: C2409.1 R2424.1 R2448.1 U2401.25
VGA_DB_DET#: AFTP5601.1 CPU1.CR24 R2059.2 VGABD1.19
VR_CAP: C2418.1 U2401.18
VR_EN: PU4601.40 R4002.2
VR_RDY: PR4609.2 PU4601.39 TP4601.1
VRALERT#: CPU1.CC36 TP1708.1
VRAM_ID1: CPU1.CE27 R2007.1 R2008.2
VRAM_ID2: CPU1.CN23 R2063.1 R2064.2
VREF_CPU: C2406.1 R2402.2 U2401.95
VREG3PD: C7216.1 C7217.1 D7201.A U7203.1
WHITE_LED_BAT: EC6404.1 Q6404.C R6406.1
WIFI_RF_EN: AFTP6110.1 CPU1.CG25 R6109.2
WIFI_RF_EN_R: R6109.1 R6114.2 WLAN1.56
WLAN_CLK_CPU_N: CPU1.BC1 WLAN1.49
WLAN_CLK_CPU_P: CPU1.BC2 WLAN1.47
WLAN_EN#: Q6102.D R6102.2 U6101.4
WLAN_PCIE_RX_N10: CPU1.BN6 WLAN1.43
WLAN_PCIE_RX_P10: CPU1.BN5 WLAN1.41
WLAN_PCIE_TX_CON_N: C6107.1 WLAN1.37
WLAN_PCIE_TX_CON_P: C6108.1 WLAN1.35
WLAN_PCIE_TX_N10: C6107.2 CPU1.BR4
WLAN_PCIE_TX_P10: C6108.2 CPU1.BR3
WWAN_BB_RST#: CPU1.CF17 WWAN1.16
WWAN_CLKREQ_CPU_N: CPU1.CF31 R1825.2 WWAN1.20
WWAN_DB_DET#: CPU1.CH36 R1922.2 R2403.2 R6201.1
WWAN_DB_DET#_R: R6201.2 WWAN1.17
WWAN_FULL_PWR_EN: CPU1.CM23 R2051.1
WWAN_FULL_PWR_EN_D8: CPU1.CJ22 R2067.1
WWAN_FULL_PWR_EN_R: R2051.2 R2067.2 WWAN1.8
WWAN_GPIO_PERST#: CPU1.CH22 WWAN1.15
WWAN_PCIE_CLK_N: CPU1.BE1 WWAN1.26
WWAN_PCIE_CLK_P: CPU1.BE2 WWAN1.27
WWAN_PCIE_RX_N: CPU1.BY8 WWAN1.29
WWAN_PCIE_RX_P: CPU1.BY9 WWAN1.30
WWAN_PCIE_TX_N: C6201.1 CPU1.CA2
WWAN_PCIE_TX_N_C: C6201.2 WWAN1.32
WWAN_PCIE_TX_P: C6202.1 CPU1.CA1
WWAN_PCIE_TX_P_C: C6202.2 WWAN1.33
WWAN_PCIE_WAKE_N: TP6201.1 WWAN1.21
WWAN_USB20_N: CPU1.CB8 R6203.1
WWAN_USB20_N_R: R6203.2 WWAN1.23
WWAN_USB20_P: CPU1.CB9 R6202.1
WWAN_USB20_P_R: R6202.2 WWAN1.24
XCLK_BIASREF: CPU1.CJ1 R1803.1
XDP_CLK_CPU_N: CPU1.AU1 TP1808.1
XDP_CLK_CPU_P: CPU1.AU2 TP1807.1
XDP_DBRESET#: CPU1.CN10 R1701.2
XDP_TCK_JTAGX: CPU1.P6 R315.1
XDP_TCLK: CPU1.T6 R317.1
XDP_TDI: CPU1.U6 R311.1
XDP_TDO_CPU: CPU1.Y5 R310.1
XDP_TMS: CPU1.T5 R309.1
XDP_TRST#: CPU1.AB6 CPU1.Y6 R316.1
XTL_24M_X1_CPU: CPU1.CK3 R1839.1
XTL_24M_X1_R: C1807.2 R1839.2 R1841.1 X1801.1
XTL_24M_X2_CPU: CPU1.CK2 R1840.1
XTL_24M_X2_R: C1808.2 R1840.2 R1841.2 X1801.3
XTL_32K_X1_CPU: C1804.1 CPU1.BN31 R1815.1 X1802.1
XTL_32K_X2_CPU: C1803.1 CPU1.BN32 R1815.2 X1802.2

Pads without a net: CPU1 A34 A35 AA4 AA24 AA26 AB25 AC6 AC7 AC24 AC25 AC26 AD24 AD26 AG6 AG7 AH26 AJ1 AJ2 AJ3 AJ4 AJ27 AL1 AL2 AL3 AL4 AM3 AM4 AN1 AN2 AN3 AN4 AR3 AT3 AU3 AW2 AY3 AY9 B35 BB9 BB24 BC24 BC28 BH3 BH4 BJ34 BJ36 BK34 BK35 BK36 BL34 BL36 BL37 BP8 BP9 BP28 BP29 BP34 BP35 BR18 BT3 BT4 BT6 BT7 BT8 BT9 BT31 BU1 BU2 BU3 BU4 BU5 BU6 BU8 BU9 BU29 BV24 BV25 BV30 BW3 BW4 BW8 BW9 BW34 BW35 BW36 BW37 BY30 BY31 C34 CA32 CA34 CA35 CA36 CA37 CC27 CE28 CF12 CF22 CF27 CF29 CF32 CG1 CG2 CG14 CG23 CH7 CH8 CH9 CH17 CH20 CH25 CH27 CH28 CH30 CH32 CJ17 CJ25 CJ27 CJ29 CJ30 CJ31 CK17 CK22 CK23 CL35 CM24 CM27 CM28 CM35 CN8 CN22 CN26 CN28 CN35 CN36 CP3 CP4 CP6 CP20 CP26 CP28 CR3 CR4 CR22 CR28 CR35 D34 D35 D37 E1 F34 F37 G1 G2 G3 G4 H3 H4 J1 J2 J3 K12 K14 K15 K17 K18 K20 L1 L2 L3 L4 L5 L25 M3 M4 M24 M26 N1 N2 N3 N5 P24 P26 R1 R2 R24 R25 R26 T3 T25 U1 U2 U3 U4 U34 U35 V24 V25 V28 V29 W1 W2 W3 W25 Y3 Y24 Y25; DBG1 1 12; DCIN1 5; DM1 87 88 91 92 95 97 100 101 104 105 162 165; DM2 87 88 91 92 95 97 100 101 104 105 162 165; ED2403 1; ED5703 4 7; ED9202 3 4; HDA27 10; HDD1 5 7; HDMI1 13 14; IOBD1 16; KB1 2 3; KBBL1 3; LCD1 38; ODD1 8 11; PU4501 15; PU4701 4 6 27 30 31 35; PU4801 4 6 27 30 31 35; PU4802 4 6 27 30 31 35; PU5102 26; RN1704 5; RN4302 1 8; SSD1 6 20 22 24 26 28 30 32 34 36 40 42 44 46 48 54 56 58 67 68; U2401 10 23; U2502 3; U3101 25; U3601 9; U5501 3; U5802 4 14 22 23 31 32 34 35 58; U6101 3; U6301 A1 A2 A7 A8 A9 A10 A11 A12 A13 A14 B1 B7 B8 B9 B10 B11 B12 B13 B14 C1 C3 C5 C7 C8 C9 C10 C11 C12 C13 C14 D1 D2 D3 D4 D12 D13 D14 E1 E2 E3 E5 E8 E9 E10 E12 E13 E14 F1 F2 F3 F10 F12 F13 F14 G1 G2 G3 G10 G12 G13 G14 H1 H2 H3 H12 H13 H14 J1 J2 J3 J12 J13 J14 K1 K2 K3 K6 K7 K10 K12 K13 K14 L1 L2 L3 L12 L13 L14 M1 M2 M3 M7 M8 M9 M10 M11 M12 M13 M14 N1 N3 N6 N7 N8 N9 N10 N11 N12 N13 N14 P1 P2 P7 P8 P9 P10 P11 P12 P13 P14; U7102 6 7 19 20; U7202 4; U7203 2 5; U9103 3 5 9 10 11 12 14 15 25 26 27 28 31 32; VGABD1 2 5; WLAN1 6 8 12 16 20 38 40 42 44 46 48 58 60 62 66 68 70; WWAN1 6 9 10 11; X1801 2

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 4088 vias
v2: diameter 0.356, hole 0.178, TOP to BOTTOM, 1018 vias
v3: diameter 0.711, hole 0.406, TOP to BOTTOM, 523 vias
v4: diameter 0.559, hole 0.305, TOP to BOTTOM, 26 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1V_CPU_CORE: length 74.7
  TOP w0.406: v3(99.34,130.17) 99.34,132.33 103.11,136.1 103.11,138.67 107.19,142.75 107.19,144.2 108.99,146 115.52,146 116.9,144.62 118.45,144.62 118.57,144.5 118.82,144.25 129.01,144.25 129.27,144.5 129.29,144.53 129.31,144.53 130.14,145.35 131.04,145.35 131.7,146.01 v1(131.7,146.23)
  L4 w0.508: v1(131.7,146.23) 131.7,145.64 132.67,144.67 139.98,144.67 141.69,146.38 142.77,146.38 143.5,145.65 143.5,143.5 143.82,143.18 v1(144.55,143.18)
  BOTTOM w0.254: CPU1.AV2 v1(100.25,106.85) ; CPU1.BF2 105.06,106.37 105.06,107.08 v1(104.94,107.2) ; v1(98.87,103.49) 98.44,103.92 CPU1.AR5 ; CPU1.BB2 v1(102.69,106.82) ; CPU1.AP2 v1(97.81,106.88)
  BOTTOM w0.305: CPU1.AU6 v1(99.79,103.49) ; CPU1.AU5 v1(99.79,104.14) ; CPU1.BC6 v1(103.49,103.5) ; CPU1.AR6 v1(98.87,103.49) ; CPU1.BA7 v1(102.56,102.85) ; CPU1.AU8 v1(99.79,102.2) ; CPU1.AU7 v1(99.79,102.85) ; CPU1.BC7 v1(103.49,102.85) ; CPU1.AW7 v1(101.64,102.85) ; PR4631.2 v1(144.55,143.18) ; CPU1.AV7 v1(100.71,102.85) ; CPU1.AR7 v1(98.87,102.85) ; CPU1.AV5 v1(100.71,104.14) ; CPU1.AW8 v1(101.64,102.2) ; CPU1.BA8 v1(102.56,102.2) ; CPU1.AR8 v1(98.87,102.2)
  BOTTOM w0.406: v3(96.55,107.8) 97.18,108.43 R707.1
  vias: v1(95.58,100.33) v1(96.1,102.22) v1(97.01,100.79) v1(97.06,92.34) v1(97.94,100.78) v1(97.97,92.34) v1(98.4,100.33) v1(98.43,91.89) v1(98.87,100.78) v1(98.89,92.34) v1(98.89,89.99) v1(99.34,91.89) v1(99.79,100.78) v1(99.8,92.34) v1(99.8,89.99) v1(100.25,100.33) v1(100.72,100.78) v1(100.71,92.34) v1(100.71,89.99) v1(101.17,100.33) v1(101.16,91.89) v1(101.62,104.17) v1(101.64,100.78) v1(101.62,92.34) v1(101.63,89.99) v1(101.65,103.52) v1(102.09,91.87) v1(102.53,92.34) v1(102.54,89.99) v1(102.56,100.78) v1(103.02,100.33) v1(103.44,92.34) v1(103.51,100.79) v1(103.9,91.89) v1(104.07,100.36) v1(104.35,92.34) v1(104.81,91.89) v1(105.33,100.78) v2(89.07,127.98) v2(89.54,117.01) v2(95.99,100.85) v2(96.12,127.57) v2(99.77,90.96) v3(85.17,115.67) v3(85.93,129.29) v3(85.93,128.4) v3(85.93,127.51) v3(86.03,130.18) v3(86.03,115.67) v3(86.77,129.26) v3(86.77,128.37) v3(86.77,127.46) v3(86.92,130.15) v3(86.87,115.67) v3(87.71,115.69) v3(87.81,130.18) v3(88.55,115.69) v3(89.39,115.69) v3(90.07,130.18) v3(90.22,115.67) v3(90.99,130.18) v3(91.06,115.67) v3(91.24,129.31) v3(91.24,128.45) v3(91.24,127.53) v3(91.93,130.2) v3(92.08,129.31) v3(92.1,128.45) v3(92.08,127.51) v3(92.67,115.67) v3(92.66,114.83) v3(92.97,130.2) v3(92.99,129.34) v3(92.99,128.47) v3(92.99,127.53) v3(93.53,115.65) v3(93.5,114.81) v3(93.91,130.2) v3(93.86,129.29) v3(93.91,128.45) v3(93.91,127.56) v3(93.9,114.07) v3(94.34,114.81) v3(94.37,115.65) v3(94.77,130.23) v3(94.79,114.06) v3(94.95,96.77) v3(94.95,95.94) v3(94.95,95.1) v3(94.95,94.26) v3(94.95,93.42) v3(95.2,115.65) v3(95.18,114.81) v3(95.63,114.06) v3(96.04,115.65) v3(96.01,114.81) v3(96.57,106.94) v3(96.88,115.65) v3(96.85,114.81) v3(97.49,130.18) v3(97.74,115.62) v3(97.69,114.78) v3(98.45,130.17) v3(98.53,129.34) v3(98.53,128.42) v3(98.53,127.56) v3(99.42,129.34) v3(99.37,128.42) v3(99.39,127.53) v3(101.22,99.24) v3(101.21,98.3) v3(101.21,97.46) v3(101.21,96.62) v3(101.21,95.78) v3(101.21,94.95) v3(101.21,94.11) v3(101.21,93.27)
1V_GT_CORE: length 3.6
  BOTTOM w0.127: CPU1.AF2 92.93,106.7 v1(92.93,107.22) ; CPU1.AB2 v1(90.49,107.19)
  BOTTOM w0.203: v1(88.22,107.44) 88.22,107.27 88.21,107.19 88.16,107.14 88.09,106.77 88.09,106.41 88.07,106.39 CPU1.V2 ; CPU1.AK2 v1(95.37,106.82)
  vias: v1(90.55,102.22) v1(91.48,102.22) v2(91.06,101.31) v2(93.26,105.18) v3(89.36,100.38) v3(90.21,100.39) v3(91.87,100.38) v3(92.76,100.38)
1V_VCCGT: length 100.3
  TOP w0.406: 73.71,131.45 73.79,131.52 73.79,138.9 73.43,139.26 73.43,143.14 77.1,146.81 93.68,146.81 95.84,144.65 97.21,144.65 97.64,144.22 106.29,144.22 108.75,146.69 115.6,146.69 117.1,145.19 118.75,145.19 119.1,144.83 128.78,144.83 130.76,146.81 132.71,146.81 133.24,146.28 133.24,144.17 134.46,142.95 135.64,142.95 136.99,141.6 136.99,138.01 137.08,137.92 137.08,137.47 137.05,137.44 137.05,136.91 136.68,136.54 136.68,135.21 137.19,134.7 137.19,134.1 136.6,133.51 v1(136.6,131.39)
  BOTTOM w0.127: CPU1.P2 85.5,106.4 85.5,106.76 85.47,106.78 v1(85.47,107.09) ; CPU1.K2 83.17,106.91 83.11,106.96 83.11,107.01 v1(83.09,107.04)
  BOTTOM w0.508: v1(136.6,131.39) 136.6,131.27 135.32,130 PR4663.1
  vias: v1(75.24,98.72) v1(75.75,99.73) v1(76.38,97.21) v1(77.14,103.48) v1(77.1,102.21) v1(77.61,100.15) v1(77.61,98.27) v1(77.61,97.33) v1(78.26,97.33) v1(78.91,100.15) v1(78.91,98.27) v1(78.91,97.33) v1(78.91,95.44) v1(79.56,100.15) v1(79.56,98.27) v1(79.56,97.33) v1(79.56,95.44) v1(80.21,98.27) v1(80.39,104.17) v1(80.39,103.49) v1(80.39,102.22) v1(80.86,100.15) v1(80.86,98.27) v1(80.86,97.33) v1(80.86,95.44) v1(81.31,104.16) v1(81.31,103.49) v1(81.31,102.85) v1(81.31,102.22) v1(81.51,100.15) v1(81.51,98.27) v1(81.51,97.33) v1(81.51,95.44) v1(82.22,104.17) v1(82.23,103.51) v1(82.23,102.87) v1(82.23,102.24) v1(82.16,97.33) v1(82.81,100.15) v1(82.81,98.27) v1(82.81,97.33) v1(82.81,95.44) v1(83.15,102.86) v1(83.15,102.22) v1(84.09,102.85) v1(84.09,102.22) v1(84.08,100.69) v1(85.01,102.85) v1(85.01,102.22) v1(84.97,100.69) v1(85.93,102.22) v1(86.84,102.22) v1(86.79,100.69) v2(75.11,101.91) v2(78.62,128.73) v2(79.58,116.59) v2(80.41,96.36) v2(86.41,101.48) v2(89.3,93.79) v3(72.77,104.22) v3(73.03,130.02) v3(73.09,129.11) v3(73.36,130.81) v3(73.58,104.96) v3(73.89,130.13) v3(73.92,129.26) v3(73.89,128.42) v3(74.3,130.86) v3(74.34,105.7) v3(74.83,130.15) v3(74.83,128.35) v3(74.83,127.47) v3(74.86,129.24) v3(75.09,106.46) v3(75.57,115.65) v3(75.75,107.14) v3(75.85,128.35) v3(75.8,127.46) v3(75.87,130.15) v3(75.87,129.26) v3(76.41,115.65) v3(76.79,130.15) v3(76.84,128.37) v3(76.86,129.29) v3(76.89,127.46) v3(77.24,115.67) v3(77.75,130.23) v3(78.08,115.67) v3(78.92,115.67) v3(79.76,115.67) v3(80.04,130.2) v3(80.6,115.67) v3(80.88,130.2) v3(81.44,115.68) v3(82.27,115.65) v3(83.11,115.65) v3(83.95,115.65) v3(84.77,94.62) v3(84.77,93.78) v3(85.61,94.62) v3(85.61,93.78) v3(86.45,94.62) v3(86.45,93.78) v3(87.29,94.62) v3(88.13,94.62) v3(88.96,94.62) v3(89.8,94.62) v3(90.64,94.62)
1V_VCCIO: length 53.4
  TOP w0.305: C1109.1 109.21,96.42 110.17,96.42 v1(110.36,96.61)
  L3 w0.508: v1(67.82,101.27) 67.44,100.89 67.44,98.63 65.79,96.98 v1(65.79,96.57)
  L4 w0.508: v1(65.79,96.57) 67.44,94.92 70.62,94.92 71.76,93.78 73.89,93.78 73.92,93.75 74.62,93.75 75.76,93.75 75.77,93.76 77.77,93.76 77.79,93.78 78.11,93.78 78.62,94.29 83.24,94.29 86.34,91.19 94.03,91.19 94.09,91.24 94.13,91.24 94.75,91.86 v1(94.78,91.86)
  BOTTOM w0.2: CPU1.BH27 v1(107.09,89.94) ; CPU1.BH26 v1(106.18,89.94)
  BOTTOM w0.305: CPU1.BP16 v1(110.36,96.61) CPU1.BP18 ; R604.1 59.87,101.91 R602.2 61.17,101.92 62.21,100.88 66.8,100.88 67.2,101.27 v1(67.82,101.27) 66.55,100 C4007.1 65.94,99.49 R4042.1
  vias: v1(94.52,92.48) v1(95.16,92.37) v1(95.68,91.88) v1(106.18,92.34) v1(106.63,91.89) v1(107.09,92.34) v1(107.46,114.76) v1(107.7,114.17) v1(107.67,113.54) v2(106.73,91.11) v2(108.58,114.01) v2(115.24,117.22)
1V_VCCSA:
  vias: v1(104.98,114.02) v1(104.98,113.39) v1(105.79,100.33) v1(106.25,102.21) v1(107.19,102.19) v1(107.18,100.78) v1(107.56,91.88) v1(108,92.34) v1(108.11,100.78) v1(108.66,92.45) v2(107,99.26) v2(107.35,105.13) v2(107.64,92.89) v2(109.38,129.36) v3(104.57,127.6) v3(104.8,128.43) v3(104.88,129.27) v3(105.38,127.81) v3(105.73,129.16) v3(106.11,128.42) v3(106.28,126.98) v3(107.11,126.95) v3(107.95,126.95)
1V_VCCST_CPU: length 59.1
  TOP w0.508: R706.1 R704.1 PR4605.1 ; PR4605.1 PR4604.1 ; PR4605.1 R705.1 PR4606.1 PR4603.1 138.53,144.22 PC4602.1 137.9,143.94 v1(137.87,143.92)
  L3 w0.508: v1(111.89,127.43) 111.99,127.53 118.56,127.53 119.35,128.32 125.12,128.32 125.91,127.53 130.96,127.53 131.7,128.27 131.7,129.43 132.07,129.8 132.44,129.8 135.84,133.2 135.84,134.52 136.41,135.08 138.04,135.08 138.59,135.63 138.59,142.01 138.64,142.06 138.64,143.16 v1(137.87,143.92)
  BOTTOM w0.127: v1(110.35,99.98) 110.04,100.3 CPU1.BP11 ; CPU1.BR11 CPU1.BT11 111.01,100.07 v1(111.01,99.97) ; v1(110.47,107.52) 110.34,107.52 110.02,107.19 CPU1.BP2
  BOTTOM w0.254: v1(110.42,119.51) 107.72,119.51 107.23,119.02 107.23,118.89 107.19,118.85 107.19,118.82 106.38,118.01 106.38,115.27 106.1,114.99 R308.1
  BOTTOM w0.508: R4036.2 112.22,127.1 v1(111.89,127.43)
  vias: v2(109.74,105.13) v2(110.51,124.67) v2(110.95,100.86)
1V_VCCST_CPU_R:
  vias: v2(112.14,125.96)
1V_VCCSTG: length 61.9
  L4 w0.254: v1(105.59,107.14) 105.49,107.24 105.49,107.27 105.48,107.33 105.47,107.38 105.44,107.44 105.22,107.72 104.07,107.72 104.01,107.66 103.99,107.64 103.94,107.59 103.8,107.45 101.03,107.45 98.76,109.73 77.3,109.73 68.61,101.04 68.61,100.32 68.56,100.27 68.56,98.93 v1(69.01,98.48)
  BOTTOM w0.254: CPU1.BG3 CPU1.BG2 CPU1.BG1 105.79,106.94 v1(105.59,107.14) ; R301.1 R4042.2 65.89,98.73 C802.1 66.55,98.55 66.55,98.22 R314.2 R309.2 68,97.97 68.28,98.25 R313.2 68.81,98.68 v1(69.01,98.48) 69.6,98.48 69.78,98.65 70.56,98.65 R311.2 71,99.4 71,100.37 R312.2 72,100.6 R310.2 73.33,100.08 v2(73.46,99.95) 73.46,99.24 72.34,98.12 R315.2
3V5V_CT1: length 2
  BOTTOM w0.203: U4001.12 57.31,128.35 56.98,128.02 v2(56.91,128.02) 56.87,128.02 56.36,128.3 C4001.1
3V5V_CT2: length 3.6
  TOP w0.254: v1(62.23,37.89) 61.45,37.89 v2(61.19,38.14) 61.16,38.17 61.16,38.89 C4002.1
  BOTTOM w0.203: v1(62.23,37.89) 62.23,37.56 62.1,37.44 U4004.12
3V_5V_DSW_OK: length 175.5
  TOP w0.102: v1(105.03,40.51) 104.82,40.73 103.22,40.73 102.21,39.73 101,39.73 100.53,39.26 PR5308.1 ; v1(147.27,83.95) 147.4,83.82 147.4,81.3 148.91,79.8 148.91,77.17 149.07,77 153.22,72.85 153.78,72.85 154.05,73.12 154.05,73.21 154.08,73.24 v1(154.08,73.52)
  L4 w0.102: v1(154.08,73.52) 154.6,73.52 155.74,72.38 155.74,71.89 155.4,71.55 155.4,71.02 158.41,68.01 158.41,67.54 161.25,64.69 161.25,63.34 165.79,58.8 166.14,58.8 168.16,56.78 168.16,56.43 174.57,50.02 174.57,48.76 175.21,48.11 175.21,46.02 174.48,45.28 174.48,41.73 173.33,38.55 173.32,38.51 173.09,37.87 170.18,34.96 168.04,34.96 167.68,35.32 162.56,35.32 162.07,34.82 146.79,34.82 145.67,33.71 135.49,33.71 133.68,35.51 130.88,35.51 130.24,36.15 129.35,36.15 127.78,37.72 124.91,37.72 122.46,40.17 121.71,40.17 120.93,40.95 120.93,41.55 119.93,42.54 110.36,42.54 108.34,40.51 v1(105.03,40.51)
  BOTTOM w0.102: U2502.4 146.6,88.38 v2(146.6,87.58) 146.6,87.52 147.65,86.46 147.65,84.33 v1(147.27,83.95) ; v1(154.08,73.52) 153.46,73.52 152.28,74.71 152.28,75.16 152.4,75.28 152.4,77.78 152.81,78.19 152.81,82.34 154.36,83.9 154.64,83.9 155.3,84.56 156.74,84.56 157.43,85.25 157.43,87.56 157.08,87.92 157.08,89.03 156.9,89.21 156.9,91.64 157.81,92.55 D2503.3 160.1,92.82 160.15,92.87 R2514.2
3V_5V_EN: length 371.4
  TOP w0.089: v1(30.84,29.31) 30.08,30.07 v2(29.89,30.07) 29.13,30.07 R4009.1
  L3 w0.089: v1(30.84,29.31) 31.14,29.01 34.3,29.01 34.6,29.3 41.34,29.3 41.47,29.3 41.57,29.3 42.4,30.13 73.87,30.13 78,34.26 91.16,34.26 91.91,35.01 93.28,35.01 93.61,35.34 100.31,35.34 100.31,35.34 100.65,35.34 102.22,36.92 103.13,36.92 103.75,37.54 104.49,37.54 105.57,38.61 106.38,38.61 106.64,38.87 107.93,38.87 109.08,40.02 109.08,40.73 110.27,41.91 119.67,41.91 120.2,41.39 120.2,40.72 120.95,39.96 124.23,39.96 126.49,37.71 127.39,37.71 129.1,36 146.45,36 149.67,32.78 155.76,32.78 160.87,37.88 164.89,37.88 166.22,36.56 167.29,36.56 168.4,37.66 170.42,37.66 171.24,36.84 182.13,36.84 183.33,35.65 186.29,35.65 189.66,39.01 192.9,39.01 193.13,38.78 196.35,38.78 196.55,38.59 200.65,38.59 200.8,38.73 200.81,38.73 200.83,38.75 207.25,38.75 207.62,39.12 212.72,39.12 215.91,42.31 216.83,42.31 218.64,44.12 218.64,47.83 219.63,48.82 219.93,48.82 221.51,50.4 221.51,61.45 220.39,62.56 220.03,62.56 215.82,66.77 213.66,66.77 213.39,66.51 213.39,65.87 212.95,65.43 209.68,65.43 209.31,65.8 190.04,65.8 187.23,62.99 184.63,62.99 180.64,66.98 178.3,66.98 177.42,67.86 175.54,67.86 175.39,68.02 175.33,68.02 175.12,68.22 174.34,69 173.65,69 171.21,71.45 171.21,72.47 171.16,72.51 171.16,72.56 162.16,81.56 162.16,82.52 161.55,83.14 161.55,84.46 161.11,84.9 161.11,86.33 160.19,87.25 160.19,87.25 142.47,104.97 142.47,107.19 141.54,108.12 141.54,110.22 140.36,111.41 140.36,115.22 138.61,116.97 v1(138.46,116.97)
  L4 w0.089: v1(30.84,29.31) 30.84,30.82 33.62,33.61 33.62,35.7 34.42,36.5 34.42,37.23 35.31,38.12 35.31,38.39 35.4,38.48 35.4,39 35.32,39.07 35.32,39.77 33.3,41.78 31.79,41.78 v1(31.65,41.64)
  BOTTOM w0.089: v1(138.46,116.97) 138.46,118.04 138.72,118.3 C4009.1 139.48,118.47 R4006.1 140.35,118.45 R4014.1 142.42,118.45 D4001.A ; PR4516.1 30.23,40.95 30.66,41.38 31.39,41.38 v1(31.65,41.64) 32.62,41.64 32.9,41.37 33.56,41.37 33.92,41.01 PR4504.1
3V_5V_POK: length 348.3
  TOP w0.089: v1(39.04,36.5) 39.2,36.65 R4033.1 ; v1(18.95,63.01) 18.95,63.21 18.39,63.78 17.76,63.78 17.48,63.49 17.49,63.06 Q1701.2 ; ED1703.2 71.93,137.87 71.64,138.16 v2(71.13,138.16) 70.88,138.16 v1(70.51,137.8)
  L2SGND w0.089: v1(18.95,63.01) 19.78,63.01 20.44,62.35 20.44,61.53 20.34,61.42 20.34,58.65 18.57,56.89 18.57,52.58 19.51,51.65 19.51,50.46 19.12,50.07 19.12,46.05 21.83,43.34 21.83,41.91 22.74,41 24.39,41 25.57,42.18 26.3,42.18 v1(26.65,41.84)
  L3 w0.089: v1(18.95,63.01) 19.18,63.01 19.72,63.55 19.72,63.83 21.35,65.46 21.35,66.75 21.17,66.93 21.17,67.31 21.35,67.49 21.36,67.49 21.84,67.98 21.84,67.98 25.18,71.32 25.81,71.32 26.97,72.48 26.97,72.55 28.16,73.74 37.18,73.74 40.75,77.32 40.75,91.76 42.16,93.17 43.94,93.17 45.28,91.84 v1(45.28,91.83) ; v1(26.65,41.84) 27.66,41.84 29.65,39.85 29.65,37.73 30.66,36.72 32.81,36.72 32.86,36.67 34.59,36.67 36.05,38.13 38.34,38.13 38.65,37.82 38.65,37.37 38.63,37.36 38.63,37.01 38.65,37 38.65,36.9 v1(39.04,36.5) ; v1(42.55,118.39) 42.75,118.39 43.73,119.37 43.73,119.95 45.38,121.6 45.38,123.63 48.95,127.2 53.83,127.2 55.73,125.3 58.79,125.3 59.3,125.81 59.3,129.83 59.7,130.23 59.7,132.6 64.89,137.79 69.65,137.79 69.77,137.67 70.39,137.67 v1(70.51,137.8) 70.51,138.39 72.46,140.34 72.46,143.85 78.68,150.06 98.76,150.06 99.48,149.34 102.96,149.34 104.82,151.2 119.21,151.2 122.42,148 138.54,148 139.12,147.42 151.16,147.42 153.2,145.38 161.53,145.38 163.08,143.83 163.08,140.85 162.76,140.53 162.76,139.13 164.09,137.8 164.09,134.94 159.72,130.58 159.72,119.87 160.54,119.05 160.54,117.17 159.79,116.42 159.79,113.21 159.64,113.06 159.64,112.73 159.35,112.44 159.35,111.3 159.62,111.03 159.62,110.42 158.19,108.99 158.19,107.91 156.55,106.27 156.55,105.65 156.55,105.51 155.05,104.01 155.05,97.51 155.14,97.43 155.14,97.05 158.98,93.2 158.98,92.48 v1(159.63,91.83)
  L4 w0.089: v1(45.28,91.83) 45.28,92.11 44.43,92.96 44.43,96.72 43.79,97.36 43.79,101.22 44.83,102.26 44.83,106.66 45.37,107.2 45.37,110.93 46.55,112.11 46.55,116.66 45.44,117.77 43.17,117.77 v1(42.55,118.39)
  BOTTOM w0.089: PR4505.2 70.62,138.56 70.62,137.9 v1(70.51,137.8) 70.08,137.37 PU4501.10 69.36,137.86 69.23,137.99 69.05,137.99 68.91,137.85 PU4501.9 ; PU4502.10 39.46,36.97 39.04,36.55 v1(39.04,36.5) 39.87,36.5 PU4502.9 ; v1(159.63,91.83) 159.46,91.66 158.67,91.66 D2503.1
3V_5V_POK#: length 4
  TOP w0.102: Q1701.6 16.84,65.53 R1726.1 16.81,65.7 17.12,65.7 17.27,65.55 18.06,65.55 ; Q1701.5 17.49,65.03 17.72,65.27 17.79,65.27 18.06,65.55 ; v2(18.29,65.84) 18.29,65.77 18.06,65.55
5V_3V_TPAN_PWR:
  vias: v1(210.29,45.76) v2(208.93,44.18)
5V_FAN_VCC: length 0.9
  TOP w0.089: AFTP2603.1 159.82,90.17 v1(159.82,89.46)
5V_HDD_S0: length 1.8
  BOTTOM w0.305: HDD1.8 159.65,39.86 160.08,40.29 v1(160.18,40.29)
  vias: v1(160.83,40.31) v2(160.1,37.52)
5V_HDMI: length 9.3
  TOP w0.508: v1(15.01,102.53) 16.24,101.3 16.41,101.3 C5736.2 16.46,100.99 17.1,100.36 F5701.2
  BOTTOM w0.305: v2(14.94,103.15) 15.73,103.15 U5702.2
  BOTTOM w0.508: HDMI1.18 12.54,103.35 13.36,102.53 v1(15.01,102.53) 15.63,102.53 U5702.2
5V_IRLED: length 8.9
  TOP w0.305: v1(220.14,46.25) 220.35,46.25 223.09,43.51 223.09,42.47 223.47,42.09 C5504.1
  TOP w0.508: C5504.1 223.54,41.88 F5506.2
  BOTTOM w0.305: LCD1.24 219.37,45.55 219.61,45.79 219.61,45.84 220.03,46.25 v1(220.14,46.25)
5V_ODD_S0:
  vias: v1(185.65,35.11) v1(190.33,34.8)
5V_S0: length 386
  TOP w0.203: R5502.1 203.53,40.38 202.96,40.95 v1(202.3,40.95)
  TOP w0.381: R2703.2 17.86,8.45 17.65,8.24 17.65,8.08 17.15,7.58 v1(17.15,6.45)
  TOP w0.508: v1(18.32,100.18) 18.32,99.72 17.2,98.6 F5701.1 17.1,97.74 C4005.1 ; R5502.1 203.72,38.16 203.72,36.72 204.22,36.22 204.22,32.67 v1(204.18,32.63) 204.3,32.52 EC8933.1 ; F5506.1 224.43,40.79 v1(224.41,40.77) ; Q5701.G 20.85,92.46 FC8913.1 20.57,92.18 19.94,92.18 19.61,92.51 v2(19.46,92.51) 19.3,92.51 18.97,92.18 D5701.3 18.16,92.9 v1(18.19,92.93)
  L2SGND w0.508: v1(157.79,65.31) 158.54,65.31 159.01,64.84 159.01,64.52 164.7,58.83 165.02,58.83 165.04,58.8 165.86,58.8 173.44,51.22 175.53,51.22 176.68,50.07 176.68,41.67 174.93,39.93 172.24,39.93 169.94,37.63 169.74,37.63 169.12,37.01 v1(169.12,36.7) ; v1(30.53,23.42) 27.84,26.11 27.84,27.26 27.08,28.02 25.63,28.02 24.56,29.08 20.99,29.08 20.27,29.81 20.27,30.55 19.76,31.06 19.76,35.5 18.71,36.56 18.71,43.99 17.56,45.14 17.56,50.11 17.22,50.45 16.97,50.7 16.97,57.04 16.24,57.77 15.86,57.77 15.36,58.27 15.28,58.73 15.11,58.9 15.11,64.5 14.71,64.9 14.71,67.84 15.78,68.91 15.78,69.66 16.33,70.21 16.85,70.21 17.59,70.94 17.59,72.87 19,74.28 19,74.97 19,75.32 21.57,77.89 22.91,77.89 23.31,77.49 27.54,77.49 28.34,76.7 34.75,76.7 35.18,77.13 37.23,77.13 37.8,77.7 v1(37.8,77.75)
  L3 w0.508: v1(18.32,100.18) 17.66,99.52 17.66,93.47 v1(18.19,92.93) 18.77,92.36 25.93,92.36 26.23,92.05 37.1,92.05 38.53,90.62 38.53,80.8 37.72,79.99 37.72,77.83 v1(37.8,77.75)
  L4 w0.203: v1(202.3,40.95) 202.32,40.97 203.3,40.97 204.59,39.68 206.71,39.68 207.17,39.68 207.9,40.41 208.05,40.41 208.06,40.42 208.94,40.42 209.3,40.78 209.3,41.11 209.3,41.28 211.72,43.71 212.21,43.71 212.54,44.03 212.54,46.57 v1(213.67,47.7)
  L4 w0.508: v1(220.35,66.76) 220.35,66.17 221.36,65.15 221.36,64.36 222.56,63.17 222.56,44.58 224.41,42.72 v1(224.41,40.77) 224.74,40.77 225.14,40.37 225.14,38.42 224.84,38.13 222.94,38.13 221.57,36.76 219.35,36.76 218.1,38 216.88,38 214.12,35.25 214.12,32.96 212.26,31.1 207.82,31.1 207.04,31.88 204.94,31.88 v1(204.18,32.63) 203.38,31.83 190.94,31.83 190.76,32.01 v4(190.76,32.45) ; v1(35.03,21.46) 35.61,20.88 35.61,5.59 34.47,4.44 29.44,4.44 28.95,4.93 23.31,4.93 21.78,6.45 v1(17.15,6.45)
  BOTTOM w0.305: 204.45,59.94 VGABD1.1
  BOTTOM w0.381: ED5502.5 213.22,47.84 213.25,47.81 213.56,47.81 v1(213.67,47.7)
  BOTTOM w0.508: v1(157.79,65.31) 158.14,65.67 158.14,67.27 160.51,69.64 160.51,75.78 161.94,77.22 163.66,77.22 164.85,78.41 164.85,79.5 165.82,80.47 165.82,92.61 166.37,93.16 166.37,93.75 166,94.12 165.34,94.12 165.02,93.8 163.55,93.8 163.53,93.83 R2612.1 ; F6501.1 80.03,37.21 79.68,36.86 v1(79.68,35.05) ; 204.45,59.94 204.45,60.89 206.05,62.49 206.05,64.14 206.33,64.42 215.34,64.42 216.13,65.2 216.13,66.58 216.74,67.18 218.81,67.18 219.24,66.76 v1(220.35,66.76) ; v1(30.53,23.42) v1(32.97,23.42) ; v1(104.14,40.3) 103.7,40.74 Q6505.E ; U5702.3 18.57,101.78 18.57,100.94 18.32,100.69 v1(18.32,100.18)
  vias: v1(38.74,30.94) v1(39.37,30.91) v1(40.01,30.89) v1(40.64,30.91) v1(99.88,40.74) v1(107.19,39.96) v1(169.14,36.04) v1(169.77,36.69) v2(39.63,30.01) v2(79.86,35.68) v3(62.49,36.93) v3(63.4,36.93) v3(64.3,36.91) v3(99.24,40.26) v3(100.11,40.04) v3(107.9,39.58) v4(157.99,37.29) v4(158.7,37.29)
5V_S5: length 440.8
  TOP w0.127: R3605.1 18.61,56.06 15.66,56.06 15.36,55.75 15.36,54.76 15.66,54.46 15.98,54.46 16.28,54.15 16.28,53.49 16.7,53.08 R3606.1 17.13,53.08 17.48,52.73 17.48,52.45 R3602.1
  TOP w0.152: R3605.1 19.71,54.97 20.05,54.97 20.35,55.26 20.35,55.51 21.93,57.1 21.96,57.1 22.39,57.53 23.95,57.53 24.62,56.86 24.62,54.96 23.89,54.23 23.89,54.05 24.28,53.66 24.4,53.66
  TOP w0.305: PR4670.2 140.49,139.6 140.68,139.78 140.68,139.84 140.69,139.86 140.69,139.92 141.01,140.23 143.96,140.23 ; v1(18.98,100.36) 18.96,100.34 18.96,100.16 19,100.11 R4303.1 ; v1(147.02,80.82) 148.44,79.39 148.44,77.16 148.94,76.67 148.94,76.67 158.22,67.39 160,67.39 160.62,66.77 162.45,66.77 162.66,66.98 v1(162.69,66.98) ; v1(112.26,140.58) 113.49,139.34 v1(113.89,139.34) ; v1(88.45,145.72) 87.84,146.33 84.84,146.33 84.24,145.72 84.24,144.59 85.14,143.69 v1(85.14,139.45) 86.14,139.45 86.88,140.19 87.86,140.19 88.23,139.83 PC4877.1 ; EC6601.1 201.12,39.58 201.75,40.22 202.53,40.22 v1(202.77,40.46)
  TOP w0.381: v1(194.54,61.07) 194.6,61.07 194.64,61.11 194.8,61.11 196.32,62.64 v2(203.01,62.64) 205.26,62.64 206.07,63.45 206.07,64.06 206.28,64.26 207.93,64.26 209.83,66.17 v1(209.93,66.17) ; 210.27,41.81 210.27,43.04 210.48,43.25 210.48,44.19 v1(210.29,44.39) ; 210.27,41.81 210.27,40.03 210.71,39.6 211.36,38.95 211.66,38.95 213.5,38.95 213.84,38.6 v1(213.84,38.25) ; 210.27,41.81 209.7,41.81 R5560.1
  TOP w0.508: 131.58,144.68 130.29,144.68 129.25,143.64 121.67,143.64 118.93,140.9 115.44,140.9 v1(113.89,139.34) ; 131.58,144.68 131.58,143.97 131.98,143.56 131.98,143.35 132.19,143.14 132.19,136.25 131.17,135.23 131.17,132.85 130.84,132.52 130.84,132.48 130.47,132.11 130.43,132.11 128.37,130.05 128.33,130.05 127.93,129.64 v1(127.93,129.46) ; 131.58,144.68 131.58,145.06 132.46,145.95 v1(132.46,146.23) ; v3(58.72,36.73) 58.72,35.25 56.85,33.37 56.85,32.23 v1(54.21,29.59) ; v1(99.34,37.11) 99.14,36.91 99.14,36.37 99.14,36.37 PC5301.1 99.06,35.48 99.06,30.63 v1(99.38,30.32) ; PC4766.1 74.45,139.42 v1(74.27,139.24)
  L2SGND w0.508: v1(99.38,30.32) 99.44,30.25 99.44,30.2 99.7,29.95 99.7,29.49 100.69,28.5 110.26,28.5 v4(110.98,29.21)
  L3 w0.305: v1(147.02,80.82) 145.6,82.24 145.6,82.73 144.87,83.46 143.73,83.46 142.1,85.08 141.92,85.08 v1(141.85,85.16)
  L4 w0.254: v1(93.91,139.42) 93.37,138.89 91.16,138.89 89.51,140.54 86.24,140.54 v1(85.14,139.45) 84.33,139.45 83.77,138.89 74.63,138.89 v1(74.27,139.24)
  L4 w0.305: v3(146.48,134.72) 145.88,134.72 140.82,129.67 140.82,128.68 139.96,127.81 138.05,127.81 136.88,126.65 v1(136.83,126.65)
  L4 w0.508: v1(99.38,30.32) 92.52,30.32 91.25,29.05 85.85,29.05 82.55,32.35 77.51,32.35 74.76,29.59 v1(54.21,29.59) ; v1(132.46,146.23) 132.46,146.03 133.19,145.3 139.72,145.3 141.53,147.12 142.93,147.12 145.6,144.45 145.6,143.28 v3(145.67,143.2)
  L4 w1.016: v1(68.82,89.72) v1(67.87,89.72) 65,89.72 63.41,88.12 63.41,84.78 56.31,77.69 56.31,76.89 50.88,71.46 50.88,70.9 45.27,65.29 45.27,65.24 43.2,63.17 v3(42.93,63.17)
  BOTTOM w0.203: U4001.4 60.35,127.95 60.79,127.51 60.81,127.51 v1(61.01,127.31) ; U4004.4 58.89,37.84 v1(58.83,37.78) ; v1(210.29,44.39) U5502.4
  BOTTOM w0.305: v1(132.46,146.23) 132.58,146.35 PR4610.1 ; v1(85.14,139.45) 85.46,139.13 PU4802.29 ; PU4801.29 94.2,139.18 93.96,139.42 v1(93.91,139.42) ; U4002.3 124.75,115.73 124.82,115.8 125.66,115.8 ; v1(162.69,66.98) 162.72,67 162.72,67.06 164.57,68.91 164.57,69.72 167.85,73 173.5,73 176.3,70.21 176.41,70.21 177.93,68.68 v1(178.74,68.68) ; v1(61.01,127.31) 61.19,127.31 61.36,127.14 61.36,127.05 61.52,126.89 EC8947.1 ; PR4704.2 74.23,143.71 73.49,142.97 73.49,140.03 v1(74.27,139.24) 74.45,139.07 75.24,139.07 PU4701.29 ; PC5202.1 116.17,140.2 116.34,140.03 PU5201.21 ; PU5301.6 98.25,37.42 99.24,36.42 PC5121.1 99.3,36.43 99.3,37.07 v1(99.34,37.11) ; v1(127.93,129.46) 127.72,129.26 123.55,129.26 122.84,128.55 120.17,128.55 119.76,128.14 C4031.1 119.43,127.74 119.08,127.38 119.08,126.54 118.19,125.66 U4006.3 ; PU5001.6 112.24,140.59 v1(112.26,140.58)
  BOTTOM w0.381: v1(136.83,126.65) 137,126.48 137,123.66 135.08,121.74 130.99,121.74 128.07,118.82 128.07,116.66 127.13,115.72 C4032.1 126.24,115.8 125.66,115.8 ; v1(194.54,61.07) 194.54,61.02 194.11,60.58 194.11,58.12 194.71,57.52 195.19,57.52 195.32,57.39 195.32,57.39 195.51,57.2 195.51,57.18 195.6,57.09 195.6,55.35 196.1,54.85 196.1,54.52 196.11,54.51 Q6405.E
  BOTTOM w0.406: ED6601.5 203.24,41 202.77,40.53 v1(202.77,40.46)
  BOTTOM w0.508: Q6404.E 14.63,108.86 12.1,108.86 Q6403.E 11.64,109.22 11.45,109.03 v1(11.45,108.45) ; v1(158.96,118.64) 158.96,119.1 159.79,119.94 161.71,119.94 162.32,120.55 163.11,120.55 163.62,121.06 166.55,121.06 168.13,119.48 168.13,114.45 167.9,114.23 167.9,107.54 166.88,106.53 165.59,106.53 164.8,107.32 PC5120.1 164.82,108.41 164.82,108.87 164.69,109 164.67,109.2 164.67,109.3 164.67,109.3 PU5101.6 ; PC5202.1 113.92,140.2 PC5001.1 113.9,139.36 v1(113.89,139.34) ; PR4813.2 v1(88.45,145.72) 88.55,145.62 91.37,145.62 92.52,144.48 93.01,144.48 93.48,144.94 PR4825.2 94.23,145.12 95.02,145.9 v1(95.58,145.9) ; v1(93.91,139.42) 93.66,139.67 93.66,139.85 93.6,139.92 PC4866.1
  vias: v1(19.13,35.15) v1(19.13,34.52) v1(19.13,33.88) v1(48.4,40.02) v1(54.92,77.47) v1(61.99,92.74) v1(62.4,93.23) v1(193.5,39.61) v1(194.13,39.61) v1(194.77,39.61) v1(214.48,38.2) v1(214.53,37.57) v2(21.93,32.4) v2(50.05,37.93) v2(50.2,65.64) v2(55.1,91.39) v2(145.37,142.61) v3(20.25,39.12) v3(35.5,56.79) v3(37.62,40.88) v3(48.09,39.32) v3(48.11,38.48) v3(48.12,37.57) v3(48.1,36.61) v3(49.15,39.93) v3(49.69,35.4) v3(49.98,39.96) v3(50.82,39.96) v3(50.75,35.44) v3(51.82,38.51) v3(56.98,36.76) v3(57.86,36.74) v3(63.43,133.55) v3(63.44,132.68) v3(63.45,131.84) v3(64.29,133.47) v3(64.3,132.6) v3(64.32,131.74) v3(65.39,105.64) v3(66.06,105.07) v3(69.74,111.41) v3(70.4,110.85) v3(146.54,143.08) v3(147.37,135.33) v3(160.67,112.12) v3(161.2,112.77) v3(161.47,113.57) v3(167.16,94.82) v3(167.62,94.03) v3(167.62,92.99) v4(21.2,122.31) v4(21.3,121.58) v4(43.69,123.88) v4(44.12,123.32) v4(44.33,124.12)
5V_TPAN_PWR: length 21.4
  TOP w0.381: v1(201.84,39.43) 201.84,38.72 R5502.2
  TOP w0.508: v1(216.9,43.39) 216.83,43.32 216.83,43.07 216.79,43.03 216.79,42.57 217.11,42.24 217.73,42.24 217.99,41.97 218.53,41.97 F5505.1
  L3 w0.381: v1(201.84,39.43) 201.92,39.34 206.96,39.34 207.31,39.69 212.39,39.69 216.09,43.39 v1(216.9,43.39)
  vias: v2(214.02,45.26)
5V_TPAN_VDD: length 2.1
  BOTTOM w0.254: LCD1.25 219.35,45.05 219.71,44.68 219.71,43.73 v1(219.85,43.6)
  vias: v2(221.72,41.17)
5V_USB30_VCCA: length 2.5
  TOP w0.635: USB2.1 13.98,34.5 ; USB2.1 13.14,35.34 ; USB2.1 13.14,33.66
  vias: v1(15.93,36.98) v1(15.93,36.15) v1(15.95,38.08)
5V_VCONN_EN: length 2.4
  TOP w0.102: v2(47.08,123.13) 47.08,123.97 R7205.2 46.92,124.16 46.19,124.88 U7202.3
5V_VCONN_P1: length 2.7
  TOP w0.305: U7202.5 48.62,125.63 48.68,125.69 48.84,125.69 R7203.1 48.61,126.13 U7202.6
  TOP w0.508: v2(49.94,125.81) R7203.1
5V_VCONN_P1_CCG4: length 18.5
  TOP w0.305: v2(43.51,110.77) 43.49,110.77 43.23,111.02 v1(43.23,111.3) 43.09,111.16 U7201.5
  TOP w0.508: v1(49.71,124.95) R7203.2
  L3 w0.508: v1(49.71,124.95) 49.71,124.57 49.08,123.94 49.08,123.28 49.06,123.26 49.06,122.1 49.07,122.1 49.07,120.64 46.43,118.01 46.43,117.47 44.68,115.72 44.68,115.22 43.13,113.67 43.13,112.63 43.18,112.58 43.18,111.35 v1(43.23,111.3)
19V_AD+: length 355.4
  TOP w0.203: PR4473.1 157.18,111.36 157.8,111.99 158.07,111.99 159.08,113.01 159.08,116.41 158.83,116.66 158.83,117.45 v1(159.29,117.91)
  TOP w0.254: v1(213.83,66.35) v2(213.83,65.74)
  L3 w0.102: v1(213.83,66.35) 214.31,65.86 216.42,65.86 219.94,62.34 220.3,62.34 221.29,61.35 221.29,53.76 220.83,53.3 219.6,53.3 217.5,51.21 217.5,50.26 214.12,46.87 212.67,46.87 211.36,45.56 211.36,43.76 210.18,42.57 208.98,42.57 208.71,42.84 207.62,42.84 206.89,42.11 205.08,42.11 204.57,42.11 204.28,42.41 201.43,42.41 201,41.98 199.17,41.98 v1(199.04,42.11)
  L4 w0.102: v3(31.35,132.13) 34.29,132.13 34.57,132.41 34.57,133.05 35.56,134.04 54.64,134.04 56.14,135.54 56.14,138.47 57.04,139.37 61.97,139.37 71.72,149.12 71.86,149.26 95.75,149.26 97.34,147.67 104.78,147.67 106.2,149.09 107.1,149.09 120.23,149.09 122.23,147.09 127.56,147.09 131.3,150.83 163.94,150.83 167.48,147.29 167.48,125.06 165.92,123.5 165.92,120.64 v1(166.26,120.31) 166.42,120.14 166.42,108.99 164.57,107.14 162.96,107.14 158.98,103.16 158.98,98.27 167.83,89.42 167.83,81.86 179.38,70.32 179.55,70.32 180.02,69.85 180.77,69.85 181.53,69.09 186.26,69.09 186.76,68.93 187.38,68.67 187.66,68.47 188.72,67.42 188.85,67.29 189.34,66.81 208.99,66.81 209.51,67.33 212.84,67.33 v1(213.83,66.35)
  BOTTOM w0.102: v1(159.29,117.91) 160.15,117.91 161.75,119.51 161.89,119.51 162.45,120.07 163.45,120.07 163.99,120.6 165.86,120.6 166.15,120.31 v1(166.26,120.31)
  BOTTOM w0.305: v1(199.04,42.11) 199.43,41.71 199.43,41.21 PD4401.1 198.76,41.28 198.2,41.28 197.84,40.92 197.84,40.49 197.56,40.21 195.84,40.21 PD4408.1 195.7,41.17 195.15,41.72 193.8,41.72 192.91,42.61 192.91,43.88 PR4465.1 193.2,44.3 193.59,44.7 194.07,44.7 PR4464.2
20V_DCBATOUT: length 2.8
  TOP w0.305: PR4439.1 196.97,52.62 AFTP4408.1 196.09,53.22 v1(195.82,53.22)
  vias: v2(191.47,56.33)
20V_VCCPD_VBUS: length 70.7
  TOP w0.305: v1(43.09,106.91) R7201.2
  TOP w0.508: v1(10.35,118.69) 10.38,118.69 10.42,118.73 10.61,118.73 11.02,118.31 C7303.1 C7307.1 11.02,116.39 AFTP7302.1 10.35,115.71 10.35,114.51 10.05,114.22 v1(9.69,114.22)
  L3 w0.508: v1(26.72,114.81) 26.72,114.73 26.89,114.56 26.89,103.82 29.42,101.3 31.1,101.3 35.24,105.44 40.47,105.44 42,106.97 43.02,106.97 v1(43.09,106.91) ; v1(10.35,118.69) 10.38,118.69 10.96,119.27 10.96,119.86 10.28,120.53 9.95,120.53 9.12,121.36 v1(9.12,122)
  L4 w0.508: v1(27.54,125.63) 27.54,125.22 24.79,122.48 24.79,120.22 25.17,119.84 25.17,118.5 v1(25.43,118.25)
  BOTTOM w0.305: C7304.1 C7302.1 11.4,124.59 10.95,125.05 v3(10.16,125.05) ; JUSB1.B4 6.76,124.95 JUSB1.A9 ; JUSB1.A4 6.76,122.45 JUSB1.B9 ; R7426.1 24.63,108.57 23.75,109.45 R7425.1 23.75,110.77 27.24,114.26 27.3,114.26 R7423.1 27.54,114.68 27.42,114.81 v1(26.72,114.81)
  BOTTOM w0.508: v1(26.72,114.81) 26.19,115.34 26.19,117.93 25.87,118.25 v1(25.43,118.25) ; C7305.1 11.23,114.12 C7306.1 9.78,114.12 v1(9.69,114.22)
  vias: v1(27.11,127.33) v1(27.1,126.69) v1(27.71,127.11) v3(39.17,127.46) v3(40.01,127.46) v3(40.9,127.46) v3(41.74,127.48)
20V_VCCPD_VBUS_R: length 4.9
  TOP w0.102: R7201.1 44.16,107.1 C7201.2 44.15,107.25 R7213.2 44.15,108.17 43.99,108.33 43.99,108.85 v2(43.58,109.26) 43.57,109.26 43.57,109.5 42.91,110.16 U7201.3
+1.8VALW_EC: length 3.1
  TOP w0.203: 33.58,57.46 33.58,57.9 33.55,57.93 U2401.54
  TOP w0.305: 33.58,57.46 v2(33.58,57.35) 33.58,56.69 C2423.1 33.45,56.47 34.14,56.47 R2462.1
+3V_1D8V_DVDD: length 12.7
  TOP w0.203: 25.77,16.88 25.93,16.72 HDA27.8
  TOP w0.254: v1(22.2,19.61) 22.08,19.48 R2710.1 ; 25.77,16.88 25.35,17.3 25.07,17.3 24.49,17.88 24.49,18.29 v1(24.46,18.31) 24.41,18.26 C2741.1
  L4 w0.254: v1(29.29,16.26) 26.52,16.26 v1(24.46,18.31) 23.88,18.31 22.58,19.61 v1(22.2,19.61)
  vias: v2(26.8,21.03)
