# Allegro board 17938-1.1228WZS1107.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQ57: length 62.5
  L2SGND w0.089: 82.76,84.91 82.87,85.03 82.87,86.24 83.17,86.53 v1(83.17,86.53)
  L2SGND w0.114: v1(80.06,48.01) 80.58,48.53 80.58,49.29 80.46,49.4 80.03,49.4 79.91,49.52 79.91,49.86 80.03,49.97 80.46,49.97 80.58,50.09 80.58,50.32 80.46,50.43 80.03,50.43 79.91,50.54 79.91,50.77 80.03,50.89 80.46,50.89 80.58,51 80.58,51.23 80.46,51.34 80.03,51.34 79.91,51.46 79.91,51.69 80.03,51.8 80.46,51.8 80.58,51.92 80.58,52.14 80.46,52.26 80.03,52.26 79.91,52.37 79.91,52.6 80.03,52.72 80.46,52.72 80.58,52.83 80.58,53.06 80.46,53.17 80.03,53.17 79.91,53.29 79.91,53.63 80.03,53.74 80.38,53.74 80.49,53.86 80.49,54.08 80.36,54.2 80.03,54.2 79.91,54.32 79.91,54.67 79.67,54.92 79.51,54.92 79.2,54.61 79.04,54.61 78.87,54.77 78.87,54.93 79.18,55.24 79.18,55.4 79.02,55.56 78.86,55.56 78.55,55.25 78.39,55.25 78.23,55.42 78.23,55.58 78.54,55.89 78.54,56.05 78.38,56.21 78.21,56.21 77.9,55.9 77.74,55.9 77.58,56.06 77.58,56.22 77.89,56.53 77.89,56.7 77.73,56.86 77.57,56.86 77.26,56.55 77.1,56.55 76.93,56.71 76.93,56.87 77.24,57.18 77.24,57.34 72.79,61.8 72.79,78.19 73.62,79.02 73.62,79.49 76.36,82.23 78.85,82.23 79.28,82.67 80.51,82.67 82.76,84.91
  BOTTOM w0.089: v1(83.17,86.53) 83.43,86.79 83.78,86.98 CPU1.L32
  BOTTOM w0.216: v1(80.06,48.01) 80.42,48.01 80.83,48.42 DM1.195
M_A_DQ58: length 59.8
  L2SGND w0.089: v1(84.3,88.68) 84.65,88.34 84.65,88.13 84.65,87.8 84.41,87.57 84.21,87.36 84.21,86.91 84.08,86.78 84.08,86.04 84.29,85.82 84.29,85.49 82.86,84.06 82.86,83.9
  L2SGND w0.114: v1(83.57,46.6) 82.06,48.11 82.06,54.62 75.04,61.65 75.04,62.37 74.93,62.49 74.43,62.49 74.31,62.6 74.31,62.83 74.43,62.94 74.93,62.94 75.04,63.06 75.04,63.29 74.93,63.4 74.43,63.4 74.31,63.52 74.31,63.74 74.43,63.86 74.93,63.86 75.04,63.97 75.04,71.92 74.59,72.38 74.59,79.34 76.9,81.65 79.17,81.65 79.59,82.07 81.96,82.07 82.86,82.97 82.86,83.9
  BOTTOM w0.089: CPU1.N29 v1(84.3,88.68)
  BOTTOM w0.216: v1(83.57,46.6) 84.03,46.15 84.03,45.18 84.03,43.94 84.08,43.89 DM1.208
M_A_DQ59: length 60.3
  L2SGND w0.089: 83.24,84.02 83.24,84.19 84.47,85.42 84.47,85.91 84.26,86.12 84.26,86.71 84.45,86.9 84.45,87.33 84.82,87.7 84.82,87.73 84.82,88.81 v1(84.3,89.33)
  L2SGND w0.114: 83.24,84.02 83.24,83.06 82.03,81.85 79.7,81.85 79.28,81.43 76.97,81.43 74.94,79.39 74.94,72.52 75.41,72.04 75.41,61.76 75.65,61.52 75.81,61.52 76.06,61.76 76.22,61.76 76.38,61.6 76.38,61.44 76.14,61.2 76.14,61.04 76.3,60.87 76.46,60.87 76.7,61.12 76.87,61.12 77.03,60.95 77.03,60.79 76.78,60.55 76.78,60.39 76.95,60.23 77.11,60.23 77.35,60.47 77.51,60.47 77.67,60.31 77.67,60.15 77.43,59.9 77.43,59.74 77.59,59.58 77.75,59.58 78,59.82 78.16,59.82 78.32,59.66 78.32,59.5 78.08,59.26 78.08,59.1 82.41,54.77 82.41,48.25 82.92,47.73 v1(83.32,47.73)
  BOTTOM w0.089: CPU1.N28 v1(84.3,89.33)
  BOTTOM w0.216: DM1.207 83.83,47.95 83.61,47.73 v1(83.32,47.73)
M_A_DQ60: length 58
  L2SGND w0.089: 77.49,82.96 77.71,82.96 79.25,84.5 81.04,84.5 82.3,85.76 82.3,86.92 82.82,87.44 82.82,88.41 82.85,88.44 82.85,88.79 v1(83.39,89.33)
  L2SGND w0.114: 77.49,82.96 76.07,82.96 71.76,78.65 71.76,59.74 78.88,52.61 78.88,47.48 v1(78.28,46.88)
  BOTTOM w0.089: CPU1.L28 v1(83.39,89.33)
  BOTTOM w0.216: DM1.191 79.83,49.26 79.53,48.96 79.53,47.82 78.59,46.88 v1(78.28,46.88)
M_A_DQ61: length 58.9
  L2SGND w0.089: v1(83.39,88.68) 83,88.29 83,87.37 82.52,86.88 82.52,85.72 80.97,84.18 80.78,84.18
  L2SGND w0.114: 80.78,84.18 80.13,84.18 78.66,82.7 76.26,82.7 76.19,82.64 73.16,79.61 73,79.44 73,79.37 72.1,78.47 72.1,59.88 72.34,59.64 72.51,59.64 72.69,59.82 72.85,59.82 73.01,59.66 73.01,59.5 72.83,59.31 72.83,59.15 72.99,58.99 73.15,58.99 73.34,59.17 73.5,59.17 73.66,59.01 73.66,58.85 73.48,58.67 73.48,58.5 73.64,58.34 73.8,58.34 73.98,58.53 74.15,58.53 74.31,58.37 74.31,58.2 74.12,58.02 74.12,57.86 74.28,57.7 74.45,57.7 74.63,57.88 74.79,57.88 74.95,57.72 74.95,57.56 74.77,57.37 74.77,57.21 79.23,52.75 v1(79.23,46.51)
  BOTTOM w0.089: CPU1.L29 v1(83.39,88.68)
  BOTTOM w0.216: v1(79.23,46.51) 79.3,46.51 79.58,46.23 DM1.190
M_A_DQ62: length 59.9
  L2SGND w0.089: 84.16,84.05 85.09,84.99 85.09,86.72 84.86,86.95 84.86,87.48 85.23,87.86 v1(85.23,87.95)
  L2SGND w0.114: 84.16,84.05 84.16,82.53 83.02,81.38 80.11,81.38 79.66,80.93 77.04,80.93 75.62,79.51 75.62,74.26 76.1,73.78 76.1,62.86 84.1,54.86 84.1,51.78 83.98,51.67 83.41,51.67 83.28,51.53 83.28,51.33 83.39,51.21 83.93,51.21 84.05,51.09 84.05,50.87 83.93,50.75 83.38,50.75 83.25,50.62 83.25,50.41 83.36,50.3 83.9,50.3 84.02,50.18 84.02,45.37 83.9,45.25 v1(83.49,45.25)
  BOTTOM w0.089: v1(85.23,87.95) 85.08,87.95 CPU1.N31
  BOTTOM w0.216: DM1.204 83.08,44.31 83.07,44.31 83.07,44.34 83,44.41 83,44.81 83.44,45.25 v1(83.49,45.25)
M_A_DQ63: length 61.4
  L2SGND w0.089: v1(84.66,86.42) 84.66,85.29 83.53,84.16
  L2SGND w0.114: 83.53,84.16 83.53,83.76 83.64,83.65 83.78,83.65 83.9,83.53 83.9,83.31 83.78,83.19 83.64,83.19 83.53,83.08 83.53,82.95 82.92,82.34 82.92,82.18 83.02,82.07 83.02,81.91 82.86,81.75 82.7,81.75 82.59,81.85 82.43,81.85 82.23,81.65 79.92,81.65 79.45,81.18 77.01,81.18 75.28,79.45 75.28,72.85 75.75,72.37 75.75,62.89 75.75,62.89 75.75,62.72 79.06,59.4 79.06,59.24 78.82,59 78.82,58.84 78.98,58.68 79.14,58.68 79.39,58.92 79.55,58.92 79.71,58.76 79.71,58.6 79.47,58.35 79.47,58.19 79.63,58.03 79.79,58.03 80.03,58.27 80.2,58.27 80.36,58.11 80.36,57.95 80.11,57.71 80.11,57.54 80.28,57.38 80.44,57.38 80.68,57.63 80.84,57.63 81,57.46 81,57.3 80.76,57.06 80.76,56.9 80.92,56.74 81.08,56.74 81.33,56.98 81.49,56.98 81.65,56.82 81.65,56.66 81.41,56.41 81.41,56.25 81.57,56.09 81.73,56.09 81.97,56.33 82.14,56.33 82.75,55.72 82.75,54.82 82.86,54.71 83.6,54.71 83.73,54.57 83.73,54.38 83.6,54.25 82.86,54.25 82.75,54.14 82.75,53.79 82.88,53.67 83.6,53.67 83.74,53.53 83.74,53.33 83.61,53.21 82.85,53.21 82.75,53.1 82.75,52.86 82.86,52.75 83.61,52.75 83.74,52.63 83.74,52.42 83.6,52.29 82.88,52.29 82.75,52.16 82.75,48.94 82.88,48.81 83.12,48.81 v1(83.32,49)
  BOTTOM w0.089: CPU1.N32 84.76,86.52 v1(84.66,86.42)
  BOTTOM w0.216: v1(83.32,49) 83.07,49 82.82,49.26 82.82,51.09 DM1.203
M_A_DQS_DN0: length 70.1
  L2SGND w0.127: v1(71.55,89.82) 71.8,89.57 71.8,89.32 71.53,89.05 66.97,89.05 63.73,85.81 63.73,61.45 55.24,52.96 54.49,52.96 53.38,51.85 53.38,51.09 52.36,50.08 51.6,50.08 50.18,48.65 50.18,46.24 50.02,46.08 49.35,46.08 v1(49.33,46.05)
  BOTTOM w0.076: 76.49,90.68 76.54,90.68 76.56,90.7 76.85,90.7 76.99,90.84 77.31,90.84 77.34,90.82 77.34,90.82 77.69,90.47 78.04,90.47 78.18,90.5 78.34,90.5 78.49,90.47 78.71,90.47 78.81,90.5 79.02,90.5 79.09,90.48 79.15,90.4 79.15,90.33 79.13,90.28 79.1,90.25 CPU1.C27
  BOTTOM w0.102: v1(71.55,89.82) 71.73,89.64 71.73,89.29 72,89.01 72.99,89.01 74.37,90.39 75.57,90.39 75.85,90.68 76.49,90.68
  BOTTOM w0.216: v1(49.33,46.05) 49.21,46.05 48.58,45.42 DM1.74
M_A_DQS_DN1: length 71.7
  L4 w0.089: v1(74.13,86.38) 74.59,85.92 74.59,85.74 74.44,85.58 74.21,85.58 73.87,85.24 73.69,85.24 73.58,85.13 73.51,85.13 73.49,85.11
  L4 w0.165: 73.49,85.11 73.26,84.88 73.26,84.87 72.82,84.43 72.82,84.04 69.02,80.24 65.03,80.24 47.73,62.95 47.73,62.5 47.9,62.34 47.9,62.11 47.54,61.76 47.31,61.76 47.15,61.92 46.71,61.92 46.21,61.42 46.21,60.98 46.38,60.8 46.38,60.6 41.1,55.32 38.12,55.32 33.48,50.67 33.48,48.06 33.35,47.94 33.09,47.94 v1(32.51,48.51)
  BOTTOM w0.076: 76.27,87.8 76.29,87.8 76.3,87.78 76.42,87.78 76.71,88.08 77.83,88.08 78.16,88.16 78.36,88.16 78.51,88.13 78.68,88.13 78.79,88.17 79.05,88.17 79.15,88.13 79.19,88.12 79.31,87.97 79.35,87.89 79.36,87.87 79.43,87.79 CPU1.D31
  BOTTOM w0.102: v1(74.13,86.38) 74.58,86.83 74.58,87.03 74.82,87.28 75.42,87.28 75.93,87.8 76.27,87.8
  BOTTOM w0.216: DM1.11 32.83,50.09 33.03,49.89 33.03,48.69 32.86,48.51 v1(32.51,48.51)
M_A_DQS_DN2: length 76
  L4 w0.089: v1(82.14,91.7) 81.56,91.12 80.35,91.12 78.98,89.75 78.98,84.34 78.98,84.34 78.98,84.19 75.53,80.74 75.53,79.87 75.57,79.83 75.57,79.76
  L4 w0.165: 75.57,79.76 75.57,79.5 70.02,73.95 67.6,73.95 50.73,57.08 50.73,53.9 48.34,51.51 45.16,51.51 44.3,50.65 42.57,50.65 42.24,50.32 40.29,50.32 39.01,49.04 39.01,48.2 38.7,47.89 38.55,47.89 38.39,47.73 38.39,47.23 38.55,47.06 38.7,47.06 39.01,46.75 39.01,45.67 38.34,45 v1(37.56,45)
  BOTTOM w0.076: CPU1.H24 v1(82.14,91.7)
  BOTTOM w0.165: v1(37.56,45) 37.84,45.28 37.96,45.28 38.13,45.12 38.13,43.9 38.08,43.85 DM1.32
M_A_DQS_DN3: length 76.2
  TOP w0.127: v2(76.26,92.46) v1(75.72,93.04)
  L2SGND w0.127: v1(42.95,49) 43.39,48.56 43.57,48.56 43.72,48.71 43.72,50.23 44.97,51.48 45.75,51.48 46.69,52.42 46.69,52.6 46.4,52.88 46.4,53.25 46.92,53.77 47.29,53.77 47.6,53.46 47.78,53.46 48.15,53.83 48.15,54.01 47.84,54.32 47.84,54.69 48.35,55.2 48.72,55.2 48.87,55.06 49.04,55.06 49.42,55.44 49.42,55.62 49.28,55.76 49.28,56.13 59.34,66.19 59.34,86.93 66.29,93.87 74.67,93.87 75.5,93.04 v1(75.72,93.04)
  BOTTOM w0.076: v1(75.72,93.04) 75.47,93.04 75.31,92.89 75.31,92.65 75.42,92.55 78.04,92.55 78.18,92.51 78.34,92.51 78.49,92.55 78.71,92.55 78.81,92.51 79.02,92.51 79.09,92.54 79.15,92.61 79.15,92.68 79.13,92.73 79.1,92.77 CPU1.C23
  BOTTOM w0.216: DM1.53 43.33,50.13 43.51,49.95 43.51,49.31 43.21,49 v1(42.95,49)
M_A_DQS_DN4: length 49.6
  L2SGND w0.127: v1(79.58,80.03) 79.38,79.83 78.57,79.83 78.04,79.31 78.04,75.01 78.35,74.7 78.35,63.74 88.13,53.96 88.13,52.9 88.01,52.77 87.94,52.77 87.68,52.51 87.68,51.79 87.94,51.52 88.01,51.52 88.13,51.4 88.13,50.76 88.01,50.64 87.21,50.64 86.95,50.37 86.95,49.28 87.57,48.66 v1(87.57,48.34)
  BOTTOM w0.076: 81.52,82.38 81.52,82.38 81.54,82.38 81.82,82.66 82.53,82.66 82.81,82.94 82.81,83.97 82.85,84.07 82.86,84.12 82.89,84.24 82.89,84.39 82.85,84.53 82.85,84.74 82.89,84.88 82.89,85.06 82.85,85.16 82.77,85.22 82.71,85.22 82.63,85.14 CPU1.J35
  BOTTOM w0.102: v1(79.58,80.03) 79.58,80.4 79.44,80.53 79.44,80.85 80.2,81.6 80.74,81.6 81.52,82.38
  BOTTOM w0.216: DM1.219 86.83,50.08 86.78,50.03 86.78,49.13 v1(87.57,48.34)
M_A_DQS_DN5: length 52.1
  L2SGND w0.127: v1(81.82,77.36) 82.01,77.55 82.38,77.55 82.49,77.43 82.49,76.42 82.38,76.31 82.38,65.73 93.37,54.74 93.37,47.93 93.76,47.54 93.76,45.78 93.63,45.65 93.14,45.65 v1(93.09,45.7)
  BOTTOM w0.076: CPU1.P34 85.15,85.52 85.28,85.39 85.34,85.36 85.34,85.36 85.42,85.32 85.51,85.23 85.54,85.21 85.58,85.09 85.58,84.83 85.55,84.73 85.55,84.54 85.58,84.44 85.58,84.18 85.55,84.08 85.55,83.55 85.7,83.39 85.7,82.82 85.58,82.7
  BOTTOM w0.102: 82.86,77.67 82.98,77.79 82.98,80.1 85.58,82.7
  BOTTOM w0.216: v1(93.09,45.7) 92.57,45.7 92.04,45.17 92.04,43.88 92.08,43.85 DM1.240 ; v1(81.82,77.36) 82.03,77.57 82.76,77.57 82.86,77.67
M_A_DQS_DN6: length 61.3
  L2SGND w0.089: v1(80.63,88.04) 81.01,88.04 81.04,88.02 81.05,87.99 81.04,87.95 80.97,87.72 80.87,87.64 79.93,87.64 79.09,86.8 79.09,86.23 77.23,84.37 74.34,84.37 74.31,84.34
  L2SGND w0.127: v1(75.47,48.93) 75.47,48.52 75.59,48.39 75.9,48.39 76.23,48.72 76.23,49.77 75.85,50.14 75.36,50.14 68.56,56.95 68.56,62.1 68.82,62.36 69.36,62.36 69.43,62.43 69.43,63.06 69.34,63.15 68.82,63.15 68.56,63.41 68.56,64.13 68.82,64.39 69.36,64.39 69.43,64.47 69.43,65.1 69.35,65.18 68.82,65.18 68.56,65.44 68.56,66.16 68.82,66.43 69.3,66.43 69.43,66.55 69.43,67.09 69.3,67.21 68.82,67.21 68.56,67.47 68.56,68.2 68.82,68.46 69.3,68.46 69.43,68.58 69.43,69.12 69.3,69.24 68.82,69.24 68.56,69.51 68.56,78.75 74.14,84.34 74.31,84.34
  BOTTOM w0.089: v1(80.63,88.04) 80.75,87.92 81.04,87.92 81.11,87.99 CPU1.G30
  BOTTOM w0.216: DM1.177 76.33,50.2 76.48,50.05 76.48,49.41 75.79,48.72 75.68,48.72 v1(75.47,48.93)
M_A_DQS_DN7: length 59.6
  L2SGND w0.089: 76.17,81.74 76.18,81.75 76.19,81.75 76.2,81.74 76.24,81.79 76.25,81.79 76.5,82.04 79.02,82.04 79.45,82.47 79.48,82.47 80.23,82.47 80.23,82.48 80.73,82.48 81.68,83.43 83.16,84.91 83.16,85.96 83.33,86.13 83.34,86.13 83.57,86.37 83.57,86.83 83.84,87.1 83.84,87.57 83.47,87.95 83.46,87.95 v1(83.45,87.95)
  L2SGND w0.127: 76.17,81.74 74.01,79.58 74.01,78.52 73.42,77.92 73.42,71.58 73.68,71.32 74.05,71.32 74.17,71.19 74.17,70.66 74.05,70.53 73.68,70.53 73.42,70.27 73.42,69.55 73.68,69.29 74.05,69.29 74.17,69.16 74.17,68.63 74.05,68.5 73.68,68.5 73.42,68.24 73.42,67.52 73.68,67.25 73.99,67.25 74.15,67.09 74.15,66.61 74.01,66.47 73.68,66.47 73.42,66.21 73.42,62.06 81.21,54.27 81.21,48.27 80.5,47.56 80.5,46.87 v1(81.02,46.35)
  BOTTOM w0.089: CPU1.L30 83.5,88.09 83.46,87.97 83.46,87.96 v1(83.45,87.95)
  BOTTOM w0.216: DM1.198 81.58,46.19 81.42,46.35 v1(81.02,46.35)
M_A_DQS_DP0: length 70.7
  TOP w0.127: v2(49.09,45.09) v1(49.6,45.41)
  L2SGND w0.127: v1(72.29,89.82) 72.03,89.55 72.03,89.23 71.62,88.83 67.07,88.83 63.96,85.72 63.96,61.35 55.34,52.73 54.58,52.73 53.6,51.75 53.6,51 52.46,49.85 51.7,49.85 50.41,48.56 50.41,46.15 49.67,45.41 v1(49.6,45.41)
  BOTTOM w0.076: CPU1.D27 79.43,90.31 79.36,90.39 79.35,90.41 79.31,90.49 79.19,90.63 79.15,90.65 79.05,90.68 78.79,90.68 78.68,90.65 78.51,90.65 78.36,90.68 78.16,90.68 78.02,90.64 77.76,90.64 77.42,90.99 77.41,90.99 77.39,91.02 76.91,91.02 76.77,90.88 76.51,90.88 76.51,90.88 76.49,90.88
  BOTTOM w0.102: 76.49,90.88 75.77,90.88 75.49,90.6 74.28,90.6 72.9,89.21 72.09,89.21 71.93,89.37 71.93,89.65 72.1,89.82 v1(72.29,89.82)
  BOTTOM w0.216: v1(49.6,45.41) 49.05,45.41 48.92,45.28 48.92,43.94 49.08,43.79 DM1.76
M_A_DQS_DP1: length 71.6
  L4 w0.089: v1(74.78,86.39) 74.78,85.66 74.52,85.39 74.29,85.39 73.95,85.05 73.77,85.05 73.7,84.98 73.7,84.94 73.68,84.92
  L4 w0.165: 73.68,84.92 73.08,84.32 73.08,83.93 69.13,79.98 65.13,79.98 47.99,62.84 47.99,62.61 48.15,62.45 48.15,62 47.65,61.5 47.21,61.5 47.04,61.66 46.81,61.66 46.46,61.31 46.46,61.08 46.64,60.9 46.64,60.49 41.21,55.06 38.23,55.06 33.73,50.57 33.73,47.96 33.46,47.68 v1(32.51,47.68)
  BOTTOM w0.076: CPU1.C31 79.1,87.73 79.13,87.76 79.15,87.82 79.15,87.88 79.09,87.96 79.08,87.96 79.02,87.99 78.81,87.99 78.71,87.95 78.49,87.95 78.34,87.99 78.18,87.99 77.85,87.9 76.79,87.9 76.49,87.6 76.3,87.6 76.29,87.59 76.27,87.59
  BOTTOM w0.102: v1(74.78,86.39) 74.78,86.95 74.91,87.08 75.5,87.08 76.02,87.59 76.27,87.59
  BOTTOM w0.216: DM1.13 33.33,50.08 33.37,50.03 33.37,48.55 v1(32.51,47.68)
M_A_DQS_DP2: length 76
  L4 w0.089: v1(81.5,91.7) 81.5,91.41 81.4,91.31 80.27,91.31 78.79,89.83 78.79,84.34 78.79,84.34 78.79,84.26 75.34,80.81 75.34,79.86 75.31,79.83
  L4 w0.165: v1(37.57,45.78) 38.08,45.27 38.25,45.27 38.76,45.78 38.76,46.65 38.59,46.81 38.45,46.81 38.13,47.12 38.13,47.83 38.45,48.14 38.59,48.14 38.76,48.31 38.76,49.15 40.18,50.57 42.14,50.57 42.47,50.9 44.19,50.9 45.06,51.77 48.23,51.77 50.47,54.01 50.47,57.18 67.49,74.2 69.91,74.2 75.31,79.6 75.31,79.83
  BOTTOM w0.089: CPU1.G24 81.5,91.8 v1(81.5,91.7)
  BOTTOM w0.165: v1(37.57,45.78) 37.8,45.55 38.07,45.55 38.4,45.23 38.4,44.01 38.58,43.83 DM1.34
M_A_DQS_DP3: length 76
  TOP w0.127: v2(75,92.42) v1(74.94,93.01)
  L2SGND w0.127: v1(42.98,48.29) 43.63,48.29 43.95,48.61 43.95,50.14 45.06,51.25 45.84,51.25 46.92,52.33 46.92,52.69 46.63,52.98 46.63,53.16 47.01,53.54 47.19,53.54 47.5,53.23 47.87,53.23 48.38,53.74 48.38,54.11 48.07,54.42 48.07,54.6 48.45,54.97 48.63,54.97 48.77,54.83 49.14,54.83 49.65,55.34 49.65,55.71 49.51,55.86 49.51,56.03 59.57,66.1 59.57,86.83 66.38,93.64 74.58,93.64 74.94,93.28 v1(74.94,93.01)
  BOTTOM w0.076: v1(74.94,93.01) 74.94,92.78 75.35,92.37 78.02,92.37 78.16,92.33 78.36,92.33 78.51,92.37 78.68,92.37 78.79,92.33 79.05,92.33 79.15,92.37 79.19,92.38 79.31,92.52 79.35,92.61 79.36,92.63 79.43,92.7 CPU1.D23
  BOTTOM w0.216: v1(42.98,48.29) 43.85,49.16 43.85,50.22 43.83,50.24 DM1.55
M_A_DQS_DP4: length 49.7
  L2SGND w0.127: v1(80.09,80.55) 80.09,79.94 79.76,79.6 78.67,79.6 78.27,79.21 78.27,75.1 78.58,74.8 78.58,63.84 88.36,54.05 88.36,52.8 88.1,52.54 88.04,52.54 87.91,52.41 87.91,51.88 88.04,51.75 88.1,51.75 88.36,51.49 88.36,50.67 88.1,50.41 87.3,50.41 87.18,50.28 87.18,49.38 87.53,49.02 87.84,49.02 87.84,49.02 v1(87.84,49.02)
  BOTTOM w0.076: CPU1.J34 82.63,85.44 82.68,85.4 82.83,85.4 83,85.28 83.07,85.09 83.07,84.86 83.03,84.72 83.03,84.55 83.07,84.44 83.07,84.19 83.04,84.09 83.02,83.98 82.99,83.93 82.99,82.86 82.61,82.48 81.89,82.48 81.67,82.26 81.67,82.24 81.66,82.23
  BOTTOM w0.102: 81.66,82.23 80.82,81.39 80.28,81.39 79.65,80.76 79.65,80.62 79.72,80.55 v1(80.09,80.55)
  BOTTOM w0.216: DM1.221 87.33,50.09 87.12,49.89 87.12,49.27 87.49,48.91 87.72,48.91 87.84,49.02 v1(87.84,49.02)
M_A_DQS_DP5: length 52
  L2SGND w0.127: v1(81.8,78) 82.02,77.78 82.47,77.78 82.72,77.53 82.72,76.32 82.61,76.21 82.61,65.82 93.6,54.84 93.6,48.03 93.99,47.63 93.99,45.69 93.73,45.43 93.45,45.43 93.3,45.28 93.3,45.1 93.18,44.97 v1(92.97,44.97)
  BOTTOM w0.076: CPU1.P35 85.15,85.1 85.21,85.19 85.25,85.2 85.26,85.2 85.32,85.17 85.39,85.11 85.4,85.06 85.4,84.86 85.37,84.76 85.37,84.51 85.4,84.41 85.4,84.21 85.37,84.12 85.37,83.47 85.52,83.32 85.52,82.93 85.44,82.84
  BOTTOM w0.102: 85.44,82.84 82.78,80.18 82.78,80.01 82.78,78.08 82.72,78.01
  BOTTOM w0.216: v1(81.8,78) 82.03,78 82.11,77.92 82.62,77.92 82.72,78.01 ; v1(92.97,44.97) 92.97,45.14 92.85,45.25 92.6,45.25 92.38,45.03 92.38,44.03 92.58,43.83 DM1.242
M_A_DQS_DP6: length 61.3
  L2SGND w0.089: v1(81.57,87.99) 81.36,88.05 81.25,87.99 81.22,87.89 81.19,87.78 81.14,87.61 80.93,87.45 80.01,87.45 79.28,86.72 79.28,86.15 77.31,84.18 74.44,84.18 74.39,84.13 74.34,84.13 74.32,84.11 74.31,84.11
  L2SGND w0.127: v1(75.52,47.96) 75.52,47.96 75.78,47.96 76.46,48.63 76.46,49.86 75.95,50.37 75.46,50.37 68.78,57.04 68.78,62.01 68.91,62.13 69.45,62.13 69.66,62.34 69.66,63.16 69.44,63.38 68.91,63.38 68.78,63.5 68.78,64.04 68.91,64.16 69.45,64.16 69.66,64.37 69.66,65.2 69.44,65.41 68.91,65.41 68.78,65.54 68.78,66.07 68.91,66.2 69.4,66.2 69.66,66.46 69.66,67.18 69.4,67.44 68.91,67.44 68.78,67.57 68.78,68.1 68.91,68.23 69.4,68.23 69.66,68.49 69.66,69.21 69.4,69.47 68.91,69.47 68.78,69.6 68.78,78.66 74.24,84.11 74.31,84.11
  BOTTOM w0.089: CPU1.H30 v1(81.57,87.99)
  BOTTOM w0.216: DM1.179 76.83,50.19 76.83,49.27 75.52,47.96 v1(75.52,47.96)
M_A_DQS_DP7: length 59.6
  L2SGND w0.089: 76.33,81.58 76.33,81.61 76.58,81.85 79.1,81.85 79.53,82.28 79.56,82.28 80.31,82.28 80.81,82.28 81.87,83.35 83.35,84.83 83.35,85.88 83.41,85.94 83.42,85.94 83.76,86.29 83.76,86.76 84.03,87.02 84.03,87.75 v1(84.25,87.97)
  L2SGND w0.127: v1(81.03,46.98) 80.73,47.28 80.73,47.46 81.44,48.17 81.44,54.36 73.64,62.15 73.64,66.11 73.77,66.24 74.1,66.24 74.38,66.52 74.38,67.18 74.08,67.48 73.77,67.48 73.64,67.61 73.64,68.14 73.77,68.27 74.14,68.27 74.4,68.53 74.4,69.25 74.14,69.52 73.77,69.52 73.64,69.64 73.64,70.18 73.77,70.3 74.14,70.3 74.4,70.56 74.4,71.29 74.14,71.55 73.77,71.55 73.64,71.67 73.64,77.83 74.11,78.29 74.24,78.43 74.24,79.49 76.33,81.58
  BOTTOM w0.089: CPU1.N30 84.25,88 v1(84.25,87.97)
  BOTTOM w0.216: DM1.200 82.08,43.87 81.92,44.03 81.92,46.34 81.27,46.98 v1(81.03,46.98)
M_A_PARITY: length 57
  L4 w0.089: 89.11,73.05 90.85,74.79 90.85,82.15 86.49,86.5 86.49,87.01 86.53,87.05 86.53,87.4 87.15,88.02 v1(87.96,88.02)
  L4 w0.203: 89.11,73.05 89.07,73.05 87.7,71.68 87.7,71.03 87.91,70.82 88.03,70.82 88.24,70.62 88.24,70.21 88.03,70.01 87.91,70.01 87.7,69.81 87.7,69.27 78.18,59.75 74.61,59.75 66.9,52.04 v1(66.9,49.79)
  BOTTOM w0.089: v1(87.96,88.02) 88.02,88.02 CPU1.W31
  BOTTOM w0.216: v1(66.9,49.79) 67.18,50.07 67.18,50.84 66.91,51.1 DM1.143
M_B_A0: length 87.7
  L2SGND w0.089: v1(93.92,80.01) 94.49,79.45 94.49,76.91
  L2SGND w0.114: 94.49,76.91 94.49,71.71 94.11,71.33 94.11,69.84 100.99,62.97 101.53,62.97 105.71,58.8 137.25,58.8 144.28,51.76 144.28,51.42 144.17,51.31 144.03,51.31 143.92,51.19 143.92,50.96 144.03,50.85 144.17,50.85 144.28,50.74 144.28,50.51 144.17,50.39 144.03,50.39 143.92,50.28 143.92,50.05 144.03,49.94 144.11,49.94 144.22,49.82 144.22,49.48 144.11,49.36 144.03,49.36 143.92,49.25 143.92,49.02 144.03,48.91 144.17,48.91 144.28,48.79 144.28,48.41 144.44,48.25 144.44,46.7 144.83,46.31 144.83,45.91 144.71,45.79 144.44,45.79 144.3,45.65 144.3,45.46 144.43,45.33 144.7,45.33 144.83,45.2 144.83,44.96 144.7,44.83 144.01,44.83 143.86,44.98 143.86,45.32 143.73,45.44 143.42,45.44 143.29,45.32 143.29,44.45 v1(143.39,44.35)
  BOTTOM w0.076: CPU1.AG36 93.35,84.58 93.58,84.15 93.61,84.12 93.61,83.84 93.42,83.63 93.37,83.59 93.37,82.92 93.39,82.88 93.39,82.84 93.41,82.81 93.42,82.69 93.45,81.35 93.45,80.48 v1(93.92,80.01)
  BOTTOM w0.216: DM2.144 142.28,43.9 142.55,44.17 143.21,44.17 v1(143.39,44.35)
M_B_A1: length 89.3
  L2SGND w0.089: v1(92.54,79) 92.94,78.6 92.94,77.9 92.51,77.47
  L2SGND w0.114: v1(140.21,49.03) 140.67,49.49 140.67,50.21 140.81,50.35 141.81,50.35 141.9,50.44 141.9,50.72 141.81,50.81 140.78,50.81 140.67,50.92 140.67,51.12 140.81,51.26 141.84,51.26 141.9,51.32 141.9,51.67 141.85,51.72 140.78,51.72 140.67,51.83 140.67,52.95 140.25,53.37 139.73,53.37 139.62,53.49 139.62,54 139.44,54.18 139.28,54.18 138.3,53.21 138.14,53.21 137.98,53.37 137.98,53.53 138.95,54.51 138.95,54.67 138.79,54.83 138.63,54.83 137.55,53.75 137.41,53.75 137.23,53.93 137.23,54.08 138.31,55.15 138.31,55.31 136.54,57.08 104.98,57.08 100.8,61.25 100.28,61.25 100.2,61.33 100.2,61.33 92.18,69.35 92.18,75.87 92.51,76.2 92.51,77.47
  BOTTOM w0.076: v1(92.54,79) 92.93,79.59 93.07,80.66 93.07,82.54 93.06,82.8 93.04,82.84 93.04,83.72 93.06,83.74 93.12,84.23 93.13,84.43 93.1,84.52 93.1,84.75 93.13,84.84 93.13,84.85 93.26,85.19 CPU1.AG35
  BOTTOM w0.216: v1(140.21,49.03) 140.1,49.03 139.7,49.44 139.58,49.87 139.58,50.01 139.53,50.06 DM2.133
M_B_A2: length 89.9
  L2SGND w0.089: 93.12,77.15 93.12,79.12 v1(92.54,79.71)
  L2SGND w0.114: v1(140.16,45.98) 140.16,45.85 140.31,45.7 140.37,45.7 140.74,45.33 140.74,44.55 141.05,44.25 142.04,44.25 142.24,44.46 142.24,46.53 141.7,47.07 141.17,47.07 140.97,47.28 140.97,47.63 141.14,47.8 141.38,47.8 141.38,47.81 141.97,47.81 142.27,48.1 142.27,48.57 142.25,48.59 142.25,48.6 142.24,48.6 142.24,51.86 136.68,57.42 105.12,57.42 100.95,61.6 100.42,61.6 100.34,61.67 92.61,69.4 92.61,76.01 93.12,76.52 93.12,77.15
  BOTTOM w0.076: CPU1.AF34 92.96,85.06 92.96,84.89 92.94,84.79 92.93,84.78 92.93,84.49 92.94,84.48 92.96,84.38 92.96,84.25 92.96,84.24 92.89,83.8 92.88,83.79 92.88,82.8 92.89,82.77 92.9,82.38 92.9,82.34 92.87,80.38 92.61,79.71 v1(92.54,79.71)
  BOTTOM w0.216: v1(140.16,45.98) 139.28,45.1 139.28,44.26 139.28,44.26 DM2.132
M_B_A3: length 89
  L2SGND w0.114: v1(93.93,78.69) 94.14,78.49 94.14,75.94 94.02,75.83 93.87,75.83 93.75,75.71 93.75,75.51 93.87,75.4 94.1,75.4 94.21,75.28 94.21,75.05 94.1,74.94 93.87,74.94 93.75,74.82 93.75,74.6 93.87,74.48 94.1,74.48 94.21,74.37 94.21,74.14 94.1,74.02 93.87,74.02 93.75,73.91 93.75,73.68 93.87,73.57 94.1,73.57 94.21,73.45 94.21,73.22 94.1,73.11 93.88,73.11 93.77,73 93.77,69.7 100.84,62.62 101.39,62.62 105.56,58.45 137.11,58.45 143.58,51.98 143.58,48.63 144.1,48.11 144.1,45.92 143.97,45.8 143.45,45.8 143.29,45.95 143.29,46.39 143.29,47.1 v1(143.07,47.32)
  BOTTOM w0.076: CPU1.AG37 93.23,83.68 93.21,83.65 93.21,82.88 93.23,82.84 93.23,82.79 93.25,82.75 93.26,82.68 93.26,81.31 93.29,81.28 93.29,80.42 93.31,80.4 93.43,80.05 93.43,79.12 93.86,78.69 v1(93.93,78.69)
  BOTTOM w0.216: v1(143.07,47.32) 141.08,47.65 140.89,47.72 140.75,47.78 139.33,49.21 139.03,50.27 DM2.131
M_B_A4: length 88.6
  L2SGND w0.089: 93.32,77.33 93.32,79.5 92.86,79.97 92.86,80.54 92.73,80.81 v1(92.48,81.05)
  L2SGND w0.114: v1(138.76,45.25) 138.77,45.25 138.84,45.25 140.06,44.03 140.52,43.91 142.18,43.91 142.59,44.31 142.59,46.7 142.29,46.99 142.29,47.64 142.61,47.96 142.61,48.71 142.59,48.73 142.59,48.74 142.59,48.74 142.59,52 136.82,57.77 105.26,57.77 101.09,61.94 100.56,61.94 93.08,69.42 93.08,69.7 93.08,76.06 93.32,76.3 93.32,77.33
  BOTTOM w0.076: CPU1.AE35 92.31,85.03 92.31,84.54 92.27,84.43 92.27,84.19 92.33,84.04 92.33,83.01 92.32,83 92.32,83 91.91,82.59 91.91,81.67 92.48,81.1 v1(92.48,81.05)
  BOTTOM w0.216: DM2.128 138.28,44.39 138.26,44.4 138.26,44.83 138.68,45.25 138.76,45.25 v1(138.76,45.25)
M_B_A5: length 89
  L2SGND w0.089: 93.55,78.19 93.5,78.54 93.5,79.73 93.46,79.91 93.36,80.25 93.18,80.69 93,81.07 92.81,81.33 v1(92.43,81.71)
  L2SGND w0.114: v1(137.78,44.97) 138.36,44.38 138.62,44.16 138.98,43.99 139.11,43.94 139.81,43.71 140.36,43.56 142.32,43.56 142.93,44.17 142.93,46.84 142.64,47.14 142.64,47.5 142.96,47.82 142.96,48.85 142.94,48.87 142.94,48.88 142.93,48.89 142.93,52.15 136.96,58.11 105.42,58.11 101.25,62.28 100.7,62.28 93.42,69.56 93.42,76.02 93.55,76.15 93.55,78.19
  BOTTOM w0.076: CPU1.AF35 92.6,84.86 92.44,84.4 92.44,84.22 92.5,84.05 92.5,82.95 92.49,82.95 92.49,82.94 92.48,82.93 92.48,82.93 92.08,82.52 92.08,82.16 92.43,81.81 v1(92.43,81.71)
  BOTTOM w0.216: v1(137.78,44.97) DM2.126
M_B_A6: length 89
  L2SGND w0.114: v1(138.84,48.97) 139.11,49.24 139.11,50.6 133.65,56.05 121.21,56.05 121.1,55.94 121.1,55.62 120.98,55.51 120.75,55.51 120.64,55.62 120.64,55.94 120.52,56.05 120.3,56.05 120.18,55.94 120.18,55.62 120.07,55.51 119.84,55.51 119.72,55.62 119.72,55.94 119.61,56.05 119.38,56.05 119.27,55.94 119.27,55.62 119.15,55.51 118.92,55.51 118.81,55.62 118.81,55.94 118.7,56.05 118.47,56.05 118.35,55.94 118.35,55.62 118.24,55.51 118.01,55.51 117.9,55.62 117.9,55.94 117.78,56.05 117.55,56.05 117.44,55.94 117.44,55.62 117.32,55.51 117.1,55.51 116.98,55.62 116.98,55.94 116.87,56.05 116.64,56.05 116.52,55.94 116.52,55.62 116.41,55.51 116.18,55.51 116.07,55.62 116.07,55.94 115.95,56.05 115.72,56.05 115.61,55.94 115.61,55.62 115.5,55.51 115.27,55.51 115.15,55.62 115.15,55.94 115.04,56.05 114.81,56.05 114.7,55.94 114.7,55.62 114.58,55.51 114.35,55.51 114.24,55.62 114.24,55.94 114.12,56.05 113.9,56.05 113.78,55.94 113.78,55.62 113.67,55.51 113.44,55.51 113.32,55.62 113.32,55.94 113.21,56.05 112.98,56.05 112.87,55.94 112.87,55.62 112.75,55.51 112.52,55.51 112.41,55.62 112.41,55.94 112.29,56.05 112.04,56.05 111.92,55.94 111.92,55.63 111.8,55.51 111.49,55.51 111.38,55.62 111.38,55.94 111.27,56.05 111.04,56.05 110.92,55.94 110.92,55.62 110.81,55.51 110.58,55.51 110.47,55.62 110.47,55.94 110.35,56.05 110.12,56.05 110.01,55.94 110.01,55.62 109.89,55.51 109.67,55.51 109.55,55.62 109.55,55.94 109.44,56.05 109.09,56.05 108.98,55.94 108.98,55.62 108.87,55.51 108.64,55.51 108.52,55.62 108.52,55.94 108.41,56.05 108.18,56.05 108.07,55.94 108.07,55.62 107.95,55.51 107.61,55.51 107.49,55.62 107.49,55.83 107.37,55.96 107.16,55.96 107.04,55.83 107.04,55.62 106.92,55.51 104.72,55.51 104.35,55.88 104.35,56.24 100.38,60.21 99.86,60.21 91.1,68.97 91.1,75.65 91.9,76.45 91.9,77.09 v1(91.5,77.49)
  BOTTOM w0.076: v1(91.5,77.49) 92.06,78.05 92.06,81.28 91.75,81.6 91.75,82.66 92.15,83.06 92.15,83.88 CPU1.AE37
  BOTTOM w0.216: DM2.127 138.03,49.53 138.59,48.97 v1(138.84,48.97)
M_B_A7: length 88.4
  L2SGND w0.089: v1(90.68,88.67) 91.1,88.25 91.1,86.36 90.05,85.31
  L2SGND w0.114: v1(136.78,44.34) 137.42,44.34 137.52,44.24 137.52,43.77 137.42,43.68 136.16,43.68 135.98,43.86 135.98,47.53 135.71,47.8 135.41,47.8 135.12,48.09 135.12,49.65 132.3,52.47 103.29,52.47 87.76,68 87.76,74.56 87.67,74.65 87.67,80.68 88.36,81.38 88.36,83.63 90.05,85.31
  BOTTOM w0.14: CPU1.AC29 v1(90.68,88.67)
  BOTTOM w0.216: v1(136.78,44.34) DM2.122
M_B_A8: length 88
  L2SGND w0.114: v1(91.35,78.17) 91.4,78.17 92.1,77.47 92.1,76.36 91.44,75.71 91.44,69.11 100,60.55 100.52,60.55 104.79,56.28 104.79,55.99 104.91,55.88 105.14,55.88 105.25,55.99 105.25,56.28 105.37,56.4 105.59,56.4 105.71,56.28 105.71,55.99 105.82,55.88 106.05,55.88 106.17,55.99 106.17,56.28 106.28,56.4 133.51,56.4 133.8,56.4 137.67,52.52 138.22,52.52 138.33,52.41 138.33,52.06 138.44,51.94 138.66,51.94 138.79,52.06 138.79,52.41 138.89,52.52 139.14,52.52 139.54,52.12 140.19,52.12 140.31,52 140.31,51.8 140.2,51.68 139.08,51.68 138.96,51.56 138.96,51.34 139.08,51.23 140.19,51.23 140.31,51.1 140.31,50.88 140.2,50.77 139.56,50.77 139.45,50.65 139.45,50.31 139.56,50.2 139.66,50.2 139.77,50.08 139.77,49.85 139.66,49.74 139.56,49.74 139.45,49.63 139.45,49.4 139.56,49.28 139.66,49.28 139.77,49.17 139.77,48.94 139.66,48.83 139.57,48.83 v1(138.97,48.22)
  BOTTOM w0.076: CPU1.AE36 92.05,84.58 91.91,84.32 91.91,84.31 91.8,84.11 91.8,83.82 91.99,83.63 91.99,83.13 91.58,82.73 91.58,81.53 91.71,81.4 91.71,78.53 v1(91.35,78.17)
  BOTTOM w0.216: DM2.125 137.53,48.06 137.87,47.72 138.84,47.72 138.97,47.85 v1(138.97,48.22)
M_B_A9: length 85
  L2SGND w0.114: v1(89.76,89.29) 90.12,88.93 90.22,88.7 90.22,86.62 90.2,86.5 89.74,85.57 88.04,83.87 88.04,81.56 87.35,80.87 87.35,73.97 87.42,73.89 87.42,67.86 103.14,52.13 132.16,52.13 134.47,49.82 134.56,49.53 134.7,48.52 134.75,48.15 134.76,48.04 134.88,47.81 135.14,47.54 v1(135.54,47.35)
  BOTTOM w0.089: CPU1.AB29 89.87,89.29 v1(89.76,89.29)
  BOTTOM w0.216: DM2.121 136.53,48.16 135.72,47.35 v1(135.54,47.35)
M_B_A10: length 89.5
  L2SGND w0.089: v1(93.86,82.71) 93.97,82.6 94.21,82.33 94.84,81.29 94.84,80.66 94.85,80.66 94.85,80.64 94.85,80.57 94.91,77.38 94.91,77.28 94.92,77.26
  L2SGND w0.114: v1(145.27,47.1) 145.61,47.1 145.72,47.21 145.72,47.88 145.13,48.48 145.13,48.54 144.97,48.69 144.97,48.98 144.97,48.98 144.97,52.05 141.35,55.67 141.35,55.83 141.96,56.44 141.96,56.6 141.77,56.8 141.61,56.8 140.99,56.18 140.83,56.18 140.67,56.35 140.67,56.51 141.28,57.12 141.28,57.28 141.12,57.44 140.96,57.44 140.35,56.83 140.19,56.83 140.02,56.99 140.02,57.15 140.64,57.77 140.64,57.93 139.35,59.22 138.64,59.22 138.37,59.48 105.99,59.48 101.82,63.65 101.27,63.65 94.8,70.13 94.8,71.19 94.92,71.32 94.92,77.26
  BOTTOM w0.076: CPU1.AG34 93.65,85.31 93.65,84.37 93.7,84.28 93.77,84.19 93.77,83.77 93.73,83.72 93.54,83.51 93.54,83.08 93.86,82.73 v1(93.86,82.71)
  BOTTOM w0.216: v1(145.27,47.1) 144.78,46.61 DM2.146
M_B_A11: length 88.6
  L2SGND w0.089: 90.33,83.97 91.82,85.46 91.82,85.99 91.6,86.21 91.6,89.17 91.54,89.23 v1(91.54,89.25)
  L2SGND w0.114: 90.33,83.97 90.33,83.49 89.37,82.54 89.37,81.4 89.22,81.25 89.22,81.09 89.58,80.73 89.58,80.56 89.42,80.4 89.26,80.4 88.91,80.75 88.73,80.75 88.11,80.14 88.11,75.01 88.73,74.39 88.73,68 103.57,53.16 133.21,53.16 136.38,49.99 136.38,46.81 136.5,46.68 137.05,46.68 137.49,46.24 137.49,45.96 137.13,45.61 v1(136.78,45.61)
  BOTTOM w0.14: CPU1.AC28 91.19,89.58 91.52,89.25 v1(91.54,89.25)
  BOTTOM w0.216: v1(136.78,45.61) 136.7,45.61 136.27,45.17 136.27,44.21 136.28,44.2 DM2.120
M_B_A12: length 87.4
  L2SGND w0.089: v1(89.81,89.92) 90,89.92 91.28,88.64 91.28,86.27 90.12,85.12 90.12,83.91 89.29,83.08
  L2SGND w0.114: 89.29,83.08 88.77,82.56 88.77,81.27 87.87,80.38 87.87,74.74 88.11,74.5 88.11,73.74 88.22,73.62 88.27,73.62 88.39,73.51 88.39,73.28 88.27,73.17 88.22,73.17 88.11,73.05 88.11,72.82 88.22,72.71 88.27,72.71 88.39,72.59 88.39,72.37 88.27,72.25 88.22,72.25 88.11,72.14 88.11,71.91 88.22,71.79 88.27,71.79 88.39,71.68 88.39,71.45 88.27,71.34 88.22,71.34 88.11,71.22 88.11,70.99 88.22,70.88 88.27,70.88 88.39,70.76 88.39,70.54 88.27,70.42 88.22,70.42 88.11,70.31 88.11,70.08 88.22,69.96 88.27,69.96 88.39,69.85 88.39,69.62 88.27,69.51 88.22,69.51 88.11,69.39 88.11,69.16 88.22,69.05 88.27,69.05 88.39,68.94 88.39,68.71 88.27,68.59 88.22,68.59 88.11,68.48 88.11,68.14 103.43,52.81 133.07,52.81 133.64,52.24 133.64,52.08 133.49,51.93 133.49,51.77 133.65,51.61 133.81,51.61 133.96,51.76 134.12,51.76 134.28,51.6 134.28,51.43 134.13,51.28 134.13,51.12 134.3,50.96 134.46,50.96 134.61,51.11 134.77,51.11 134.93,50.95 134.93,50.79 134.78,50.64 134.78,50.48 134.94,50.31 135.1,50.31 135.25,50.46 135.42,50.46 136.03,49.85 136.03,49.03 135.91,48.9 v1(135.57,48.9)
  BOTTOM w0.089: CPU1.AB28 89.89,89.92 v1(89.81,89.92)
  BOTTOM w0.216: DM2.119 136.03,50.28 136.08,50.22 136.08,49.41 v1(135.57,48.9)
M_B_A13: length 91.6
  L2SGND w0.114: v1(148.34,45.91) 148.68,45.91 148.96,46.18 148.96,46.67 147.99,47.65 147.99,48.1 147.98,48.1 147.98,48.56 147.99,48.56 147.99,53.59 139.91,61.67 139.9,61.67 107.8,61.67 107.26,62.21 107.1,62.21 106.72,61.83 106.56,61.83 106.39,61.99 106.39,62.15 106.77,62.53 106.77,62.69 106.61,62.86 106.45,62.86 106.07,62.48 105.91,62.48 105.75,62.64 105.75,62.8 106.13,63.18 106.13,63.34 105.97,63.5 105.8,63.5 105.42,63.12 105.26,63.12 105.1,63.28 105.1,63.45 105.48,63.83 105.48,63.99 105.32,64.15 105.16,64.15 104.78,63.77 104.62,63.77 104.45,63.93 104.45,64.09 104.83,64.47 104.83,64.63 97.03,72.43 96.84,72.43 96.19,73.08 96.19,75.75 v1(96.46,76.02)
  BOTTOM w0.076: 94.9,80.03 94.93,80.09 94.93,80.16 95,80.23 95.04,80.3 95.09,80.32 95.16,80.38 95.41,80.38 95.41,80.39 95.46,80.39 95.61,80.58 95.63,80.59 95.63,80.6 95.64,80.61 95.64,80.77 95.65,80.99 95.65,81.07 95.65,81.09 95.7,81.14 95.71,81.53 95.71,82.26 95.71,82.4 95.71,82.42 95.71,82.55 95.71,82.55 95.71,82.74 95.62,83.39 95.57,83.63 95.49,83.71 95.46,83.85 95.45,83.9 95.45,84.07 95.46,84.12 95.46,84.12 95.47,84.19 95.47,84.43 95.45,84.48 95.22,84.71 CPU1.AK35
  BOTTOM w0.14: 94.9,80.03 94.87,80 94.87,76.66 95.07,76.46 95.35,76.46 95.92,77.03 96.3,77.03 96.48,76.85 96.48,76.04 v1(96.46,76.02)
  BOTTOM w0.216: DM2.158 147.78,44.15 147.77,44.16 147.77,44.61 148.34,45.18 v1(148.34,45.91)
M_B_A14: length 88.4
  L2SGND w0.089: v1(95.24,81.44) 95.43,81.64 96.17,81.64 96.32,81.48 96.32,77.09 95.75,76.52 95.75,73.06
  L2SGND w0.114: v1(146.43,49.51) 146.53,49.42 147.14,49.42 147.3,49.58 147.3,49.9 147.23,49.97 146.45,49.97 146.34,50.08 146.34,50.32 146.45,50.43 147.21,50.43 147.3,50.52 147.3,50.8 147.21,50.89 146.45,50.89 146.34,51 146.34,51.23 146.45,51.34 147.21,51.34 147.3,51.44 147.3,51.71 147.21,51.8 146.45,51.8 146.34,51.92 146.34,52.14 146.45,52.26 147.21,52.26 147.3,52.35 147.3,52.62 147.21,52.72 146.45,52.72 146.34,52.83 146.34,53.06 146.45,53.17 146.98,53.17 147.06,53.26 147.06,53.52 146.95,53.63 146.45,53.63 146.34,53.74 146.34,54.26 139.62,60.98 139.4,60.98 106.43,60.98 102.39,65.03 101.84,65.03 100.58,66.28 100.58,66.45 101.1,66.97 101.1,67.35 97.42,71.03 97.42,71.04 95.75,72.71 95.75,73.06
  BOTTOM w0.076: CPU1.AJ35 94.82,84.74 94.82,84.57 94.8,84.39 94.8,84.22 94.82,84.06 94.84,83.72 94.84,83.28 94.76,82.75 94.76,82.46 94.87,81.91 v1(95.24,81.44)
  BOTTOM w0.216: v1(146.43,49.51) 146.03,49.92 DM2.151
M_B_A15: length 89.2
  L2SGND w0.114: v1(95.24,82.08) 95.48,82.32 96.24,82.32 96.68,81.89 96.68,76.96 95.96,76.25 95.96,72.98 101.58,67.36 101.58,66.96 101.07,66.45 101.07,66.28 101.32,66.03 101.48,66.03 102,66.55 102.16,66.55 102.32,66.39 102.32,66.23 101.8,65.71 101.8,65.55 101.96,65.39 102.12,65.39 102.24,65.5 102.4,65.5 106.58,61.32 139.76,61.32 139.76,61.32 147.64,53.44 147.64,48.71 147.63,48.7 147.63,48.03 147.35,47.75 146.94,47.75 146.82,47.64 146.82,46.92 146.82,46.92 146.82,46.86 146.93,46.74 v1(147.35,46.74)
  BOTTOM w0.076: CPU1.AK34 94.96,85.06 94.96,84.9 94.99,84.75 94.99,84.56 94.96,84.37 94.96,84.25 95,83.91 95,83.24 94.95,82.91 94.95,82.9 94.94,82.86 94.92,82.74 94.92,82.5 95.17,82.09 v1(95.24,82.08)
  BOTTOM w0.216: v1(147.35,46.74) 147.35,45.24 147.28,45.16 DM2.156
M_B_A16: length 88.9
  L2SGND w0.089: v1(93.91,81.32) 94.67,80.56 94.67,77.32 94.71,77.27
  L2SGND w0.114: v1(145.29,46.35) 144.78,46.86 144.78,48.39 144.62,48.55 144.62,49.12 144.62,51.91 139.46,57.07 139.46,57.24 140.08,57.86 140.08,58 139.89,58.18 139.76,58.18 139.13,57.56 138.97,57.56 138.77,57.76 138.77,57.93 139.37,58.53 139.37,58.69 139.21,58.85 139.04,58.85 138.44,58.25 138.28,58.25 138.12,58.41 138.12,58.57 138.38,58.83 138.38,58.99 138.23,59.14 138.04,59.14 137.8,58.9 137.63,58.9 137.39,59.14 105.85,59.14 101.68,63.31 101.13,63.31 94.45,69.99 94.45,71.19 94.71,71.45 94.71,77.27
  BOTTOM w0.076: CPU1.AJ34 94.27,85.32 94.27,84.37 94.21,84.26 94.21,84.26 94.16,84.18 94.16,84.18 94.15,84.1 94.15,84.07 94.15,83.83 94.17,83.78 94.34,83.49 94.34,83.32 94.27,82.81 94.24,82.57 94.24,82.53 94.28,82.12 94.32,81.55 94.21,81.41 v1(93.91,81.32)
  BOTTOM w0.216: v1(145.29,46.35) 145.35,46.35 146.24,45.46 146.24,42.93 DM2.152
M_B_ACT_N: length 86.7
  L2SGND w0.089: 87.47,86.51 87.47,89.44 v1(87.96,89.92)
  L2SGND w0.114: 87.47,86.51 87.47,85.85 85.91,84.28 85.91,82.91 85.64,82.64 85.64,72.89 85.83,72.7 85.83,72.43 85.64,72.24 85.64,71.97 85.83,71.78 85.83,71.52 85.64,71.33 85.64,71.06 85.83,70.87 85.83,70.6 85.64,70.41 85.64,70.14 85.83,69.96 85.83,69.69 85.64,69.5 85.64,69.23 85.83,69.04 85.83,68.77 85.64,68.58 85.64,68.31 85.83,68.13 85.83,67.86 85.64,67.67 85.64,67.31 102.2,50.76 130.95,50.76 132.32,49.39 132.32,47.09 v1(133.78,45.63)
  BOTTOM w0.089: CPU1.W28 88.3,89.58 v1(87.96,89.92)
  BOTTOM w0.216: v1(133.78,45.63) 133.87,45.63 134.78,44.72 DM2.114
M_B_ALERT_N: length 84.6
  L2SGND w0.114: v1(88.86,88.67) 88.86,86.47 87.31,84.91 87.31,83.53 86.13,82.35 86.13,74.53 86.62,74.04 86.62,67.31 98.38,55.54 98.76,55.54 102.86,51.44 131.24,51.44 133.16,49.52 133.16,48.6 134.66,47.09 134.66,44.96 v1(135.28,44.35)
  BOTTOM w0.089: v1(88.86,88.67) 89.17,88.85 CPU1.Y29
  BOTTOM w0.216: DM2.116 v1(135.28,44.35)
M_B_BA0: length 88.7
  L2SGND w0.114: v1(145.29,45.08) 145.6,45.08 145.73,45.21 145.73,46.13 145.98,46.38 146.87,46.38 147.78,45.47 148.73,45.47 149.44,46.18 149.44,46.7 148.33,47.81 148.33,53.73 140.05,62.01 140.04,62.01 107.94,62.01 97.15,72.8 96.8,72.8 96.42,73.18 96.42,75.1 v1(96.61,75.29)
  BOTTOM w0.076: CPU1.AJ37 94.66,83.62 94.67,83.6 94.67,83.3 94.59,82.76 94.59,82.45 94.61,82.15 94.61,82.12 94.66,81.45 94.61,81.38 94.61,78.71 94.59,78.69 94.39,77.94
  BOTTOM w0.216: v1(96.61,75.29) 95.58,75.29 94.39,76.48 94.39,77.94 ; DM2.150 145.78,42.91 145.78,44.61 145.31,45.08 v1(145.29,45.08)
M_B_BA1: length 92
  L2SGND w0.114: v1(146.79,45.4) 147.1,45.09 148.86,45.09 149.79,46.02 149.79,46.86 148.67,47.98 148.67,53.87 140.19,62.35 140.18,62.35 108.09,62.35 97.03,73.41 97.03,74.81 v1(97.04,74.82)
  BOTTOM w0.076: 93.88,77.85 94.44,78.77 94.44,81.44 94.49,81.5 94.44,82.11 94.44,82.13 94.4,82.57 94.43,82.78 94.51,83.31 94.51,83.55 94.31,83.87 94.31,84.06 94.34,84.16 94.34,84.16 94.43,84.33 94.43,84.34 94.55,84.59 94.57,84.63 CPU1.AJ36
  BOTTOM w0.216: 93.88,77.85 93.88,76.3 95.36,74.82 v1(97.04,74.82) ; v1(146.79,45.4) 146.79,45.87 145.77,46.89 145.77,47.31 144.53,48.56 DM2.145
M_B_BG0: length 86.7
  L2SGND w0.089: 88.38,88.84 v1(87.93,89.29)
  L2SGND w0.114: v1(133.91,47.18) 132.74,48.35 132.74,49.46 131.09,51.1 102.34,51.1 102.03,51.41 102.03,51.57 102.06,51.6 102.06,51.76 101.89,51.92 101.73,51.92 101.71,51.9 101.54,51.9 101.38,52.06 101.38,52.22 101.41,52.25 101.41,52.41 101.25,52.57 101.09,52.57 101.06,52.54 100.9,52.54 100.74,52.7 100.74,52.87 100.76,52.89 100.76,53.05 100.6,53.22 100.44,53.22 100.41,53.19 100.25,53.19 100.09,53.35 100.09,53.51 100.12,53.54 100.12,53.7 99.95,53.86 99.79,53.86 99.77,53.84 99.6,53.84 99.44,54 99.44,54.16 99.47,54.19 99.47,54.35 99.31,54.51 99.15,54.51 99.12,54.48 98.96,54.48 98.8,54.64 98.8,54.81 98.82,54.83 98.82,54.99 98.66,55.16 98.5,55.16 98.47,55.13 98.31,55.13 86.17,67.27 86.17,71.01 86.16,71.02 86.16,74.02 85.92,74.27 85.92,82.58 86.13,82.78 86.13,84.06 88.47,86.41 88.47,86.87 88.38,86.96 88.38,88.84
  BOTTOM w0.089: v1(87.93,89.29) 88.05,89.29 CPU1.W29
  BOTTOM w0.216: DM2.115 135.03,48.39 133.91,47.28 v1(133.91,47.18)
M_B_BG1: length 86.8
  L2SGND w0.089: v1(88.86,89.3) 89.33,88.84 89.33,85.49 89,85.17 88.98,85.17
  L2SGND w0.114: v1(134.03,49) 133.57,49.46 133.57,49.59 132.83,50.34 132.83,50.5 132.98,50.65 132.98,50.81 132.82,50.98 132.66,50.98 132.5,50.82 132.34,50.82 132.18,50.98 132.18,51.14 132.34,51.3 132.34,51.46 132.18,51.62 132.01,51.62 131.86,51.47 131.7,51.47 131.38,51.79 103,51.79 98.15,56.64 97.99,56.64 97.96,56.61 97.8,56.61 97.64,56.77 97.64,56.93 97.66,56.96 97.66,57.12 97.5,57.29 97.34,57.29 97.31,57.26 97.15,57.26 96.99,57.42 96.99,57.58 97.02,57.61 97.02,57.77 96.86,57.93 96.69,57.93 96.67,57.9 96.51,57.9 96.34,58.07 96.34,58.23 96.37,58.26 96.37,58.42 96.21,58.58 96.05,58.58 96.02,58.55 95.86,58.55 95.7,58.71 95.7,58.87 95.72,58.9 95.72,59.06 95.56,59.23 95.4,59.23 95.37,59.2 95.21,59.2 95.05,59.36 95.05,59.52 95.08,59.55 95.08,59.71 94.92,59.87 94.75,59.87 94.73,59.84 94.57,59.84 94.4,60.01 94.4,60.17 94.43,60.2 94.43,60.36 94.27,60.52 94.11,60.52 94.08,60.49 93.92,60.49 93.76,60.65 93.76,60.81 93.78,60.84 93.78,61 93.62,61.17 93.46,61.17 93.43,61.14 93.27,61.14 93.11,61.3 93.11,61.46 93.14,61.49 93.14,61.65 92.98,61.81 92.81,61.81 92.79,61.78 92.63,61.78 92.46,61.95 92.46,62.11 92.49,62.14 92.49,62.3 92.33,62.46 92.17,62.46 92.14,62.43 91.98,62.43 91.82,62.59 91.82,62.76 91.84,62.78 91.84,62.94 91.68,63.11 91.52,63.11 91.49,63.08 91.33,63.08 91.17,63.24 91.17,63.4 91.2,63.43 91.2,63.59 91.04,63.75 90.87,63.75 90.85,63.73 90.69,63.73 90.52,63.89 90.52,64.05 90.55,64.08 90.55,64.24 90.39,64.4 90.23,64.4 90.2,64.37 90.04,64.37 89.88,64.53 89.88,64.7 89.9,64.72 89.9,64.88 89.74,65.05 89.58,65.05 89.55,65.02 89.39,65.02 89.23,65.18 89.23,65.34 89.26,65.37 89.26,65.53 89.1,65.69 88.93,65.69 88.91,65.67 88.75,65.67 88.58,65.83 88.58,65.99 88.61,66.02 88.61,66.18 88.45,66.34 88.29,66.34 88.26,66.31 88.1,66.31 87.94,66.47 87.94,66.64 87.96,66.66 87.96,66.82 87.8,66.99 87.64,66.99 87.61,66.96 87.45,66.96 87.29,67.12 87.29,67.28 87.32,67.31 87.32,67.47 87.07,67.71 87.07,73.91 86.34,74.64 86.34,82.17 87.68,83.52 87.68,83.87 88.98,85.17
  BOTTOM w0.14: CPU1.Y28 v1(88.86,89.3)
  BOTTOM w0.216: v1(134.03,49) 134.11,49 134.53,49.43 134.53,49.85 134.53,49.86 DM2.113
M_B_CKE0: length 83
  L2SGND w0.089: v1(87.04,89.3) 87,89.3 85.72,88.03 85.72,87 86.04,86.68 86.04,86 85.94,85.9
  L2SGND w0.114: v1(131.02,47.7) 130.99,47.7 128.64,50.05 128.53,50.05 101.93,50.05 84.9,67.08 84.9,82.74 84.66,82.97 84.66,83.75 85.94,85.02 85.94,85.9
  BOTTOM w0.14: v1(87.04,89.3) 87.01,89.34 86.99,89.34 86.75,89.58 CPU1.T28
  BOTTOM w0.216: DM2.109 133.53,49.71 131.52,47.7 v1(131.02,47.7)
M_B_CKE1: length 83.7
  L2SGND w0.089: v1(87.04,88.65) 86.64,87.41 86.64,86.14 86.85,85.93
  L2SGND w0.114: 86.85,85.93 86.85,85.51 85.62,84.28 85.62,83 85.28,82.66 85.28,67.19 102.07,50.39 128.54,50.39 130.51,50.28 131.05,50.18 131.49,49.73 131.57,49.54 131.73,48.29 131.9,46.95 132.24,46.37 132.38,46.18 133.26,44.92 133.47,44.65 v1(133.78,44.35)
  BOTTOM w0.14: v1(87.04,88.65) 86.99,88.7 86.94,88.7 86.71,88.93 CPU1.T29
  BOTTOM w0.216: v1(133.78,44.35) DM2.110
M_B_CLK0: length 89.5
  L2SGND w0.089: 93.16,85.03 93.16,85.05 93.18,85.07 93.18,85.82 93.82,86.46 93.82,87.56 93.58,87.8 93.58,88.65 93.46,88.78 93.16,88.78 93,88.94 93,89.13 93.13,89.26 v1(93.35,89.26)
  L2SGND w0.127: v1(141.19,48.44) 141.12,48.44 141.12,48.43 140.88,48.43 139.95,47.51 138.47,47.51 138.33,47.64 137.88,48.09 137.88,50.61 133.43,55.06 126.58,55.06 126.16,54.65 125.43,54.65 125.17,54.91 125.17,55.07 125.05,55.2 124.67,55.2 124.54,55.07 124.54,54.91 124.28,54.65 123.71,54.65 123.45,54.91 123.45,55.07 123.32,55.2 122.94,55.2 122.39,54.65 104.19,54.65 90.22,68.62 90.22,79.4 91.62,80.8 91.62,82.72 93.16,84.26 93.16,85.03
  BOTTOM w0.216: DM2.137 140.53,50.24 140.7,50.07 140.7,48.92 v1(141.19,48.44) ; CPU1.AF29 93.03,88.93 v1(93.35,89.26)
M_B_CLK1: length 89.3
  L2SGND w0.089: 90.88,83.39 90.88,83.55 92.19,84.86 92.19,86.27 92.07,86.38 92.07,88.69 92.2,88.81 92.38,88.81 v1(92.51,88.69)
  L2SGND w0.127: v1(141.73,46) 141.6,45.87 141.42,45.87 140.46,46.84 140.06,46.84 138.2,46.84 137.25,47.79 137.25,50.35 133.58,54.01 103.93,54.01 89.59,68.35 89.59,79.28 90.85,80.54 90.85,83.36 90.88,83.39
  BOTTOM w0.216: CPU1.AE29 92.12,88.7 92.28,88.62 v1(92.51,88.69) ; v1(141.73,46) 140.79,45.05 140.79,44.35 140.93,44.2 140.93,43.94 140.78,43.79 DM2.138
M_B_CLK#0: length 89.6
  L2SGND w0.089: 93.39,85.03 93.39,85.05 93.37,85.07 93.37,85.74 94.01,86.38 94.01,87.64 93.77,87.88 93.77,89.52 v1(93.4,89.89)
  L2SGND w0.127: 93.39,85.03 93.39,84.17 91.84,82.62 91.84,80.7 90.45,79.31 90.45,68.71 104.29,54.88 122.3,54.88 122.84,55.42 123.41,55.42 123.67,55.16 123.67,55 123.8,54.88 124.18,54.88 124.31,55 124.31,55.16 124.57,55.42 125.14,55.42 125.4,55.16 125.4,55 125.53,54.88 126.07,54.88 126.48,55.29 133.53,55.29 138.11,50.71 138.11,48.18 138.43,47.87 138.56,47.73 139.86,47.73 141.26,49.14 141.44,49.14 v1(141.61,48.98)
  BOTTOM w0.216: v1(141.61,48.98) 141.17,48.98 141.04,49.11 141.04,50.23 141.03,50.25 DM2.139 ; CPU1.AF28 92.98,89.58 93.4,89.87 v1(93.4,89.89)
M_B_CLK#1: length 89.2
  L2SGND w0.089: 90.62,83.39 90.62,83.57 92,84.94 92,86.19 91.88,86.3 91.88,88.76 92.12,89 92.13,89 92.18,89.06 v1(92.49,89.32)
  L2SGND w0.127: v1(141.76,45.31) 141.37,45.61 140.36,46.61 139.96,46.61 138.1,46.61 137.02,47.7 137.02,50.25 133.49,53.79 103.83,53.79 89.36,68.26 89.36,79.37 90.62,80.63 90.62,83.39
  BOTTOM w0.216: CPU1.AE28 v1(92.49,89.32) ; v1(141.76,45.31) 141.53,45.31 141.13,44.91 141.13,44.49 141.28,44.34 DM2.140
M_B_CS#0: length 86.5
  L2SGND w0.114: v1(145.97,48.74) 145.65,49.06 145.65,53.64 145.39,53.9 145.23,53.9 144.74,53.41 144.58,53.41 144.34,53.64 144.34,53.82 144.98,54.46 144.98,54.65 139.34,60.29 106.15,60.29 102.1,64.34 101.56,64.34 97.56,68.34 97.56,68.5 98.08,69.02 98.08,69.18 97.92,69.34 97.76,69.34 97.24,68.82 97.07,68.82 96.86,69.04 96.86,69.2 97.51,69.85 97.51,69.98 97.31,70.17 97.18,70.17 96.53,69.52 96.37,69.52 96.21,69.69 96.21,69.85 96.85,70.48 96.85,70.64 96.68,70.81 96.52,70.81 95.89,70.17 95.73,70.17 95.48,70.41 95.48,71.31 95.34,71.45 95.34,76.87 95.74,77.27 95.74,78.21 v1(95.33,78.61)
  BOTTOM w0.076: CPU1.AL37 95.96,83.46 95.96,83.45 95.99,83.28 96.01,83.16 96.02,83.15 96.02,83.12 96.02,83.09 96.03,83.06 96.03,83.02 96.03,82.94 96.03,82.93 96.04,82.87 96.04,82.82 96.04,82.8 96.04,82.51 96.04,82.46 96.04,82.41 96.04,82.39 96.04,82.34 96.04,82.24 96.04,81.82 96.04,81.79 96.04,80.46 95.91,80.09 95.91,79.41 95.91,79.4 95.83,79.11 v1(95.33,78.61)
  BOTTOM w0.216: DM2.149 145.53,49.7 145.97,49.25 v1(145.97,48.74)
M_B_CS#1: length 87.6
  L2SGND w0.114: v1(147.2,48.88) 147.01,49.07 146.25,49.07 146,49.33 146,54.12 139.48,60.64 106.29,60.64 102.25,64.68 101.7,64.68 100.24,66.14 99.5,66.88 99.5,67.06 100.11,67.68 100.11,67.86 99.91,68.06 99.75,68.06 99.12,67.43 98.95,67.43 98.79,67.59 98.79,67.75 99.43,68.38 99.43,68.54 99.26,68.71 99.1,68.71 98.47,68.07 98.31,68.07 98.15,68.23 98.15,68.4 98.78,69.03 98.78,69.19 97.08,70.89 97.08,70.9 96.8,71.17 96.8,71.17 96.54,71.44 96.38,71.44 96.19,71.25 96.03,71.25 95.87,71.41 95.87,71.57 96.05,71.76 96.05,71.92 95.55,72.43 95.55,76.77 96.04,77.27 96.04,79.02 95.84,79.22 95.84,79.55 96.04,79.76 96.04,80.21 95.93,80.32 95.44,80.32 95.32,80.21 v1(95.32,79.99)
  BOTTOM w0.076: v1(95.32,79.99) 95.34,79.97 95.42,79.97 95.77,80.41 95.79,80.52 95.8,80.54 95.8,80.76 95.81,81.02 95.87,81.08 95.87,81.75 95.87,81.75 95.87,82.25 95.87,82.4 95.87,82.42 95.87,82.48 95.88,82.48 95.88,82.51 95.88,82.79 95.88,82.82 95.88,82.86 95.87,82.91 95.87,82.93 95.87,82.96 95.87,82.96 95.86,83.07 95.85,83.14 95.85,83.14 95.75,83.7 95.64,83.81 95.62,83.89 95.62,83.91 95.62,84.05 95.64,84.18 95.64,84.46 95.63,84.47 95.62,84.57 95.62,84.74 95.87,85.25 CPU1.AL35
  BOTTOM w0.216: v1(147.2,48.88) 147.53,49.2 DM2.157
M_B_DIMB_ODT0: length 88.3
  L2SGND w0.114: v1(95.31,77.45) 95.14,77.28 95.14,70.27 101.41,64 101.96,64 106.01,59.95 139.2,59.95 142.58,56.57 142.58,56.41 141.91,55.75 141.91,55.59 142.08,55.43 142.24,55.43 142.9,56.09 143.06,56.09 143.22,55.93 143.22,55.76 142.56,55.1 142.56,54.94 142.72,54.78 142.88,54.78 143.55,55.44 143.71,55.44 143.87,55.28 143.87,55.12 143.21,54.46 143.21,54.29 143.37,54.13 143.53,54.13 144.19,54.79 144.35,54.79 144.51,54.64 144.51,54.47 143.85,53.81 143.85,53.65 144.49,53.01 145.02,53.01 145.31,52.72 145.31,48.84 145.47,48.68 145.47,48.62 145.79,48.3 146.16,48.3 146.16,48.31 v1(146.55,48.31)
  BOTTOM w0.076: CPU1.AL36 95.87,84.39 96.08,84.18 96.12,84.1 96.13,84.1 96.13,83.76 96.21,83.3 96.21,82.9 96.21,82.89 96.21,82.83 96.21,82.8 96.21,82.5 96.21,82.46 96.21,82.45 96.2,82.39 96.2,82.23 96.2,81.83 96.2,81.79 96.2,80.21
  BOTTOM w0.216: 96.2,80.21 96.18,80.15 96.18,79.89 96.17,79.88 96.15,79.36 95.99,78.78 95.79,78.09 95.79,78.07 95.79,78.02 95.76,77.98 95.76,77.89 95.32,77.45 v1(95.31,77.45) ; v1(146.55,48.31) 146.55,48.91 147.03,49.39 DM2.155
M_B_DIMB_ODT1: length 89.6
  L2SGND w0.114: v1(149.12,48.67) 149.56,48.24 149.87,48.24 150.19,48.57 150.19,49.63 150.08,49.75 149.1,49.75 149.01,49.83 149.01,50.12 149.1,50.2 149.95,50.2 150.06,50.32 150.06,50.53 149.94,50.66 149.13,50.66 149.01,50.77 149.01,51 149.13,51.12 149.95,51.12 150.06,51.23 150.06,51.45 149.94,51.57 149.13,51.57 149.01,51.69 149.01,51.92 149.13,52.03 149.95,52.03 150.06,52.15 150.06,52.36 149.94,52.49 149.13,52.49 149.01,52.6 149.01,52.83 149.13,52.95 149.56,52.95 149.69,53.07 149.69,53.34 140.33,62.69 140.33,62.69 108.3,62.69 97.49,73.51 97.49,75.6 v1(97.41,75.67)
  BOTTOM w0.089: CPU1.AL34 95.87,85.7 96.19,85.38 96.19,84.69 96.21,84.46 96.22,84.46 96.22,84.29 96.22,84.28 96.26,84.21 96.32,84.15 96.32,83.75 96.33,83.58 96.38,83.31 96.38,83.29 96.39,83.13 96.39,83.13 96.39,83.05 96.38,83.03 96.38,82.9 96.38,82.86 96.38,82.76 96.39,82.75 96.39,82.65 96.4,82.63 96.4,82.57 96.44,81.8 96.44,80.28 96.47,80.25 96.47,77.37 96.85,76.99 96.85,76.21 97.39,75.67 v1(97.41,75.67)
  BOTTOM w0.216: v1(149.12,48.67) 149.09,48.67 148.53,49.24 DM2.161
M_B_DQ0: length 52.4
  L4 w0.089: v1(97.31,76.94) 97.82,76.43 97.82,73.14
  L4 w0.203: 97.82,73.14 96.4,71.73 96.4,53.46 96.6,52.48 98.5,50.58 98.51,50.58 99.15,49.94 99.17,49.94 100.29,48.82 106.35,48.82 v1(107.31,47.86)
  BOTTOM w0.076: v1(97.31,76.94) 96.98,77.24 96.88,77.41 96.7,78.34 96.7,80.26 96.62,80.35 96.63,81.72 96.63,82.21 97.17,82.75 97.17,83.05 97.16,83.09 96.94,83.39 96.84,83.48 96.72,83.66 96.72,83.69 96.66,83.74 96.66,83.77 96.66,84.14 96.77,84.34 96.77,84.97 CPU1.AN35
  BOTTOM w0.216: v1(107.31,47.86) 107.88,47.29 107.88,46.05 108.28,45.65 DM2.8
M_B_DQ1: length 49.3
  L4 w0.203: v1(106.89,49.61) 107.06,49.78 107.06,50.03 106.76,50.32 101.07,50.32 98.4,52.99 98.4,52.99 98.29,53.11 98.29,54.43 97.35,55.36 97.35,71.3 98.49,72.44 98.49,77.8 98.1,78.2 98.1,78.55 98.49,78.95 98.49,79.24 98.33,79.41 97.91,79.41 97.53,79.02 97.51,79.02 v1(97.34,78.84)
  BOTTOM w0.076: 97.89,79.53 98.12,79.76 98.12,79.88 98.2,82.28 98.2,83.24 97.96,83.89 97.96,84.11 98,84.22 98,84.4 97.96,84.51 97.96,84.76 98.04,84.98 98.04,85.72 98.03,85.73 97.82,85.94 CPU1.AN34
  BOTTOM w0.089: 97.89,79.53 97.89,79.19 97.55,78.84 v1(97.34,78.84)
  BOTTOM w0.216: v1(106.89,49.61) 107.03,49.75 DM2.3
M_B_DQ2: length 52.4
  L4 w0.089: 99.3,70.43 99.54,70.67 99.54,76.59 v1(99.5,76.64)
  L4 w0.203: v1(109.76,47.37) 109.59,47.54 109.59,48.16 109.76,48.33 109.76,50.27 107.76,52.27 103.22,52.27 99.3,56.19 99.3,58.13 99.45,58.28 99.98,58.28 100.18,58.48 100.18,58.91 100,59.09 99.45,59.09 99.3,59.25 99.3,70.43
  BOTTOM w0.076: CPU1.AR35 98.29,85.19 98.12,84.73 98.12,84.54 98.16,84.43 98.16,84.19 98.12,84.08 98.14,83.89 98.37,83.27 98.37,82.25 98.3,79.83 98.29,79.81 98.29,79.67 98.12,79.5 98.12,79.5 98.12,77.42
  BOTTOM w0.089: v1(99.5,76.64) 99.5,76.64 99.5,76.66 99.47,76.69 99.47,76.71 99.38,76.8 98.75,76.8 98.12,77.42
  BOTTOM w0.216: DM2.16 110.28,46.38 109.95,46.71 109.95,46.88 109.76,47.06 v1(109.76,47.37)
