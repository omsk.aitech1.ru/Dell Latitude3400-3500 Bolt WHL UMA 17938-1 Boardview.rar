# Allegro board 17938-1.1228WZS1107.brd (continued)
## Library data of the parts (continued)
R3504 = 0R0402-PAD: tolerance: ZZ.R0402.001; signal model: wistron_R3504
R3505 = 0R0402-PAD: tolerance: ZZ.R0402.001; signal model: wistron_R3505
R3508 = 0R0402-PAD: tolerance: ZZ.R0402.001; signal model: wistron_R3508
R3513 R6125 = R805H24: tolerance: 63.R0031.16L
R3604 = R402H16: tolerance: 64.22125.6DL
R3612 = R402H15: tolerance: 63.R0034.L0L; signal model: wistron_R3612
R3613 = R402H15: tolerance: 63.R0034.L0L; signal model: wistron_R3613
R3614 = R402H15: tolerance: 63.R0034.L0L; signal model: wistron_R3614
R3615 = R402H15: tolerance: 63.R0034.L0L; signal model: wistron_R3615
R4010 R4048 R6325 R6326 R6328-R6336 R7144 = R402H16: tolerance: 63.20334.L0L
R4302 = R402H16: tolerance: 64.15025.6DL
R4304 R5751 R5755 R5817 R5834 R7215 = R402H16: tolerance: 63.22234.1DL
R4307 = R603H22: tolerance: 63.24434.15L
R4315 R4381 = R402H16: tolerance: 64.18725.6DL
R4376 = R402H16: tolerance: 64.47035.6DL
R4401 R4402 = R402H16: tolerance: 64.1R005.L0L
R5010 R5011 R5115 R5116 R5118 R5501 R5502 R5523 R5556 R5558 R5559 R6302 R6349 = R603H22: tolerance: 63.R0033.L0L
R5504 = R402H14: tolerance: 63.10134.1DL
R5511 = R402H15: tolerance: 63.R0034.L0L; signal model: wistron_R5511
R5512 = R402H15: tolerance: 63.R0034.L0L; signal model: wistron_R5512
R5546 R5548 R6804 = R402H16: tolerance: 64.47015.6DL
R5549 R6404 R7404 R7422 R7434 = R402H16: tolerance: 64.10045.6DL
R5765 = 0R0402-PAD: tolerance: ZZ.R0402.001; signal model: wistron_R5765
R5766 = 0R0402-PAD: tolerance: ZZ.R0402.001; signal model: wistron_R5766
R5767 = 0R0402-PAD: tolerance: ZZ.R0402.001; signal model: wistron_R5767
R5768 = 0R0402-PAD: tolerance: ZZ.R0402.001; signal model: wistron_R5768
R5769 = 0R0402-PAD: tolerance: ZZ.R0402.001; signal model: wistron_R5769
R5770 = 0R0402-PAD: tolerance: ZZ.R0402.001; signal model: wistron_R5770
R5771 = 0R0402-PAD: tolerance: ZZ.R0402.001; signal model: wistron_R5771
R5772 = 0R0402-PAD: tolerance: ZZ.R0402.001; signal model: wistron_R5772
R5781 = R402H16: tolerance: 64.15035.6DL
R5804 = R402H16: tolerance: 64.49915.6DL
R5824 = R402H15: tolerance: 63.R0034.L0L; signal model: wistron_R5824
R5825 = R402H15: tolerance: 63.R0034.L0L; signal model: wistron_R5825
R5840 = R402H15: tolerance: 63.R0034.L0L; signal model: wistron_R5840
R5841 = R402H15: tolerance: 63.R0034.L0L; signal model: wistron_R5841
R5842 = R402H15: tolerance: 63.R0034.L0L; signal model: wistron_R5842
R5843 = R402H15: tolerance: 63.R0034.L0L; signal model: wistron_R5843
R5854 = R402H16: tolerance: 63.5R134.1DL; signal model: wistron_R5854
R5855 = R402H16: tolerance: 63.5R134.1DL; signal model: wistron_R5855
R5856 = R402H16: tolerance: 63.5R134.1DL; signal model: wistron_R5856
R5857 = R402H16: tolerance: 63.5R134.1DL; signal model: wistron_R5857
R5858 = R402H16: tolerance: 63.5R134.1DL; signal model: wistron_R5858
R5859 = R402H16: tolerance: 63.5R134.1DL; signal model: wistron_R5859
R5860 = R402H16: tolerance: 63.5R134.1DL; signal model: wistron_R5860
R5861 = R402H16: tolerance: 63.5R134.1DL; signal model: wistron_R5861
R6101 R6102 = R402H16: tolerance: 63.75334.1DL
R6104 = 0R0402-PAD: tolerance: ZZ.R0402.001; signal model: wistron_R6104
R6105 = 0R0402-PAD: tolerance: ZZ.R0402.001; signal model: wistron_R6105
R6120 = R402H16: tolerance: 63.22034.1DL; signal model: wistron_R6120
R6121 R6122 = R402H16: tolerance: 64.71525.6DL
R6123 = R402H16: tolerance: 63.22034.1DL; signal model: wistron_R6123
R6124 = R1206H26: tolerance: 63.R0037.L0L
R6202 = R402H16: tolerance: 63.R0034.1DL; signal model: wistron_R6202
R6203 = R402H16: tolerance: 63.R0034.1DL; signal model: wistron_R6203
R6358 = R402H14: tolerance: 64.10R05.6DL; signal model: wistron_R6358
R6359 = R402H14: tolerance: 64.10R05.6DL; signal model: wistron_R6359
R6360 = R402H14: tolerance: 64.10R05.6DL; signal model: wistron_R6360
R6361 = R402H14: tolerance: 64.10R05.6DL; signal model: wistron_R6361
R6362 = R402H14: tolerance: 64.10R05.6DL; signal model: wistron_R6362
R6363 = R402H14: tolerance: 64.10R05.6DL; signal model: wistron_R6363
R6364 = R402H14: tolerance: 64.10R05.6DL; signal model: wistron_R6364
R6365 = R402H14: tolerance: 64.10R05.6DL; signal model: wistron_R6365
R6366 = R402H14: tolerance: 64.10R05.6DL; signal model: wistron_R6366
R6367 = R402H14: tolerance: 64.10R05.6DL; signal model: wistron_R6367
R6368 = R402H14: tolerance: 64.10R05.6DL; signal model: wistron_R6368
R6406 = R402H16: tolerance: 64.54905.6DL
R6410 = R402H16: tolerance: 64.42205.6DL
R6414 = R402H16: tolerance: 64.33035.6DL
R6503 = R603H22: tolerance: 63.10133.15L
R6604 = R402H16: tolerance: 63.R0034.1DL; signal model: wistron_R6604
R6605 = R402H16: tolerance: 63.R0034.1DL; signal model: wistron_R6605
R6606 = R402H16: tolerance: 63.R0034.1DL; signal model: wistron_R6606
R6607 = R402H16: tolerance: 63.R0034.1DL; signal model: wistron_R6607
R6802 R6803 = R402-PAD-NP: tolerance: ZZ.R0402.0001
R7101 R7102 = R402H15: tolerance: 63.10434.L1L
R7103 = R402H16: tolerance: 63.R0034.1DL; signal model: wistron_R7103
R7104 = R402H16: tolerance: 63.R0034.1DL; signal model: wistron_R7104
R7115 = R402H16: tolerance: 63.R0034.1DL; signal model: wistron_R7115
R7117 = R402H16: tolerance: 63.R0034.1DL; signal model: wistron_R7117
R7119 = R402H16: tolerance: 63.R0034.1DL; signal model: wistron_R7119
R7120 = R402H16: tolerance: 63.R0034.1DL; signal model: wistron_R7120
R7122 = R402H16: tolerance: 63.R0034.1DL; signal model: wistron_R7122
R7123 = R402H16: tolerance: 63.R0034.1DL; signal model: wistron_R7123
R7124 = R402H16: tolerance: 63.R0034.1DL; signal model: wistron_R7124
R7125 = R402H16: tolerance: 63.R0034.1DL; signal model: wistron_R7125
R7131 = R402H16: tolerance: 63.R0034.1DL; signal model: wistron_R7131
R7132 = R402H16: tolerance: 63.R0034.1DL; signal model: wistron_R7132
R7133 = R402H16: tolerance: 63.R0034.1DL; signal model: wistron_R7133
R7134 = R402H16: tolerance: 63.R0034.1DL; signal model: wistron_R7134
R7153 = R402H15: tolerance: 63.R0034.L0L; signal model: wistron_R7153
R7154 = R402H15: tolerance: 63.R0034.L0L; signal model: wistron_R7154
R7155 = R402H15: tolerance: 63.R0034.L0L; signal model: wistron_R7155
R7156 = R402H15: tolerance: 63.R0034.L0L; signal model: wistron_R7156
R7177 = R402H16: tolerance: 63.5R134.1DL; signal model: wistron_R7177
R7178 = R402H16: tolerance: 63.5R134.1DL; signal model: wistron_R7178
R7179 = R402H16: tolerance: 63.5R134.1DL; signal model: wistron_R7179
R7180 = R402H16: tolerance: 63.5R134.1DL; signal model: wistron_R7180
R7181 = R402H16: tolerance: 63.5R134.1DL; signal model: wistron_R7181
R7182 = R402H16: tolerance: 63.5R134.1DL; signal model: wistron_R7182
R7183 = R402H16: tolerance: 63.5R134.1DL; signal model: wistron_R7183
R7184 = R402H16: tolerance: 63.5R134.1DL; signal model: wistron_R7184
R7212 = R402H16: tolerance: 64.12035.6DL
R7217 = R402H16: tolerance: 64.90935.6DL
R7218 = R402H16: tolerance: 64.30135.6DL
R7330 R7331 = R402H16: tolerance: 64.20045.6DL
R7332 = R402H15: tolerance: 63.R0034.L0L; signal model: wistron_R7332
R7333 = R402H15: tolerance: 63.R0034.L0L; signal model: wistron_R7333
R7334 = R402H15: tolerance: 63.R0034.L0L; signal model: wistron_R7334
R7335 = R402H15: tolerance: 63.R0034.L0L; signal model: wistron_R7335
R7410 = R1206H26: tolerance: 63.15132.11L
R9118 = R402H16: tolerance: 64.22015.6DL
R9132 = R402H16: tolerance: 63.33034.1DL; signal model: wistron_R9132
R9133 = R402H16: tolerance: 63.33034.1DL; signal model: wistron_R9133
R9138 = R402H16: tolerance: 63.33034.1DL; signal model: wistron_R9138
R9209 = 0R0402-PAD: tolerance: ZZ.R0402.001; signal model: wistron_R9209
R9210 = 0R0402-PAD: tolerance: ZZ.R0402.001; signal model: wistron_R9210
RJ1 = 2RJ3076-078211F: tolerance: 022.10008.0551
RN401 RN1807 = ARES8-CN24-UH20: tolerance: 66.22236.A8L
RN1201 RN1301 = SMD-ARES4H18: tolerance: 66.10236.04L
RN1601 RN1704 = ARES8-CN24-MUH20: tolerance: 66.10336.08L
RN1602 = SMD-ARES4H20: tolerance: 66.R0036.04L
RN1703 RN1810 RN2601 RN6501 = ARES2H18: tolerance: 66.10336.04L
RN1801 RN2001 = SMD-ARES4H20: tolerance: 66.20336.04L
RN1806 = ARES8-CN24-MUH20: tolerance: 66.15035.A8L; signal model: wistron_RN1806
RN1811 RN2413 RN2602 RN2901 RN6503 RN7201 RN7202 RN9301 = ARES2H16: tolerance: 66.22236.04L
RN2402 = SMD-ARES4H18: tolerance: 66.47236.04L
RN2403 RN2404 RN2409 RN2410 RN2412 RN5502 = ARES8-CN24H20: tolerance: 66.10436.A8L
RN2405-RN2407 RN2411 = SMD-ARES4: tolerance: 66.10436.04L
RN3201 = ARES8-CN24H22: tolerance: 66.75036.08L
RN4302 RN5503 = ARES8-CN24H20: tolerance: 66.10136.A8L
RN5504 RN5505 RN6502 = SMD-ARES4H18: tolerance: 66.33036.04L
RN6401 = SMD-ARES4H18: tolerance: 66.10136.04L
SPR3 SPR4 = SPR5630H142: tolerance: 34.4Y806.001
SPR5-SPR9 = SPR5128H111: tolerance: 34.4YW18.001
SSD1 = NFSM0-S6701-TSH4-U: tolerance: 062.10003.00X1
TP1 = 51574-0084N-W01: tolerance: 020.K0151.0008
TP401 TP402 TP620 TP623 TP640 TP1702 TP1705 TP1706 TP1708 TP1807 TP1808 TP1901 TP2201 TP2202 TP4411 TP4601 TP6001 TP6201 TP7201 TP9101-TP9104 = TPAD14-OP: tolerance: ZZ.PAD14.001
TP4401 = TPAD28: tolerance: ZZ.PAD28.XXX
TP6801-TP6807 = TPAD14-5: tolerance: ZZ.PAD01.4H1
U2401 = TQFP128-2H48: tolerance: 071.01416.000G
U2402 = SC70-5-1H44: tolerance: 73.01G08.EHG
U2502 = SOT-23-5H58: tolerance: 074.00524.0B9F
U2601 = MSOP8-1H44: tolerance: 74.07718.0B9
U3101 = QFN32J4-G2D85H36: tolerance: 071.8111H.0003
U3502 = SOT-23-5H56: tolerance: 074.06288.009B
U3601 = QFN16-G1D8-UH32: tolerance: 74.02544.073; signal model: wistron_U3601
U4001 U4004 U5502 = DFN14J32-G255D95H32: tolerance: 074.02898.0093
U4002 U4003 U4006 = DFN8F3-G2517H32: tolerance: 074.05027.0093
U4007 = SC70-5H44: tolerance: 073.7SZ08.000G
U4302 = SOT-23-5H52: tolerance: 074.01004.00BF
U5501 = SOT-23-5H56: tolerance: 074.22811.009F
U5702 = SOT23-2D8-312H58: tolerance: 74.03517.07B
U5802 = QFN60J9050-G7131H32: tolerance: 71.08338.A03; signal model: wistron_U5802
U6101 = SOT-23-5H58: tolerance: 074.51712.009F
U6301 = BGA153G115130-2H40: tolerance: 072.KMBG4.0C0U
U7001 = LGA12G2H40: tolerance: 074.LNG2D.00BZ
U7101 = QFN40J4060-G2848H32: tolerance: 071.00546.0A03
U7102 = QFN20J3-G1D8H32: tolerance: 071.10224.0003; signal model: wistron_U7102
U7201 = QFN24-G2D8-UH24: tolerance: 071.04126.0D03
U7202 = DFN6G1820-G1511-UH24: tolerance: 074.02151.0A73
U7203 = DFN6F2-G1711-UH32: tolerance: 074.70933.0033
U7403 = CSP16G2D2H24: tolerance: 074.53363.M001
U7419 = CSP15G154256H24: tolerance: 074.20509.007Z
U9103 = QFN32G5-G3D75-UH40: tolerance: 071.33203.0A03
USB1 USB2 = SKT-USB13-160146-4-U: tolerance: 022.10005.0EY1
WLAN1 = 40-42064-067212HF: tolerance: 062.10007.0511
WWAN1 = 04-6809-634-310-846: tolerance: 020.K0346.0034
X1801 = S-OSC3-2016H28: tolerance: 082.30006.0041
X1802 X2401 = SMD49-12H34: tolerance: 082.30003.0301
X3101 = OSC-3225-4P-4H36: tolerance: 82.30020.G61
XF3201 = XFORM12A127096H81: tolerance: 68.0NS14.301; signal model: wistron_XF3201
XF3202 = XFORM12A127096H81: tolerance: 68.0NS14.301; signal model: wistron_XF3202

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
0R0402-PAD
  custom 0.127x0.127 smd: 1(0,0.432) 2(0,-0.432)
0R0603-PAD
  custom 0.254x0.254 smd: 1(0,0.66) 2(0,-0.66)
0R0603-PAD-1-U
  custom 0.254x0.254 smd: 1(0,0.66) 2(0,-0.66)
0R0603-PAD-U
  custom 0.254x0.254 smd: 1(0,0.66) 2(0,-0.66)
0R0805-PAD
  rect 1.549x1.346 smd: 1(0,0.838) 2(0,-0.838)
0R0805-PAD-U
  rect 1.549x1.333 smd: 1(0,0.838) 2(0,-0.838)
2RJ3076-078211F
  round 1.321 hole 0.914: 1(3.57,10.1) 2(2.55,11.2) 3(1.53,10.1) 4(0.51,11.2) 5(-0.51,10.1) 6(-1.53,11.2) 7(-2.55,10.1) 8(-3.57,11.2)
  oval 1.321x2.311 hole 0.61x1.6: 9(8.4,7.8) 10(-8.4,7.8) 11(8.4,0) 12(-8.4,0)
04-6809-634-310-846
  rect 0.305x0.813 smd: 1(-8.25,2.5) 2(-7.75,2.5) 3(-7.25,2.5) 4(-6.75,2.5) 5(-6.25,2.5) 6(-5.75,2.5) 7(-5.25,2.5) 8(-4.75,2.5) 9(-4.25,2.5) 10(-3.75,2.5) 11(-3.25,2.5) 12(-2.75,2.5) 13(-2.25,2.5) 14(-1.75,2.5) 15(-1.25,2.5) 16(-0.75,2.5) 17(-0.25,2.5) 18(0.25,2.5) 19(0.75,2.5) 20(1.25,2.5) 21(1.75,2.5) 22(2.25,2.5) 23(2.75,2.5) 24(3.25,2.5) 25(3.75,2.5) 26(4.25,2.5) 27(4.75,2.5) 28(5.25,2.5) 29(5.75,2.5) 30(6.25,2.5) 31(6.75,2.5) 32(7.25,2.5) 33(7.75,2.5) 34(8.25,2.5)
  rect 0.406x0.813 smd: 35(9.475,0) 36(-9.475,0)
14-00790-1A03-A
  oval 1.321x2.235 hole 0.61x1.524: 1(-4.85,8.4) 2(4.7,2.9) 3(-4.85,0.6) 4(4.7,0) 5(4.7,8.4) 6(4.7,5.65) MS(-4.85,4.3)
40-42064-067212HF
  round 0.254 hole 1.651 unplated: (-10,0)
  round 0.254 hole 1.168 unplated: (10,0)
  rect 0.305x1.549 smd: 1(9.25,-5.275) 2(9,2.275) 3(8.75,-5.275) 4(8.5,2.275) 5(8.25,-5.275) 6(8,2.275) 7(7.75,-5.275) 8(7.5,2.275) 9(7.25,-5.275) 10(7,2.275) 11(6.75,-5.275) 12(6.5,2.275) 13(6.25,-5.275) 14(6,2.275) 15(5.75,-5.275) 16(5.5,2.275) 17(5.25,-5.275) 18(5,2.275) 19(4.75,-5.275) 20(4.5,2.275) 21(4.25,-5.275) 22(4,2.275) 23(3.75,-5.275) 32(1.5,2.275) 33(1.25,-5.275) 34(1,2.275) 35(0.75,-5.275) 36(0.5,2.275) 37(0.25,-5.275) 38(0,2.275) 39(-0.25,-5.275) 40(-0.5,2.275) 41(-0.75,-5.275) 42(-1,2.275) 43(-1.25,-5.275) 44(-1.5,2.275) 45(-1.75,-5.275) 46(-2,2.275) 47(-2.25,-5.275) 48(-2.5,2.275) 49(-2.75,-5.275) 50(-3,2.275) 51(-3.25,-5.275) 52(-3.5,2.275) 53(-3.75,-5.275) 54(-4,2.275) 55(-4.25,-5.275) 56(-4.5,2.275) 57(-4.75,-5.275) 58(-5,2.275) 59(-5.25,-5.275) 60(-5.5,2.275) 61(-5.75,-5.275) 62(-6,2.275) 63(-6.25,-5.275) 64(-6.5,2.275) 65(-6.75,-5.275) 66(-7,2.275) 67(-7.25,-5.275) 68(-7.5,2.275) 69(-7.75,-5.275) 70(-8,2.275) 71(-8.25,-5.275) 72(-8.5,2.275) 73(-8.75,-5.275) 74(-9,2.275) 75(-9.25,-5.275)
  rect 1.194x2.743 smd: 76(10.35,-4.5) 77(-10.35,-4.5)
300E40-1010RA-G3
  rect 0.305x0.889 smd: 1(-9.75,2.82) 2(-9.25,2.82) 3(-8.75,2.82) 4(-8.25,2.82) 5(-7.75,2.82) 6(-7.25,2.82) 7(-6.75,2.82) 8(-6.25,2.82) 9(-5.75,2.82) 10(-5.25,2.82) 11(-4.75,2.82) 12(-4.25,2.82) 13(-3.75,2.82) 14(-3.25,2.82) 15(-2.75,2.82) 16(-2.25,2.82) 17(-1.75,2.82) 18(-1.25,2.82) 19(-0.75,2.82) 20(-0.25,2.82) 21(0.25,2.82) 22(0.75,2.82) 23(1.25,2.82) 24(1.75,2.82) 25(2.25,2.82) 26(2.75,2.82) 27(3.25,2.82) 28(3.75,2.82) 29(4.25,2.82) 30(4.75,2.82) 31(5.25,2.82) 32(5.75,2.82) 33(6.25,2.82) 34(6.75,2.82) 35(7.25,2.82) 36(7.75,2.82) 37(8.25,2.82) 38(8.75,2.82) 39(9.25,2.82) 40(9.75,2.82)
  rect 0.559x0.889 smd: 41(-10.65,2.82) 42(10.65,2.82)
  rect 1.397x1.905 smd: 43(-12.849,0) 44(12.849,0)
50224-0040N-001
  rect 0.61x1.549 smd: 1(-1.5,3.875) 2(-0.5,3.875) 3(0.5,3.875) 4(1.5,3.875)
  rect 1.194x1.803 smd: 5(-2.797,0) 6(2.797,0)
50224-0080N-W02-U
  rect 0.406x1.549 smd: 1(-3.5,3.875) 2(-2.5,3.875) 3(-1.5,3.875) 4(-0.5,3.875) 5(0.5,3.875) 6(1.5,3.875) 7(2.5,3.875) 8(3.5,3.875)
  rect 1.194x1.803 smd: 9(-4.797,0) 10(4.797,0)
50406-02071-W01
  rect 0.305x1.295 smd: 1(-4.75,-1.95) 2(-4.25,-1.95) 3(-3.75,-1.95) 4(-3.25,-1.95) 5(-2.75,-1.95) 6(-2.25,-1.95) 7(-1.75,-1.95) 8(-1.25,-1.95) 9(-0.75,-1.95) 10(-0.25,-1.95) 11(0.25,-1.95) 12(0.75,-1.95) 13(1.25,-1.95) 14(1.75,-1.95) 15(2.25,-1.95) 16(2.75,-1.95) 17(3.25,-1.95) 18(3.75,-1.95) 19(4.25,-1.95) 20(4.75,-1.95)
  rect 1.194x2.692 smd: 21(-7.15,0) 24(7.15,0)
  rect 2.311x1.295 smd: 22(-3.9,1.95) 23(3.9,1.95)
50552-01601-001
  rect 0.406x1.549 smd: 1(-3.75,1.173) 2(-3.25,-1.173) 3(-2.75,1.173) 4(-2.25,-1.173) 5(-1.75,1.173) 6(-1.25,-1.173) 7(-0.75,1.173) 8(-0.25,-1.173) 9(0.25,1.173) 10(0.75,-1.173) 11(1.25,1.173) 12(1.75,-1.173) 13(2.25,1.173) 14(2.75,-1.173) 15(3.25,1.173) 16(3.75,-1.173)
  rect 1.397x2.896 smd: 17(-5.45,0) 18(5.45,0)
50696-00601-001
  rect 0.305x0.813 smd: 1(1.25,2.5) 2(0.75,2.5) 3(0.25,2.5) 4(-0.25,2.5) 5(-0.75,2.5) 6(-1.25,2.5)
  rect 0.406x0.813 smd: 7(2.25,0) 8(-2.25,0)
50698-00401-W01-U
  rect 0.305x1.6 smd: 1(1.5,5.2) 2(0.5,5.2) 3(-0.5,5.2) 4(-1.5,5.2)
  rect 1.803x2.007 smd: 5(4.21,0) 6(-4.21,0)
50699-03001-W01
  rect 0.229x0.813 smd: 1(-11.6,3.3) 2(-10.8,3.3) 3(-10,3.3) 4(-9.2,3.3) 5(-8.4,3.3) 6(-7.6,3.3) 7(-6.8,3.3) 8(-6,3.3) 9(-5.2,3.3) 10(-4.4,3.3) 11(-3.6,3.3) 12(-2.8,3.3) 13(-2,3.3) 14(-1.2,3.3) 15(-0.4,3.3) 16(0.4,3.3) 17(1.2,3.3) 18(2,3.3) 19(2.8,3.3) 20(3.6,3.3) 21(4.4,3.3) 22(5.2,3.3) 23(6,3.3) 24(6.8,3.3) 25(7.6,3.3) 26(8.4,3.3) 27(9.2,3.3) 28(10,3.3) 29(10.8,3.3) 30(11.6,3.3)
  rect 0.559x1.295 smd: 31(-13.075,0) 32(13.075,0)
51530-02001-W01-U
  rect 0.305x0.838 smd: 1(-4.75,3.175) 2(-4.25,3.175) 3(-3.75,3.175) 4(-3.25,3.175) 5(-2.75,3.175) 6(-2.25,3.175) 7(-1.75,3.175) 8(-1.25,3.175) 9(-0.75,3.175) 10(-0.25,3.175) 11(0.25,3.175) 12(0.75,3.175) 13(1.25,3.175) 14(1.75,3.175) 15(2.25,3.175) 16(2.75,3.175) 17(3.25,3.175) 18(3.75,3.175) 19(4.25,3.175) 20(4.75,3.175)
  rect 0.813x2.007 smd: 21(-6.45,0) 22(6.45,0)
51574-0084N-W01
  rect 0.305x1.194 smd: 1(-3.5,3.3) 2(-2.5,3.3) 3(-1.5,3.3) 4(-0.5,3.3) 5(0.5,3.3) 6(1.5,3.3) 7(2.5,3.3) 8(3.5,3.3)
  rect 0.406x0.813 smd: 9(-5.185,0) 10(5.185,0)
88231-1001-LP
  rect 0.813x1.905 smd: 1(-5.625,4.878) 2(-4.375,4.878) 3(-3.125,4.878) 4(-1.875,4.878) 5(-0.625,4.878) 6(0.625,4.878) 7(1.875,4.878) 8(3.125,4.878) 9(4.375,4.878) 10(5.625,4.878)
  rect 1.295x3.353 smd: 11(-8.473,0) 12(8.473,0)
196415-06031-3
  rect 0.305x0.838 smd: 1(-1.25,3.175) 2(-0.75,3.175) 3(-0.25,3.175) 4(0.25,3.175) 5(0.75,3.175) 6(1.25,3.175)
  rect 0.813x2.007 smd: 7(-2.95,0) 8(2.95,0)
ADDR0206-P013A-1-U
  round 0.254 hole 1.6 unplated: (-34.4,0)
  round 0.254 hole 1.118 unplated: (34.4,0)
  custom 0.089x0.089 smd: 1(-33.375,-4.1) 2(-33.125,4.1) 3(-32.875,-4.1) 4(-32.625,4.1) 5(-32.375,-4.1) 6(-32.125,4.1) 7(-31.875,-4.1) 8(-31.625,4.1) 9(-31.375,-4.1) 10(-31.125,4.1) 11(-30.875,-4.1) 12(-30.625,4.1) 13(-30.375,-4.1) 14(-30.125,4.1) 15(-29.875,-4.1) 16(-29.625,4.1) 17(-29.375,-4.1) 18(-29.125,4.1) 19(-28.875,-4.1) 20(-28.625,4.1) 21(-28.375,-4.1) 22(-28.125,4.1) 23(-27.875,-4.1) 24(-27.625,4.1) 25(-27.375,-4.1) 26(-27.125,4.1) 27(-26.875,-4.1) 28(-26.625,4.1) 29(-26.375,-4.1) 30(-26.125,4.1) 31(-25.875,-4.1) 32(-25.625,4.1) 33(-25.375,-4.1) 34(-25.125,4.1) 35(-24.875,-4.1) 36(-24.625,4.1) 37(-24.375,-4.1) 38(-24.125,4.1) 39(-23.875,-4.1) 40(-23.625,4.1) 41(-23.375,-4.1) 42(-23.125,4.1) 43(-22.875,-4.1) 44(-22.625,4.1) 45(-22.375,-4.1) 46(-22.125,4.1) 47(-21.875,-4.1) 48(-21.625,4.1) 49(-21.375,-4.1) 50(-21.125,4.1) 51(-20.875,-4.1) 52(-20.625,4.1) 53(-20.375,-4.1) 54(-20.125,4.1) 55(-19.875,-4.1) 56(-19.625,4.1) 57(-19.375,-4.1) 58(-19.125,4.1) 59(-18.875,-4.1) 60(-18.625,4.1) 61(-18.375,-4.1) 62(-18.125,4.1) 63(-17.875,-4.1) 64(-17.625,4.1) 65(-17.375,-4.1) 66(-17.125,4.1) 67(-16.875,-4.1) 68(-16.625,4.1) 69(-16.375,-4.1) 70(-16.125,4.1) 71(-15.875,-4.1) 72(-15.625,4.1) 73(-15.375,-4.1) 74(-15.125,4.1) 75(-14.875,-4.1) 76(-14.625,4.1) 77(-14.375,-4.1) 78(-14.125,4.1) 79(-13.875,-4.1) 80(-13.625,4.1) 81(-13.375,-4.1) 82(-13.125,4.1) 83(-12.875,-4.1) 84(-12.625,4.1) 85(-12.375,-4.1) 86(-12.125,4.1) 87(-11.875,-4.1) 88(-11.625,4.1) 89(-11.375,-4.1) 90(-11.125,4.1) 91(-10.875,-4.1) 92(-10.625,4.1) 93(-10.375,-4.1) 94(-10.125,4.1) 95(-9.875,-4.1) 96(-9.625,4.1) 97(-9.375,-4.1) 98(-9.125,4.1) 99(-8.875,-4.1) 100(-8.625,4.1) 101(-8.375,-4.1) 102(-8.125,4.1) 103(-7.875,-4.1) 104(-7.625,4.1) 105(-7.375,-4.1) 106(-7.125,4.1) 107(-6.875,-4.1) 108(-6.625,4.1) 109(-6.375,-4.1) 110(-6.125,4.1) 111(-5.875,-4.1) 112(-5.625,4.1) 113(-5.375,-4.1) 114(-5.125,4.1) 115(-4.875,-4.1) 116(-4.625,4.1) 117(-4.375,-4.1) 118(-4.125,4.1) 119(-3.875,-4.1) 120(-3.625,4.1) 121(-3.375,-4.1) 122(-3.125,4.1) 123(-2.875,-4.1) 124(-2.625,4.1) 125(-2.375,-4.1) 126(-2.125,4.1) 127(-1.875,-4.1) 128(-1.625,4.1) 129(-1.375,-4.1) 130(-1.125,4.1) 131(-0.875,-4.1) 132(-0.625,4.1) 133(-0.375,-4.1) 134(-0.125,4.1) 135(0.125,-4.1) 136(0.375,4.1) 137(0.625,-4.1) 138(0.875,4.1) 139(1.125,-4.1) 140(1.375,4.1) 141(1.625,-4.1) 142(1.875,4.1) 143(2.125,-4.1) 144(2.375,4.1) 145(4.625,-4.1) 146(4.875,4.1) 147(5.125,-4.1) 148(5.375,4.1) 149(5.625,-4.1) 150(5.875,4.1) 151(6.125,-4.1) 152(6.375,4.1) 153(6.625,-4.1) 154(6.875,4.1) 155(7.125,-4.1) 156(7.375,4.1) 157(7.625,-4.1) 158(7.875,4.1) 159(8.125,-4.1) 160(8.375,4.1) 161(8.625,-4.1) 162(8.875,4.1) 163(9.125,-4.1) 164(9.375,4.1) 165(9.625,-4.1) 166(9.875,4.1) 167(10.125,-4.1) 168(10.375,4.1) 169(10.625,-4.1) 170(10.875,4.1) 171(11.125,-4.1) 172(11.375,4.1) 173(11.625,-4.1) 174(11.875,4.1) 175(12.125,-4.1) 176(12.375,4.1) 177(12.625,-4.1) 178(12.875,4.1) 179(13.125,-4.1) 180(13.375,4.1) 181(13.625,-4.1) 182(13.875,4.1) 183(14.125,-4.1) 184(14.375,4.1) 185(14.625,-4.1) 186(14.875,4.1) 187(15.125,-4.1) 188(15.375,4.1) 189(15.625,-4.1) 190(15.875,4.1) 191(16.125,-4.1) 192(16.375,4.1) 193(16.625,-4.1) 194(16.875,4.1) 195(17.125,-4.1) 196(17.375,4.1) 197(17.625,-4.1) 198(17.875,4.1) 199(18.125,-4.1) 200(18.375,4.1) 201(18.625,-4.1) 202(18.875,4.1) 203(19.125,-4.1) 204(19.375,4.1) 205(19.625,-4.1) 206(19.875,4.1) 207(20.125,-4.1) 208(20.375,4.1) 209(20.625,-4.1) 210(20.875,4.1) 211(21.125,-4.1) 212(21.375,4.1) 213(21.625,-4.1) 214(21.875,4.1) 215(22.125,-4.1) 216(22.375,4.1) 217(22.625,-4.1) 218(22.875,4.1) 219(23.125,-4.1) 220(23.375,4.1) 221(23.625,-4.1) 222(23.875,4.1) 223(24.125,-4.1) 224(24.375,4.1) 225(24.625,-4.1) 226(24.875,4.1) 227(25.125,-4.1) 228(25.375,4.1) 229(25.625,-4.1) 230(25.875,4.1) 231(26.125,-4.1) 232(26.375,4.1) 233(26.625,-4.1) 234(26.875,4.1) 235(27.125,-4.1) 236(27.375,4.1) 237(27.625,-4.1) 238(27.875,4.1) 239(28.125,-4.1) 240(28.375,4.1) 241(28.625,-4.1) 242(28.875,4.1) 243(29.125,-4.1) 244(29.375,4.1) 245(29.625,-4.1) 246(29.875,4.1) 247(30.125,-4.1) 248(30.375,4.1) 249(30.625,-4.1) 250(30.875,4.1) 251(31.125,-4.1) 252(31.375,4.1) 253(31.625,-4.1) 254(31.875,4.1) 255(32.125,-4.1) 256(32.375,4.1) 257(32.625,-4.1) 258(32.875,4.1) 259(33.125,-4.1) 260(33.375,4.1)
  rect 3.505x4.597 smd: 261(-33.8,-12) 262(33.8,-12)
AFTE14P-75
  round 0.356 smd: 1(0,0)
ARES2H16
  rect 0.457x0.635 smd: 1(-0.335,-0.44) 2(0.335,-0.44) 3(0.335,0.44) 4(-0.335,0.44)
ARES2H18
  rect 0.457x0.635 smd: 1(-0.335,-0.44) 2(0.335,-0.44) 3(0.335,0.44) 4(-0.335,0.44)
ARES8-CN24-MUH20
  rect 0.457x0.61 smd: 1(-0.838,-0.445) 4(0.838,-0.445) 5(0.838,0.445) 8(-0.838,0.445)
  rect 0.305x0.61 smd: 2(-0.25,-0.445) 3(0.25,-0.445) 6(0.25,0.445) 7(-0.25,0.445)
ARES8-CN24-UH20
  rect 0.457x0.61 smd: 1(-0.838,-0.445) 4(0.838,-0.445) 5(0.838,0.445) 8(-0.838,0.445)
  rect 0.305x0.61 smd: 2(-0.25,-0.445) 3(0.25,-0.445) 6(0.25,0.445) 7(-0.25,0.445)
ARES8-CN24H20
  rect 0.457x0.559 smd: 1(-0.838,-0.483) 4(0.838,-0.483) 5(0.838,0.483) 8(-0.838,0.483)
  rect 0.305x0.559 smd: 2(-0.25,-0.483) 3(0.25,-0.483) 6(0.25,0.483) 7(-0.25,0.483)
ARES8-CN24H22
  rect 0.457x0.559 smd: 1(-0.838,-0.483) 4(0.838,-0.483) 5(0.838,0.483) 8(-0.838,0.483)
  rect 0.305x0.559 smd: 2(-0.25,-0.483) 3(0.25,-0.483) 6(0.25,0.483) 7(-0.25,0.483)
BGA153G115130-2H40
  oval 0.229x0.356 smd: A1(-3.25,3.25) A2(-2.75,3.25) A3(-2.25,3.25) A4(-1.75,3.25) A5(-1.25,3.25) A6(-0.75,3.25)
  round 0.356 smd: A7(-0.25,3.25) A8(0.25,3.25) A9(0.75,3.25) A10(1.25,3.25) A11(1.75,3.25) A12(2.25,3.25) A13(2.75,3.25) A14(3.25,3.25) B2(-2.75,2.75) B3(-2.25,2.75) B4(-1.75,2.75) B5(-1.25,2.75) B6(-0.75,2.75) B7(-0.25,2.75) B8(0.25,2.75) B9(0.75,2.75) B10(1.25,2.75) B11(1.75,2.75) B12(2.25,2.75) B13(2.75,2.75) B14(3.25,2.75) C2(-2.75,2.25) C3(-2.25,2.25) C4(-1.75,2.25) C5(-1.25,2.25) C6(-0.75,2.25) C7(-0.25,2.25) C8(0.25,2.25) C9(0.75,2.25) C10(1.25,2.25) C11(1.75,2.25) C12(2.25,2.25) C13(2.75,2.25) C14(3.25,2.25) D1(-3.25,1.75) D2(-2.75,1.75) D3(-2.25,1.75) D4(-1.75,1.75) D12(2.25,1.75) D13(2.75,1.75) D14(3.25,1.75) E1(-3.25,1.25) E2(-2.75,1.25) E3(-2.25,1.25) E5(-1.25,1.25) E6(-0.75,1.25) E7(-0.25,1.25) E8(0.25,1.25) E9(0.75,1.25) E10(1.25,1.25) E12(2.25,1.25) E13(2.75,1.25) E14(3.25,1.25) F1(-3.25,0.75) F2(-2.75,0.75) F3(-2.25,0.75) F5(-1.25,0.75) F10(1.25,0.75) F12(2.25,0.75) F13(2.75,0.75) F14(3.25,0.75) G1(-3.25,0.25) G2(-2.75,0.25) G3(-2.25,0.25) G5(-1.25,0.25) G10(1.25,0.25) G12(2.25,0.25) G13(2.75,0.25) G14(3.25,0.25) H1(-3.25,-0.25) H2(-2.75,-0.25) H3(-2.25,-0.25) H5(-1.25,-0.25) H10(1.25,-0.25) H12(2.25,-0.25) H13(2.75,-0.25) H14(3.25,-0.25) J1(-3.25,-0.75) J2(-2.75,-0.75) J3(-2.25,-0.75) J5(-1.25,-0.75) J10(1.25,-0.75) J12(2.25,-0.75) J13(2.75,-0.75) J14(3.25,-0.75) K1(-3.25,-1.25) K2(-2.75,-1.25) K3(-2.25,-1.25) K5(-1.25,-1.25) K6(-0.75,-1.25) K7(-0.25,-1.25) K8(0.25,-1.25) K9(0.75,-1.25) K10(1.25,-1.25) K12(2.25,-1.25) K13(2.75,-1.25) K14(3.25,-1.25) L1(-3.25,-1.75) L2(-2.75,-1.75) L3(-2.25,-1.75) L12(2.25,-1.75) L13(2.75,-1.75) L14(3.25,-1.75) M2(-2.75,-2.25) M3(-2.25,-2.25) M4(-1.75,-2.25) M5(-1.25,-2.25) M6(-0.75,-2.25) M7(-0.25,-2.25) M8(0.25,-2.25) M9(0.75,-2.25) M10(1.25,-2.25) M11(1.75,-2.25) M12(2.25,-2.25) M13(2.75,-2.25) M14(3.25,-2.25) N2(-2.75,-2.75) N3(-2.25,-2.75) N4(-1.75,-2.75) N5(-1.25,-2.75) N6(-0.75,-2.75) N7(-0.25,-2.75) N8(0.25,-2.75) N9(0.75,-2.75) N10(1.25,-2.75) N11(1.75,-2.75) N12(2.25,-2.75) N13(2.75,-2.75) N14(3.25,-2.75) P2(-2.75,-3.25) P3(-2.25,-3.25) P4(-1.75,-3.25) P5(-1.25,-3.25) P6(-0.75,-3.25) P7(-0.25,-3.25) P8(0.25,-3.25) P9(0.75,-3.25) P10(1.25,-3.25) P11(1.75,-3.25) P12(2.25,-3.25) P13(2.75,-3.25) P14(3.25,-3.25)
  oval 0.356x0.229 smd: B1(-3.25,2.75) C1(-3.25,2.25) M1(-3.25,-2.25) N1(-3.25,-2.75) P1(-3.25,-3.25)
BGA1528M2446-1H52
  round 0.356 smd: A3(-10.396,22.315) A36(10.855,22.315) B2(-10.855,21.855) B37(11.315,21.855) C1(-11.315,21.396) CP1(-11.315,-21.855) CP37(11.315,-21.855) CR2(-10.855,-22.315) CR36(10.855,-22.315)
  round 0.33 smd: A4(-9.746,22.315) A35(10.205,22.315) B3(-10.227,21.687) B36(10.687,21.687) C2(-10.687,21.227) C37(11.315,21.205) CN1(-11.315,-21.205) CN37(11.315,-21.205) CP2(-10.687,-21.687) CP36(10.687,-21.687) CR3(-10.205,-22.315) CR35(10.205,-22.315) D1(-11.315,20.746)
  round 0.305 smd: A5(-9.096,22.292) A6(-8.232,22.315) A32(8.228,22.315) A34(9.555,22.315) AA4(-9.365,10.421) AA9(-6.21,10.624) AA24(3.679,10.481) AA26(4.606,10.481) AA34(9.365,10.719) AB3(-10.334,9.763) AB4(-9.325,9.763) AB5(-8.617,10.162) AB6(-7.967,10.162) AB7(-7.317,10.162) AB8(-6.668,10.162) AB9(-6.21,9.7) AB10(-5.753,10.162) AB25(4.142,10.025) AB27(5.069,10.025) AB28(5.719,10.025) AB29(6.369,10.025) AB30(7.019,10.025) AB31(7.669,10.025) AB32(8.32,10.025) AB33(9.04,10.068) AB34(9.69,10.068) AC4(-9.365,9.106) AC5(-8.617,9.238) AC6(-7.967,9.238) AC7(-7.317,9.238) AC8(-6.668,9.238) AC10(-5.753,9.238) AC24(3.679,9.57) AC25(4.142,9.114) AC26(4.606,9.57) AC27(5.069,9.114) AC28(5.719,9.114) AC29(6.369,9.114) AC30(7.019,9.114) AC31(7.669,9.114) AC32(8.32,9.114) AC34(9.365,9.417) AD4(-9.69,8.543) AD9(-6.21,8.776) AD24(3.679,8.658) AD26(4.606,8.658) AD33(9.04,8.809) AD35(10.245,8.809) AE4(-9.365,7.98) AE5(-8.617,8.314) AE6(-7.967,8.314) AE7(-7.317,8.314) AE8(-6.668,8.314) AE9(-6.21,7.852) AE10(-5.753,8.314) AE24(3.679,7.747) AE25(4.142,8.203) AE26(4.606,7.747) AE27(5.069,8.203) AE28(5.719,8.203) AE29(6.369,8.203) AE30(7.019,8.203) AE31(7.669,8.203) AE32(8.32,8.203) AE34(9.365,8.202) AF3(-10.334,7.322) AF4(-9.325,7.322) AF5(-8.617,7.39) AF6(-7.967,7.39) AF7(-7.317,7.39) AF8(-6.668,7.39) AF10(-5.753,7.39) AF25(4.142,7.291) AF27(5.069,7.291) AF28(5.719,7.291) AF29(6.369,7.291) AF30(7.019,7.291) AF31(7.669,7.291) AF32(8.32,7.291) AF33(9.04,7.551) AF34(9.69,7.551) AG4(-9.365,6.665) AG5(-8.617,6.467) AG6(-7.967,6.467) AG7(-7.317,6.467) AG8(-6.668,6.467) AG9(-6.21,6.929) AG10(-5.753,6.467) AG24(3.679,6.835) AG26(4.606,6.835) AG34(9.365,6.9) AH4(-9.69,6.102) AH9(-6.21,6.005) AH24(3.679,5.924) AH25(4.142,6.38) AH26(4.606,5.924) AH27(5.069,6.38) AH28(5.719,6.38) AH29(6.369,6.38) AH30(7.019,6.38) AH31(7.669,6.38) AH32(8.32,6.38) AH33(9.04,6.293) AH35(10.245,6.293) AJ4(-9.365,5.539) AJ5(-8.617,5.543) AJ6(-7.967,5.543) AJ7(-7.317,5.543) AJ8(-6.668,5.543) AJ10(-5.753,5.543) AJ25(4.142,5.468) AJ27(5.069,5.468) AJ28(5.719,5.468) AJ29(6.369,5.468) AJ30(7.019,5.468) AJ31(7.669,5.468) AJ32(8.32,5.468) AJ34(9.365,5.685) AK3(-10.334,4.882) AK4(-9.325,4.882) AK9(-6.21,5.081) AK24(3.679,5.013) AK26(4.606,5.013) AK33(9.04,5.034) AK34(9.69,5.034) AL4(-9.365,4.224) AL5(-8.617,4.619) AL6(-7.967,4.619) AL7(-7.317,4.619) AL8(-6.668,4.619) AL9(-6.21,4.157) AL10(-5.753,4.619) AL24(3.679,4.101) AL25(4.142,4.557) AL26(4.606,4.101) AL27(5.069,4.557) AL28(5.719,4.557) AL29(6.369,4.557) AL30(7.019,4.557) AL31(7.669,4.557) AL32(8.32,4.557) AL34(9.365,4.383) AM4(-9.69,3.661) AM5(-8.617,3.695) AM6(-7.967,3.695) AM7(-7.317,3.695) AM8(-6.668,3.695) AM10(-5.753,3.695) AM25(4.142,3.646) AM27(5.069,3.646) AM28(5.719,3.646) AM29(6.369,3.646) AM30(7.019,3.646) AM31(7.669,3.646) AM32(8.32,3.646) AM33(9.04,3.775) AM35(10.245,3.775) AN4(-9.365,3.098) AN5(-8.617,2.771) AN6(-7.967,2.771) AN7(-7.317,2.771) AN8(-6.668,2.771) AN9(-6.21,3.233) AN10(-5.753,2.771) AN24(3.679,3.19) AN25(4.142,2.734) AN26(4.606,3.19) AN27(5.069,2.734) AN28(5.719,2.734) AN29(6.369,2.734) AN30(7.019,2.734) AN31(7.669,2.734) AN32(8.32,2.734) AN34(9.365,3.168) AP3(-10.334,2.441) AP4(-9.325,2.441) AP9(-6.21,2.31) AP24(3.679,2.278) AP26(4.606,2.278) AP33(9.04,2.517) AP34(9.69,2.517) AR4(-9.365,1.783) AR5(-8.617,1.848) AR6(-7.967,1.848) AR7(-7.317,1.848) AR8(-6.668,1.848) AR10(-5.753,1.848) AR25(4.142,1.823) AR27(5.069,1.823) AR28(5.719,1.823) AR29(6.369,1.823) AR30(7.019,1.823) AR31(7.669,1.823) AR32(8.32,1.823) AR34(9.365,1.866) AT4(-9.69,1.22) AT9(-6.21,1.386) AT24(3.679,1.367) AT26(4.606,1.367) AT33(9.04,1.259) AT35(10.245,1.259) AU4(-9.365,0.657) AU5(-8.617,0.924) AU6(-7.967,0.924) AU7(-7.317,0.924) AU8(-6.668,0.924) AU9(-6.21,0.462) AU10(-5.753,0.924) AU24(3.679,0.456) AU25(4.142,0.911) AU26(4.606,0.456) AU27(5.069,0.911) AU28(5.719,0.911) AU29(6.369,0.911) AU30(7.019,0.911) AU31(7.669,0.911) AU32(8.32,0.911) AU34(9.365,0.65) AV3(-10.334,0) AV4(-9.325,0) AV5(-8.617,0) AV6(-7.967,0) AV7(-7.317,0) AV8(-6.668,0) AV10(-5.753,0) AV25(4.142,0) AV27(5.069,0) AV28(5.719,0) AV29(6.369,0) AV30(7.019,0) AV31(7.669,0) AV32(8.32,0) AV33(9.04,0) AV34(9.69,0) AW4(-9.365,-0.657) AW5(-8.617,-0.924) AW6(-7.967,-0.924) AW7(-7.317,-0.924) AW8(-6.668,-0.924) AW9(-6.21,-0.462) AW10(-5.753,-0.924) AW24(3.679,-0.456) AW25(4.142,-0.911) AW26(4.606,-0.456) AW27(5.069,-0.911) AW28(5.719,-0.911) AW29(6.369,-0.911) AW30(7.019,-0.911) AW31(7.669,-0.911) AW32(8.32,-0.911) AW34(9.365,-0.65) AY4(-9.69,-1.22) AY9(-6.21,-1.386) AY24(3.679,-1.367) AY26(4.606,-1.367) AY33(9.04,-1.259) AY35(10.245,-1.259) B4(-9.515,21.707) B5(-8.866,21.684) B33(8.901,22.004) B34(9.396,21.582) B35(10.037,21.687) BA4(-9.365,-1.783) BA5(-8.617,-1.848) BA6(-7.967,-1.848) BA7(-7.317,-1.848) BA8(-6.668,-1.848) BA10(-5.753,-1.848) BA25(4.142,-1.823) BA27(5.069,-1.823) BA28(5.719,-1.823) BA29(6.369,-1.823) BA30(7.019,-1.823) BA31(7.669,-1.823) BA32(8.32,-1.823) BA34(9.365,-1.866) BB3(-10.334,-2.441) BB4(-9.325,-2.441) BB9(-6.21,-2.31) BB24(3.679,-2.278) BB26(4.606,-2.278) BB33(9.04,-2.517) BB34(9.69,-2.517) BC4(-9.365,-3.098) BC5(-8.617,-2.771) BC6(-7.967,-2.771) BC7(-7.317,-2.771) BC8(-6.668,-2.771) BC9(-6.21,-3.233) BC10(-5.753,-2.771) BC24(3.679,-3.19) BC25(4.142,-2.734) BC26(4.606,-3.19) BC27(5.069,-2.734) BC28(5.719,-2.734) BC29(6.369,-2.734) BC30(7.019,-2.734) BC31(7.669,-2.734) BC32(8.32,-2.734) BC34(9.365,-3.168) BD4(-9.69,-3.661) BD5(-8.617,-3.695) BD6(-7.967,-3.695) BD7(-7.317,-3.695) BD8(-6.668,-3.695) BD10(-5.753,-3.695) BD25(4.142,-3.646) BD27(5.069,-3.646) BD28(5.719,-3.646) BD29(6.369,-3.646) BD30(7.019,-3.646) BD31(7.669,-3.646) BD32(8.32,-3.646) BD33(9.04,-3.775) BD35(10.245,-3.775) BE4(-9.365,-4.224) BE5(-8.617,-4.619) BE6(-7.967,-4.619) BE7(-7.317,-4.619) BE8(-6.668,-4.619) BE9(-6.21,-4.157) BE10(-5.753,-4.619) BE24(3.679,-4.101) BE25(4.142,-4.557) BE26(4.606,-4.101) BE27(5.069,-4.557) BE28(5.719,-4.557) BE29(6.369,-4.557) BE30(7.019,-4.557) BE31(7.669,-4.557) BE32(8.32,-4.557) BE34(9.365,-4.383) BF3(-10.334,-4.882) BF4(-9.325,-4.882) BF9(-6.21,-5.081) BF24(3.679,-5.013) BF26(4.606,-5.013) BF33(9.04,-5.034) BF34(9.69,-5.034) BG4(-9.365,-5.539) BG5(-8.617,-5.543) BG6(-7.967,-5.543) BG7(-7.317,-5.543) BG8(-6.668,-5.543) BG10(-5.753,-5.543) BG25(4.142,-5.468) BG27(5.069,-5.468) BG28(5.719,-5.468) BG29(6.369,-5.468) BG30(7.019,-5.468) BG31(7.669,-5.468) BG32(8.32,-5.468) BG34(9.365,-5.685) BH4(-9.69,-6.102) BH9(-6.21,-6.005) BH24(3.679,-5.924) BH25(4.142,-6.38) BH26(4.606,-5.924) BH27(5.069,-6.38) BH28(5.719,-6.38) BH29(6.369,-6.38) BH30(7.019,-6.38) BH31(7.669,-6.38) BH32(8.32,-6.38) BH33(9.04,-6.293) BH35(10.245,-6.293) BJ4(-9.365,-6.665) BJ5(-8.617,-6.467) BJ6(-7.967,-6.467) BJ7(-7.317,-6.467) BJ8(-6.668,-6.467) BJ9(-6.21,-6.929) BJ10(-5.753,-6.467) BJ24(3.679,-6.835) BJ26(4.606,-6.835) BJ34(9.365,-6.9) BK3(-10.334,-7.322) BK4(-9.325,-7.322) BK5(-8.617,-7.39) BK6(-7.967,-7.39) BK7(-7.317,-7.39) BK8(-6.668,-7.39) BK10(-5.753,-7.39) BK25(4.142,-7.291) BK27(5.069,-7.291) BK28(5.719,-7.291) BK29(6.369,-7.291) BK30(7.019,-7.291) BK31(7.669,-7.291) BK32(8.32,-7.291) BK33(9.04,-7.551) BK34(9.69,-7.551) BL4(-9.365,-7.98) BL5(-8.617,-8.314) BL6(-7.967,-8.314) BL7(-7.317,-8.314) BL8(-6.668,-8.314) BL9(-6.21,-7.852) BL10(-5.753,-8.314) BL24(3.679,-7.747) BL25(4.142,-8.203) BL26(4.606,-7.747) BL27(5.069,-8.203) BL28(5.719,-8.203) BL29(6.369,-8.203) BL30(7.019,-8.203) BL31(7.669,-8.203) BL32(8.32,-8.203) BL34(9.365,-8.202) BM4(-9.69,-8.543) BM9(-6.21,-8.776) BM24(3.679,-8.658) BM26(4.606,-8.658) BM33(9.04,-8.809) BM35(10.245,-8.809) BN4(-9.365,-9.106) BN5(-8.617,-9.238) BN6(-7.967,-9.238) BN7(-7.317,-9.238) BN8(-6.668,-9.238) BN10(-5.753,-9.238) BN25(4.142,-9.114) BN27(5.069,-9.114) BN28(5.719,-9.114) BN29(6.369,-9.114) BN30(7.019,-9.114) BN31(7.669,-9.114) BN32(8.32,-9.114) BN34(9.365,-9.417) BP3(-10.334,-9.763) BP4(-9.325,-9.763) BP5(-8.617,-10.162) BP6(-7.967,-10.162) BP7(-7.317,-10.162) BP8(-6.668,-10.162) BP9(-6.018,-10.162) BP11(-5.093,-9.786) BP12(-4.253,-9.786) BP14(-3.413,-9.786) BP15(-2.574,-9.786) BP16(-1.734,-9.786) BP18(-0.894,-9.786) BP19(-0.054,-9.786) BP20(0.786,-9.786) BP22(1.626,-9.786) BP23(2.465,-9.786) BP24(3.305,-9.786) BP25(4.145,-9.786) BP27(5.069,-10.025) BP28(5.719,-10.025) BP29(6.369,-10.025) BP30(7.019,-10.025) BP31(7.669,-10.025) BP32(8.32,-10.025) BP33(9.04,-10.068) BP34(9.69,-10.068) BR4(-9.365,-10.421) BR11(-5.093,-10.436) BR12(-4.253,-10.436) BR14(-3.413,-10.436) BR15(-2.574,-10.436) BR16(-1.734,-10.436) BR18(-0.894,-10.436) BR19(-0.054,-10.436) BR20(0.786,-10.436) BR22(1.626,-10.436) BR23(2.465,-10.436) BR24(3.305,-10.436) BR25(4.145,-10.436) BR34(9.365,-10.719) BT4(-9.69,-10.984) BT5(-8.617,-11.086) BT6(-7.967,-11.086) BT7(-7.317,-11.086) BT8(-6.668,-11.086) BT9(-6.018,-11.086) BT11(-5.093,-11.086) BT12(-4.253,-11.086) BT14(-3.413,-11.086) BT15(-2.574,-11.086) BT16(-1.734,-11.086) BT18(-0.894,-11.086) BT19(-0.054,-11.086) BT20(0.786,-11.086) BT22(1.626,-11.086) BT23(2.465,-11.086) BT24(3.305,-11.086) BT25(4.145,-11.086) BT27(5.069,-10.937) BT28(5.719,-10.937) BT29(6.369,-10.937) BT30(7.019,-10.937) BT31(7.669,-10.937) BT32(8.32,-10.937) BT33(9.04,-11.327) BT35(10.245,-11.327) BU4(-9.365,-11.547) BU5(-8.617,-12.009) BU6(-7.967,-12.009) BU7(-7.317,-12.009) BU8(-6.668,-12.009) BU9(-6.018,-12.009) BU11(-5.093,-11.736) BU12(-4.253,-11.736) BU14(-3.413,-11.736) BU15(-2.574,-11.736) BU16(-1.734,-11.736) BU18(-0.894,-11.736) BU19(-0.054,-11.736) BU20(0.786,-11.736) BU22(1.626,-11.736) BU23(2.465,-11.736) BU24(3.305,-11.736) BU25(4.145,-11.736) BU27(5.069,-11.848) BU28(5.719,-11.848) BU29(6.369,-11.848) BU30(7.019,-11.848) BU31(7.669,-11.848) BU32(8.32,-11.848) BU34(9.365,-11.934) BV3(-10.334,-12.204) BV4(-9.325,-12.204) BV11(-5.093,-12.386) BV12(-4.253,-12.386) BV14(-3.413,-12.386) BV15(-2.574,-12.386) BV16(-1.734,-12.386) BV18(-0.894,-12.386) BV19(-0.054,-12.386) BV20(0.786,-12.386) BV22(1.626,-12.386) BV23(2.465,-12.386) BV24(3.305,-12.386) BV25(4.145,-12.386) BV27(5.069,-12.76) BV28(5.719,-12.76) BV29(6.369,-12.76) BV30(7.019,-12.76) BV31(7.669,-12.76) BV32(8.32,-12.76) BV33(9.04,-12.585) BV34(9.69,-12.585) BW4(-9.365,-12.861) BW5(-8.617,-12.933) BW6(-7.967,-12.933) BW7(-7.317,-12.933) BW8(-6.668,-12.933) BW9(-6.018,-12.933) BW11(-5.093,-13.036) BW12(-4.253,-13.036) BW14(-3.413,-13.036) BW15(-2.574,-13.036) BW16(-1.734,-13.036) BW18(-0.894,-13.036) BW19(-0.054,-13.036) BW20(0.786,-13.036) BW22(1.626,-13.036) BW23(2.465,-13.036) BW24(3.305,-13.036) BW25(4.145,-13.036) BW34(9.365,-13.236) BY4(-9.69,-13.424) BY5(-8.617,-13.857) BY6(-7.967,-13.857) BY7(-7.317,-13.857) BY8(-6.668,-13.857) BY9(-6.018,-13.857) BY11(-5.093,-13.686) BY12(-4.253,-13.686) BY14(-3.413,-13.686) BY15(-2.574,-13.686) BY16(-1.734,-13.686) BY18(-0.894,-13.686) BY19(-0.054,-13.686) BY20(0.786,-13.686) BY22(1.626,-13.686) BY23(2.465,-13.686) BY24(3.305,-13.686) BY25(4.145,-13.686) BY27(5.069,-13.671) BY28(5.719,-13.671) BY29(6.369,-13.671) BY30(7.019,-13.671) BY31(7.669,-13.671) BY32(8.32,-13.671) BY33(9.04,-13.844) BY35(10.245,-13.844) C3(-10.059,21.059) C4(-9.213,21.132) C9(-6.305,21.245) C21(1.275,21.245) C25(3.792,21.245) C29(6.309,21.245) C33(8.826,21.245) C34(9.396,20.932) C35(10.037,21.037) C36(10.687,21.037) CA4(-9.365,-13.988) CA11(-5.093,-14.336) CA12(-4.253,-14.336) CA14(-3.413,-14.336) CA15(-2.574,-14.336) CA16(-1.734,-14.336) CA18(-0.894,-14.336) CA19(-0.054,-14.336) CA20(0.786,-14.336) CA22(1.626,-14.336) CA23(2.465,-14.336) CA24(3.305,-14.336) CA25(4.145,-14.336) CA27(5.069,-14.582) CA28(5.719,-14.582) CA29(6.369,-14.582) CA30(7.019,-14.582) CA31(7.669,-14.582) CA32(8.32,-14.582) CA34(9.365,-14.451) CB3(-10.334,-14.645) CB4(-9.325,-14.645) CB5(-8.617,-14.781) CB6(-7.967,-14.781) CB7(-7.317,-14.781) CB8(-6.668,-14.781) CB9(-6.018,-14.781) CB11(-5.093,-14.985) CB12(-4.253,-14.985) CB14(-3.413,-14.985) CB15(-2.574,-14.985) CB16(-1.734,-14.985) CB18(-0.894,-14.985) CB19(-0.054,-14.985) CB20(0.786,-14.985) CB22(1.626,-14.985) CB23(2.465,-14.985) CB24(3.305,-14.985) CB25(4.145,-14.985) CB33(9.04,-15.102) CB34(9.69,-15.102) CC4(-9.365,-15.302) CC5(-8.617,-15.705) CC6(-7.967,-15.705) CC7(-7.317,-15.705) CC8(-6.668,-15.705) CC9(-6.018,-15.705) CC11(-5.093,-15.635) CC12(-4.253,-15.635) CC14(-3.413,-15.635) CC15(-2.574,-15.635) CC16(-1.734,-15.635) CC18(-0.894,-15.635) CC19(-0.054,-15.635) CC20(0.786,-15.635) CC22(1.626,-15.635) CC23(2.465,-15.635) CC24(3.305,-15.635) CC25(4.145,-15.635) CC27(5.069,-15.494) CC28(5.719,-15.494) CC29(6.369,-15.494) CC30(7.019,-15.494) CC31(7.669,-15.494) CC32(8.32,-15.494) CC34(9.365,-15.753) CD4(-9.69,-15.865) CD11(-5.093,-16.285) CD12(-4.253,-16.285) CD14(-3.413,-16.285) CD15(-2.574,-16.285) CD16(-1.734,-16.285) CD18(-0.894,-16.285) CD19(-0.054,-16.285) CD20(0.786,-16.285) CD22(1.626,-16.285) CD23(2.465,-16.285) CD24(3.305,-16.285) CD25(4.145,-16.285) CE4(-9.365,-16.428) CE5(-8.617,-16.628) CE6(-7.967,-16.628) CE7(-7.317,-16.628) CE8(-6.668,-16.628) CE9(-6.018,-16.628) CE27(5.069,-16.405) CE28(5.719,-16.405) CE29(6.369,-16.405) CE30(7.019,-16.405) CE31(7.669,-16.405) CE32(8.32,-16.405) CE33(9.04,-16.36) CE35(10.245,-16.36) CF3(-10.334,-17.086) CF4(-9.325,-17.086) CF11(-5.37,-17.115) CF12(-4.368,-17.115) CF14(-3.33,-17.115) CF15(-2.292,-17.115) CF17(-1.254,-17.115) CF19(-0.216,-17.115) CF20(0.822,-17.115) CF22(1.86,-17.115) CF23(2.898,-17.115) CF25(3.936,-17.115) CF27(5.069,-17.317) CF28(5.719,-17.317) CF29(6.369,-17.317) CF30(7.019,-17.317) CF31(7.669,-17.317) CF32(8.32,-17.317) CF34(9.365,-16.968) CG4(-9.365,-17.743) CG5(-8.617,-17.552) CG6(-7.967,-17.552) CG7(-7.317,-17.552) CG8(-6.668,-17.552) CG9(-6.018,-17.552) CG11(-5.37,-17.765) CG12(-4.368,-17.765) CG14(-3.33,-17.765) CG15(-2.292,-17.765) CG17(-1.254,-17.765) CG19(-0.216,-17.765) CG20(0.822,-17.765) CG22(1.86,-17.765) CG23(2.898,-17.765) CG25(3.936,-17.765) CG33(9.04,-17.619) CG34(9.69,-17.619) CH4(-9.69,-18.306) CH5(-8.617,-18.476) CH6(-7.967,-18.476) CH7(-7.317,-18.476) CH8(-6.668,-18.476) CH9(-6.018,-18.476) CH11(-5.37,-18.415) CH12(-4.368,-18.415) CH14(-3.33,-18.415) CH15(-2.292,-18.415) CH17(-1.254,-18.415) CH19(-0.216,-18.415) CH20(0.822,-18.415) CH22(1.86,-18.415) CH23(2.898,-18.415) CH25(3.936,-18.415) CH27(5.069,-18.228) CH28(5.719,-18.228) CH29(6.369,-18.228) CH30(7.019,-18.228) CH31(7.669,-18.228) CH32(8.32,-18.228) CH34(9.365,-18.27) CJ4(-9.365,-18.869) CJ11(-5.37,-19.065) CJ12(-4.368,-19.065) CJ14(-3.33,-19.065) CJ15(-2.292,-19.065) CJ17(-1.254,-19.065) CJ19(-0.216,-19.065) CJ20(0.822,-19.065) CJ22(1.86,-19.065) CJ23(2.898,-19.065) CJ25(3.936,-19.065) CJ27(5.069,-19.139) CJ28(5.719,-19.139) CJ29(6.369,-19.139) CJ30(7.019,-19.139) CJ31(7.669,-19.139) CJ32(8.32,-19.139) CJ33(9.04,-18.833) CJ35(10.245,-18.878) CK1(-11.315,-19.561) CK3(-9.895,-19.83) CK4(-9.325,-19.518) CK5(-8.617,-19.4) CK6(-7.967,-19.4) CK7(-7.317,-19.4) CK8(-6.668,-19.4) CK9(-6.018,-19.4) CK11(-5.37,-19.715) CK12(-4.368,-19.715) CK14(-3.33,-19.715) CK15(-2.292,-19.715) CK17(-1.254,-19.715) CK19(-0.216,-19.715) CK20(0.822,-19.715) CK22(1.86,-19.715) CK23(2.898,-19.715) CK25(3.936,-19.715) CK33(9.15,-19.504) CK34(9.775,-19.326) CK36(10.612,-19.462) CK37(11.315,-19.374) CL2(-10.896,-20.058) CL35(10.061,-19.91) CL36(10.948,-20.019) CM1(-11.315,-20.555) CM3(-10.333,-20.383) CM4(-9.496,-20.343) CM5(-8.782,-20.365) CM6(-8.132,-20.371) CM7(-7.565,-20.69) CM8(-6.999,-20.371) CM9(-6.305,-20.365) CM10(-5.61,-20.371) CM11(-5.044,-20.69) CM12(-4.478,-20.371) CM13(-3.783,-20.365) CM14(-3.088,-20.371) CM15(-2.522,-20.69) CM16(-1.956,-20.371) CM17(-1.261,-20.365) CM18(-0.566,-20.371) CM19(0,-20.69) CM20(0.566,-20.371) CM21(1.261,-20.365) CM22(1.956,-20.371) CM23(2.522,-20.69) CM24(3.088,-20.371) CM25(3.783,-20.365) CM26(4.478,-20.371) CM27(5.044,-20.69) CM28(5.61,-20.371) CM29(6.305,-20.365) CM30(6.955,-20.365) CM31(7.531,-20.814) CM32(8.176,-20.365) CM33(8.826,-20.365) CM34(9.471,-20.286) CM35(10.447,-20.433) CM37(11.315,-20.555) CN2(-10.752,-20.88) CN3(-10.007,-20.946) CN4(-9.358,-20.978) CN5(-8.794,-21.367) CN9(-6.305,-21.245) CN13(-3.783,-21.245) CN17(-1.261,-21.245) CN21(1.261,-21.245) CN25(3.783,-21.245) CN29(6.305,-21.245) CN33(8.826,-21.245) CN34(9.396,-20.932) CN35(10.037,-21.037) CN36(10.687,-21.037) CP3(-10.037,-21.687) CP4(-9.39,-21.627) CP5(-8.942,-22.099) CP33(8.871,-21.968) CP34(9.396,-21.582) CP35(10.037,-21.687) CR4(-9.555,-22.315) CR6(-8.232,-22.315) CR32(8.321,-22.315) CR34(9.555,-22.315) D2(-10.64,20.579) D4(-9.594,20.605) D5(-8.782,20.365) D6(-8.132,20.371) D7(-7.565,20.69) D8(-6.999,20.371) D9(-6.305,20.505) D21(1.275,20.595) D22(1.883,20.365) D23(2.534,20.69) D24(3.184,20.365) D25(3.792,20.595) D26(4.4,20.365) D27(5.051,20.69) D28(5.701,20.365) D30(6.917,20.365) D31(7.568,20.69) D32(8.218,20.365) D34(9.396,20.282) D35(10.447,20.433) D37(11.315,20.555) E1(-11.315,20.096) E3(-10.008,20.089) E4(-9.365,19.995) E9(-6.21,19.862) E23(2.621,20.04) E27(5.051,20.04) E29(6.309,20.04) E31(7.568,20.04) E33(8.781,20.04) E35(10.061,19.91) E36(10.948,20.019) F2(-11.001,19.527) F3(-10.334,19.527) F4(-9.69,19.432) F5(-8.617,19.4) F6(-7.967,19.4) F7(-7.317,19.4) F8(-6.668,19.4) F21(1.149,19.715) F22(2.058,19.715) F24(3.184,19.715) F25(4.093,19.715) F33(9.15,19.504) F34(9.775,19.326) F36(10.612,19.462) F37(11.315,19.374) G1(-11.315,18.844) G4(-9.365,18.869) G9(-6.21,18.938) G21(1.149,19.065) G22(2.058,19.065) G24(3.184,19.065) G25(4.093,19.065) G27(5.069,19.139) G28(5.719,19.139) G29(6.369,19.139) G30(7.019,19.139) G31(7.669,19.139) G32(8.32,19.139) G33(9.04,18.833) G35(10.245,18.878) H4(-9.69,18.306) H5(-8.617,18.476) H6(-7.967,18.476) H7(-7.317,18.476) H8(-6.668,18.476) H9(-6.21,18.014) H21(1.149,18.415) H22(2.058,18.415) H24(3.184,18.415) H25(4.093,18.415) H27(5.069,18.228) H28(5.719,18.228) H29(6.369,18.228) H30(7.019,18.228) H31(7.669,18.228) H32(8.32,18.228) H34(9.365,18.27) J4(-9.365,17.743) J5(-8.617,17.552) J6(-7.967,17.552) J7(-7.317,17.552) J8(-6.668,17.552) J21(1.149,17.765) J22(2.058,17.765) J24(3.184,17.765) J25(4.093,17.765) J33(9.04,17.619) J34(9.69,17.619) K3(-10.334,17.086) K4(-9.325,17.086) K9(-6.21,17.09) K11(-5.322,17.115) K12(-4.38,17.115) K14(-3.438,17.115) K15(-2.496,17.115) K17(-1.554,17.115) K18(-0.613,17.115) K20(0.329,17.115) K21(1.149,17.115) K22(2.058,17.115) K24(3.184,17.115) K25(4.093,17.115) K27(5.069,17.317) K28(5.719,17.317) K29(6.369,17.317) K30(7.019,17.317) K31(7.669,17.317) K32(8.32,17.317) K34(9.365,16.968) L4(-9.365,16.428) L5(-8.617,16.628) L6(-7.967,16.628) L7(-7.317,16.628) L8(-6.668,16.628) L10(-5.753,16.628) L25(4.142,16.405) L27(5.069,16.405) L28(5.719,16.405) L29(6.369,16.405) L30(7.019,16.405) L31(7.669,16.405) L32(8.32,16.405) L33(9.04,16.36) L35(10.245,16.36) M4(-9.69,15.865) M9(-6.21,16.167) M24(3.679,15.949) M26(4.606,15.949) N4(-9.365,15.302) N5(-8.617,15.705) N6(-7.967,15.705) N7(-7.317,15.705) N8(-6.668,15.705) N9(-6.21,15.243) N10(-5.753,15.705) N25(4.142,15.494) N27(5.069,15.494) N28(5.719,15.494) N29(6.369,15.494) N30(7.019,15.494) N31(7.669,15.494) N32(8.32,15.494) N34(9.365,15.753) P3(-10.334,14.645) P4(-9.325,14.645) P5(-8.617,14.781) P6(-7.967,14.781) P7(-7.317,14.781) P8(-6.668,14.781) P10(-5.753,14.781) P24(3.679,15.038) P26(4.606,15.038) P33(9.04,15.102) P34(9.69,15.102) R4(-9.365,13.988) R9(-6.21,14.319) R24(3.679,14.127) R25(4.142,14.582) R26(4.606,14.127) R27(5.069,14.582) R28(5.719,14.582) R29(6.369,14.582) R30(7.019,14.582) R31(7.669,14.582) R32(8.32,14.582) R34(9.365,14.451) T4(-9.69,13.424) T5(-8.617,13.857) T6(-7.967,13.857) T7(-7.317,13.857) T8(-6.668,13.857) T9(-6.21,13.395) T10(-5.753,13.857) T25(4.142,13.671) T27(5.069,13.671) T28(5.719,13.671) T29(6.369,13.671) T30(7.019,13.671) T31(7.669,13.671) T32(8.32,13.671) T33(9.04,13.844) T35(10.245,13.844) U4(-9.365,12.861) U5(-8.617,12.933) U6(-7.967,12.933) U7(-7.317,12.933) U8(-6.668,12.933) U10(-5.753,12.933) U24(3.679,13.215) U26(4.606,13.215) U34(9.365,13.236) V3(-10.334,12.204) V4(-9.325,12.204) V9(-6.21,12.471) V24(3.679,12.304) V25(4.142,12.76) V26(4.606,12.304) V27(5.069,12.76) V28(5.719,12.76) V29(6.369,12.76) V30(7.019,12.76) V31(7.669,12.76) V32(8.32,12.76) V33(9.04,12.585) V34(9.69,12.585) W4(-9.365,11.547) W5(-8.617,12.009) W6(-7.967,12.009) W7(-7.317,12.009) W8(-6.668,12.009) W9(-6.21,11.548) W10(-5.753,12.009) W25(4.142,11.848) W27(5.069,11.848) W28(5.719,11.848) W29(6.369,11.848) W30(7.019,11.848) W31(7.669,11.848) W32(8.32,11.848) W34(9.365,11.934) Y4(-9.69,10.984) Y5(-8.617,11.086) Y6(-7.967,11.086) Y7(-7.317,11.086) Y8(-6.668,11.086) Y10(-5.753,11.086) Y24(3.679,11.392) Y25(4.142,10.937) Y26(4.606,11.392) Y27(5.069,10.937) Y28(5.719,10.937) Y29(6.369,10.937) Y30(7.019,10.937) Y31(7.669,10.937) Y32(8.32,10.937) Y33(9.04,11.327) Y35(10.245,11.327)
  oval 0.254x0.343 smd: A8(-6.915,22.315) A22(1.883,22.315) A24(3.184,22.315) A26(4.4,22.315) A28(5.701,22.315) A30(6.917,22.315) B6(-8.216,21.665) B7(-7.565,21.99) B8(-6.915,21.665) B9(-6.305,21.895) B21(1.275,21.895) B22(1.883,21.665) B23(2.534,21.99) B24(3.184,21.665) B25(3.792,21.895) B26(4.4,21.665) B27(5.051,21.99) B28(5.701,21.665) B29(6.309,21.895) B30(6.917,21.665) B31(7.568,21.99) B32(8.218,21.665) C6(-8.216,21.015) C7(-7.565,21.34) C8(-6.999,21.021) C22(1.883,21.015) C23(2.534,21.34) C24(3.184,21.015) C26(4.4,21.015) C27(5.051,21.34) C28(5.701,21.015) C30(6.917,21.015) C31(7.568,21.34) C32(8.218,21.015) CN6(-8.216,-21.015) CN7(-7.565,-21.34) CN8(-6.999,-21.021) CN10(-5.61,-21.021) CN11(-5.044,-21.34) CN12(-4.478,-21.021) CN14(-3.088,-21.021) CN15(-2.522,-21.34) CN16(-1.956,-21.021) CN18(-0.566,-21.021) CN19(0,-21.34) CN20(0.566,-21.021) CN22(1.956,-21.021) CN23(2.522,-21.34) CN24(3.088,-21.021) CN26(4.478,-21.021) CN27(5.044,-21.34) CN28(5.61,-21.021) CN30(6.912,-21.014) CN31(7.605,-21.461) CN32(8.219,-21.014) CP6(-8.216,-21.665) CP7(-7.565,-21.99) CP8(-6.915,-21.665) CP9(-6.305,-21.895) CP10(-5.694,-21.665) CP11(-5.044,-21.99) CP12(-4.393,-21.665) CP13(-3.783,-21.895) CP14(-3.172,-21.665) CP15(-2.522,-21.99) CP16(-1.871,-21.665) CP17(-1.261,-21.895) CP18(-0.65,-21.665) CP19(0,-21.99) CP20(0.65,-21.665) CP21(1.261,-21.895) CP22(1.871,-21.665) CP23(2.522,-21.99) CP24(3.172,-21.665) CP25(3.783,-21.895) CP26(4.393,-21.665) CP27(5.044,-21.99) CP28(5.694,-21.665) CP29(6.305,-21.895) CP30(6.983,-21.669) CP31(7.605,-22.19) CP32(8.296,-21.665) CR8(-6.915,-22.315) CR10(-5.694,-22.315) CR12(-4.393,-22.315) CR14(-3.172,-22.315) CR16(-1.871,-22.315) CR18(-0.65,-22.315) CR20(0.65,-22.315) CR22(1.871,-22.315) CR24(3.172,-22.315) CR26(4.393,-22.315) CR28(5.694,-22.315) CR30(6.912,-22.315)
  round 0.406 smd: A11(-5.322,22.315) A12(-4.38,22.315) A14(-3.438,22.315) A15(-2.496,22.315) A17(-1.554,22.315) A18(-0.613,22.315) A20(0.329,22.315) B11(-5.322,21.665) B12(-4.38,21.665) B14(-3.438,21.665) B15(-2.496,21.665) B17(-1.554,21.665) B18(-0.613,21.665) B20(0.329,21.665) C11(-5.322,21.015) C12(-4.38,21.015) C14(-3.438,21.015) C15(-2.496,21.015) C17(-1.554,21.015) C18(-0.613,21.015) C20(0.329,21.015) D11(-5.322,20.365) D12(-4.38,20.365) D14(-3.438,20.365) D15(-2.496,20.365) D17(-1.554,20.365) D18(-0.613,20.365) D20(0.329,20.365) F11(-5.322,19.715) F12(-4.38,19.715) F14(-3.438,19.715) F15(-2.496,19.715) F17(-1.554,19.715) F18(-0.613,19.715) F20(0.329,19.715) G11(-5.322,19.065) G12(-4.38,19.065) G14(-3.438,19.065) G15(-2.496,19.065) G17(-1.554,19.065) G18(-0.613,19.065) G20(0.329,19.065) H11(-5.322,18.415) H12(-4.38,18.415) H14(-3.438,18.415) H15(-2.496,18.415) H17(-1.554,18.415) H18(-0.613,18.415) H20(0.329,18.415) J11(-5.322,17.765) J12(-4.38,17.765) J14(-3.438,17.765) J15(-2.496,17.765) J17(-1.554,17.765) J18(-0.613,17.765) J20(0.329,17.765)
  oval 0.343x0.254 smd: AA1(-11.315,10.421) AA2(-10.665,10.421) AA3(-10.015,10.421) AA35(10.015,10.719) AA36(10.665,10.719) AA37(11.315,10.719) AB2(-10.99,9.763) AB35(10.34,10.068) AB36(10.99,10.068) AC1(-11.315,9.106) AC2(-10.665,9.106) AC3(-10.015,9.106) AC35(10.015,9.417) AC36(10.665,9.417) AC37(11.315,9.417) AD3(-10.34,8.543) AD36(10.895,8.809) AE1(-11.315,7.98) AE2(-10.665,7.98) AE3(-10.015,7.98) AE35(10.015,8.202) AE36(10.665,8.202) AE37(11.315,8.202) AF2(-10.99,7.322) AF35(10.34,7.551) AF36(10.99,7.551) AG1(-11.315,6.665) AG2(-10.665,6.665) AG3(-10.015,6.665) AG35(10.015,6.9) AG36(10.665,6.9) AG37(11.315,6.9) AH3(-10.34,6.102) AH36(10.895,6.293) AJ1(-11.315,5.539) AJ2(-10.665,5.539) AJ3(-10.015,5.539) AJ35(10.015,5.685) AJ36(10.665,5.685) AJ37(11.315,5.685) AK2(-10.99,4.882) AK35(10.34,5.034) AK36(10.99,5.034) AL1(-11.315,4.224) AL2(-10.665,4.224) AL3(-10.015,4.224) AL35(10.015,4.383) AL36(10.665,4.383) AL37(11.315,4.383) AM3(-10.34,3.661) AM36(10.895,3.775) AN1(-11.315,3.098) AN2(-10.665,3.098) AN3(-10.015,3.098) AN35(10.015,3.168) AN36(10.665,3.168) AN37(11.315,3.168) AP2(-10.99,2.441) AP35(10.34,2.517) AP36(10.99,2.517) AR1(-11.315,1.783) AR2(-10.665,1.783) AR3(-10.015,1.783) AR35(10.015,1.866) AR36(10.665,1.866) AR37(11.315,1.866) AT3(-10.34,1.22) AT36(10.895,1.259) AU1(-11.315,0.657) AU2(-10.665,0.657) AU3(-10.015,0.657) AU35(10.015,0.65) AU36(10.665,0.65) AU37(11.315,0.65) AV2(-10.99,0) AV35(10.34,0) AV36(10.99,0) AW1(-11.315,-0.657) AW2(-10.665,-0.657) AW3(-10.015,-0.657) AW35(10.015,-0.65) AW36(10.665,-0.65) AW37(11.315,-0.65) AY3(-10.34,-1.22) AY36(10.895,-1.259) BA1(-11.315,-1.783) BA2(-10.665,-1.783) BA3(-10.015,-1.783) BA35(10.015,-1.866) BA36(10.665,-1.866) BA37(11.315,-1.866) BB2(-10.99,-2.441) BB35(10.34,-2.517) BB36(10.99,-2.517) BC1(-11.315,-3.098) BC2(-10.665,-3.098) BC3(-10.015,-3.098) BC35(10.015,-3.168) BC36(10.665,-3.168) BC37(11.315,-3.168) BD3(-10.34,-3.661) BD36(10.895,-3.775) BE1(-11.315,-4.224) BE2(-10.665,-4.224) BE3(-10.015,-4.224) BE35(10.015,-4.383) BE36(10.665,-4.383) BE37(11.315,-4.383) BF2(-10.99,-4.882) BF35(10.34,-5.034) BF36(10.99,-5.034) BG1(-11.315,-5.539) BG2(-10.665,-5.539) BG3(-10.015,-5.539) BG35(10.015,-5.685) BG36(10.665,-5.685) BG37(11.315,-5.685) BH3(-10.34,-6.102) BH36(10.895,-6.293) BJ1(-11.315,-6.665) BJ2(-10.665,-6.665) BJ3(-10.015,-6.665) BJ35(10.015,-6.9) BJ36(10.665,-6.9) BJ37(11.315,-6.9) BK2(-10.99,-7.322) BK35(10.34,-7.551) BK36(10.99,-7.551) BL1(-11.315,-7.98) BL2(-10.665,-7.98) BL3(-10.015,-7.98) BL35(10.015,-8.202) BL36(10.665,-8.202) BL37(11.315,-8.202) BM3(-10.34,-8.543) BM36(10.895,-8.809) BN1(-11.315,-9.106) BN2(-10.665,-9.106) BN3(-10.015,-9.106) BN35(10.015,-9.417) BN36(10.665,-9.417) BN37(11.315,-9.417) BP2(-10.99,-9.763) BP35(10.34,-10.068) BP36(10.99,-10.068) BR1(-11.315,-10.421) BR2(-10.665,-10.421) BR3(-10.015,-10.421) BR35(10.015,-10.719) BR36(10.665,-10.719) BR37(11.315,-10.719) BT3(-10.34,-10.984) BT36(10.895,-11.327) BU1(-11.315,-11.547) BU2(-10.665,-11.547) BU3(-10.015,-11.547) BU35(10.015,-11.934) BU36(10.665,-11.934) BU37(11.315,-11.934) BV2(-10.99,-12.204) BV35(10.34,-12.585) BV36(10.99,-12.585) BW1(-11.315,-12.861) BW2(-10.665,-12.861) BW3(-10.015,-12.861) BW35(10.015,-13.236) BW36(10.665,-13.236) BW37(11.315,-13.236) BY3(-10.34,-13.424) BY36(10.895,-13.844) CA1(-11.315,-13.988) CA2(-10.665,-13.988) CA3(-10.015,-13.988) CA35(10.015,-14.451) CA36(10.665,-14.451) CA37(11.315,-14.451) CB2(-10.99,-14.645) CB35(10.34,-15.102) CB36(10.99,-15.102) CC1(-11.315,-15.302) CC2(-10.665,-15.302) CC3(-10.015,-15.302) CC35(10.015,-15.753) CC36(10.665,-15.753) CC37(11.315,-15.753) CD3(-10.34,-15.865) CE1(-11.315,-16.428) CE2(-10.665,-16.428) CE3(-10.015,-16.428) CE36(10.895,-16.36) CF2(-10.99,-17.086) CF35(10.015,-16.968) CF36(10.665,-16.968) CF37(11.315,-16.968) CG1(-11.315,-17.743) CG2(-10.665,-17.743) CG3(-10.015,-17.743) CG35(10.34,-17.619) CG36(10.99,-17.619) CH3(-10.34,-18.306) CH35(10.015,-18.27) CH36(10.665,-18.27) CH37(11.315,-18.27) CJ1(-11.315,-18.869) CJ2(-10.665,-18.869) CJ3(-10.015,-18.869) CJ36(10.895,-18.878) CK2(-10.485,-19.555) G2(-10.665,18.869) G3(-10.015,18.869) G36(10.895,18.878) H3(-10.34,18.306) H35(10.015,18.27) H36(10.665,18.27) H37(11.315,18.27) J1(-11.315,17.743) J2(-10.665,17.743) J3(-10.015,17.743) J35(10.34,17.619) J36(10.99,17.619) K2(-10.99,17.086) K35(10.015,16.968) K36(10.665,16.968) K37(11.315,16.968) L1(-11.315,16.428) L2(-10.665,16.428) L3(-10.015,16.428) L36(10.895,16.36) M3(-10.34,15.865) N1(-11.315,15.302) N2(-10.665,15.302) N3(-10.015,15.302) N35(10.015,15.753) N36(10.665,15.753) N37(11.315,15.753) P2(-10.99,14.645) P35(10.34,15.102) P36(10.99,15.102) R1(-11.315,13.988) R2(-10.665,13.988) R3(-10.015,13.988) R35(10.015,14.451) R36(10.665,14.451) R37(11.315,14.451) T3(-10.34,13.424) T36(10.895,13.844) U1(-11.315,12.861) U2(-10.665,12.861) U3(-10.015,12.861) U35(10.015,13.236) U36(10.665,13.236) U37(11.315,13.236) V2(-10.99,12.204) V35(10.34,12.585) V36(10.99,12.585) W1(-11.315,11.547) W2(-10.665,11.547) W3(-10.015,11.547) W35(10.015,11.934) W36(10.665,11.934) W37(11.315,11.934) Y3(-10.34,10.984) Y36(10.895,11.327)
