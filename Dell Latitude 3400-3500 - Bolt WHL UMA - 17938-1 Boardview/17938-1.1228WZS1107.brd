# Allegro board 17938-1.1228WZS1107.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
RTC_3P3_EN_G: length 7.7
  BOTTOM w0.102: Q2510.D 161.65,80.11 163.23,81.69 163.23,82.05 162.97,82.32 162.09,82.32 161.91,82.49 161.53,82.49 160.8,81.76 v2(159.9,81.76) 159.67,81.54 R2506.1
RTC_DET#: length 51.6
  TOP w0.102: v1(142.08,88.36) 142.1,88.34 142.6,88.34 142.81,88.56 142.81,92.86 138.34,97.33 138.34,99.58 137.09,100.84 v1(137.09,100.85) ; v2(123.82,93.54) v1(124.23,93.14)
  L3 w0.102: v1(142.08,88.36) 142.07,88.38 142.07,88.4 140.41,90.06 135.02,90.06 132.88,92.19 128.39,92.19 127.41,93.17 127.41,93.57 127.09,93.9 124.99,93.9 v1(124.23,93.14)
  BOTTOM w0.076: CPU1.CP22 122.25,93.58 122.26,93.58 122.44,93.68 122.75,93.68 122.97,93.46 123.76,93.46 124.08,93.14 v1(124.23,93.14)
  BOTTOM w0.102: v1(137.09,100.85) 137.09,100.89 141.1,104.9 141.1,107.21 R1554.2 140.69,107.75 140.29,108.15 140.29,109.88 141.07,110.67 Q2505.D
RTC_RST#: length 82.3
  TOP w0.102: v1(141.66,86.67) 141.96,86.97 v2(141.96,87.3) 141.84,87.43 141.66,87.43 141.41,87.68 141.41,87.68 141.13,87.96 141.13,90.06 ED1802.2 139.92,90.35 G1801.2 138.86,90.02 138.1,90.02 C1806.1 137.84,90.2 137.33,90.7 RN1801.4
  L3 w0.102: v1(141.66,86.67) 141.66,86.43 142.23,85.86 142.29,85.79 142.6,85.48 142.6,85.47 142.73,85.35 142.73,85.22 143.95,83.99 145.09,83.99 148.05,81.03 148.05,78.94 153.95,73.03 v1(154.48,73.03)
  BOTTOM w0.076: CPU1.BR34 110.97,85.71 111.29,85.4 111.29,84.34 111.32,84.29 111.34,84.25 111.39,84.15 111.39,83.84 111.83,83.4 111.83,82.59
  BOTTOM w0.102: v1(154.48,73.03) 152.38,70.93 152.38,70.84 152.11,70.58 125.56,70.58 120.67,75.47 118.14,75.47 115.7,77.91 115.7,78.67 114.74,79.64 113.9,79.64 111.83,81.71 111.83,82.59
RTCRST_ON: length 174.4
  TOP w0.102: v1(25.43,65.1) 25.88,64.65 25.88,60.8 25.57,60.49 U2401.31
  L3 w0.102: v1(25.43,65.1) 25.43,66.34 28.81,69.72 28.99,69.72 28.99,69.72 v1(29,69.72)
  BOTTOM w0.102: v1(29,69.72) 29.02,69.7 29.03,69.7 29.64,69.09 31.3,69.09 31.48,68.91 31.98,68.91 40.9,68.91 42.22,67.59 45.5,67.59 49.04,64.04 73.78,64.04 78.39,68.66 122.07,68.66 123.98,66.76 146.51,66.76 149.37,63.89 153.42,63.89 154.16,64.62 154.16,68.05 155.39,69.29 156.68,69.29 157.86,70.48 157.86,73.86 154.46,77.27 v2(154.46,79.48) 154.46,82.49 154.85,82.88 155.08,82.88 155.34,83.15 157.23,83.15 Q2507.G 157.47,83.47 R2518.1 R2567.1 158.32,82.58 158.75,82.14 159.63,82.14 160.26,82.77 D2502.K
RUNPWROK: length 366.3
  TOP w0.102: v1(32.97,61.15) 32.84,61.15 31.16,59.47 U2401.48 31.16,56.98 ED1706.2 ; R4011.2 v1(84.9,41.58)
  L3 w0.102: v1(32.97,61.15) 32.97,60.02 30.29,57.34 30.29,55.49 28.89,54.09 28.89,53.83 26.89,51.82 26.89,49.68 25.42,48.21 25.42,42.36 25.45,42.33 25.45,40.45 27.38,38.52 27.38,38.17 29.5,36.05 33.78,36.05 36.53,33.3 56.55,33.3 57.99,34.75 60.83,34.75 62.22,36.14 70.86,36.14 74.95,40.23 83.55,40.23 v1(84.9,41.58) 86.02,40.46 97.11,40.46 99.59,42.94 100.84,42.94 101.95,44.05 102.53,44.05 102.59,43.99 v1(102.6,43.99) ; v1(144.88,143.89) 145.06,143.71 145.06,136.6 141.56,133.1 141.56,132.68 141.54,132.66 141.54,129.85 140.9,129.2 v1(140.9,127.59)
  L4 w0.102: v1(140.9,127.59) 140.9,122.91 143.68,120.13 143.68,118.66 144.07,118.26 144.35,118.26 144.86,117.76 144.86,117.73 145.62,116.97 145.62,113.18 145.34,112.9 145.34,110.59 149.63,106.31 149.63,102.51 151.13,101 151.13,100.46 152.17,99.42 152.17,99.19 152.68,98.68 152.68,96.68 155.03,94.34 155.83,94.34 156.72,93.45 156.72,93.07 156.64,92.99 156.64,92.61 159.16,90.1 160.09,90.1 162.58,87.61 162.58,87.08 162.12,86.62 162.12,82.83 162.17,82.78 162.17,81.03 173.55,69.65 173.71,69.65 173.71,69.65 174.22,69.65 176.83,67.04 177,67.04 177.44,67.04 178.69,65.79 v1(178.69,65.32)
  BOTTOM w0.102: v1(102.6,43.99) 102.6,44 102.66,44.06 102.66,44.53 102.84,44.71 102.84,45.81 102.37,46.28 102.37,51.66 104.41,53.71 109.94,53.71 109.98,53.75 110.29,53.75 111.15,54.62 144.76,54.62 145.23,54.15 147.12,54.15 147.56,53.71 156.8,53.71 157.62,54.54 164.55,54.54 168.99,58.98 168.99,61.33 169.71,62.07 170.83,63.19 170.83,65.14 171.21,65.52 173.34,65.52 174.04,64.82 178.19,64.82 v1(178.69,65.32) ; v1(144.88,143.89) 144.88,144.3 142.7,146.48 140.59,146.48 140.21,146.1 139.51,146.1 138.87,146.74 138.36,146.74 R4005.2 137.93,146.38 R4002.1 ; v1(84.9,41.58) 84.43,41.11 D4002.A 86.39,40.26 D4003.A ; R1716.1 105.64,116.79 105.17,117.26 105.17,118.02 105.44,118.29 106.2,118.29 106.23,118.31 106.25,118.31 106.88,118.95 106.88,119.28 107.55,119.94 111.74,119.94 112.6,119.08 113.05,119.08 119.18,119.08 119.79,119.69 119.79,122.66 123.68,126.54 126.27,126.54 126.95,127.23 v2(138.3,127.23) 140.69,127.23 140.9,127.43 v1(140.9,127.59)
SA0_CHA_DIM0: length 7.1
  TOP w0.102: v1(96.69,45.94) 96.98,46.23 R1205.1 97.62,47.98 R1204.1 98.38,48.29 v2(98.53,48.44)
  BOTTOM w0.102: DM1.256 96.08,45.54 96.48,45.94 v1(96.69,45.94)
SA0_CHB_DIM0: length 5.3
  TOP w0.102: R1303.1 173.64,45.82 173.76,45.7 v1(173.79,45.7) 173.79,45.72 173.93,45.86 R1302.1
  BOTTOM w0.102: v1(173.79,45.7) 173.76,45.7 173.73,45.73 173.49,45.73 172.28,44.52 DM2.256
SA1_CHA_DIM0: length 4.2
  TOP w0.102: R1208.1 97.15,45.75 v1(96.7,45.3) 96.7,44.8 R1210.1
  BOTTOM w0.102: v1(96.7,45.3) 96.68,45.28 96.68,44.73 97.08,44.33 DM1.260
SA1_CHB_DIM0: length 5.6
  TOP w0.102: R1307.1 173.71,45.04 173.74,45.06 v1(173.79,45.06) 173.82,45.06 174.05,45.28 174.42,45.28 R1306.1 174.59,44.42 v2(174.37,44.2)
  BOTTOM w0.102: v1(173.79,45.06) 173.96,45.06 174.4,44.62 174.4,44.03 DM2.260
SA2_CHA_DIM0: length 4.5
  TOP w0.102: R1211.1 R1212.1 74.88,42.18 v2(74.53,42.53) 74.35,42.53 74.15,42.32 v1(74.15,41.61)
  BOTTOM w0.102: v1(74.15,41.61) 74.15,41.63 73.58,42.2 73.58,42.9 DM1.166
SA2_CHB_DIM0: length 6.2
  TOP w0.102: v1(149.71,45.02) 149.85,44.88 150.37,44.88 150.73,44.53 150.73,44.04 150.6,43.92 R1311.1 150.65,43.69 v2(151.62,43.69) 151.77,43.84 R1310.1
  BOTTOM w0.102: DM2.166 149.78,44.95 v1(149.71,45.02)
SATA1_ODD_PRSNT#: length 140.9
  TOP w0.102: R1617.2 193.53,36.21 v2(193.53,36.68) 193.26,36.95 193.11,36.95 192.57,37.48 191.58,37.48 191.01,38.05 v1(190.35,38.05) 190.3,38.05 190.25,38 R6004.1
  L4 w0.102: v1(190.35,38.05) 190.3,38.05 189.77,37.52 189.77,37.16 188.73,36.12 188.73,35.36 186.17,32.8 182.92,32.8 181.84,31.73 173.23,31.73 172.95,32 172.95,34.64 174.01,35.7 174.96,36.65 174.98,36.67 175.83,39.03 176.66,41.35 176.66,44.36 177.73,45.43 177.73,50.66 177.7,50.69 177.7,50.77 167.55,60.92 167.55,61.49 167.48,61.56 167.48,61.57 160.66,68.39 160.66,69.28 158.49,71.45 158.49,73.45 152.76,79.18 152.76,83.91 152.37,84.31 152.37,84.98 149.49,87.86 148.91,87.86 139.39,97.37 139.39,101.61 134.9,106.1 134.2,106.1 134.2,106.09 133.69,106.09 133.2,106.58 130.41,106.58 129.92,106.09 127.73,106.09 123.68,106.53 123,106.53 121.85,105.38 121.85,103.37 120.09,101.62 v1(120.09,101.62)
  BOTTOM w0.102: CPU1.CM10 120.09,101.44 v1(120.09,101.62)
SATA_LED#: length 265.3
  TOP w0.102: v1(29.44,26.6) 28.34,25.49 D6401.1
  L4 w0.102: v1(126.5,102.5) 127.16,103.16 130.42,103.16 131.68,101.91 133.28,101.91 136.85,98.33 136.85,96.86 140.04,93.68 140.04,93.03 144.4,88.67 144.57,88.67 144.92,88.32 144.94,88.32 145.31,87.95 145.49,87.95 149.85,83.59 149.85,79.96 150.43,79.37 150.43,77.9 152.5,75.83 152.86,75.83 156.47,72.23 156.47,70.58 158.61,68.43 158.61,67.62 165.42,60.81 165.42,60.06 174.77,50.71 174.77,48.84 175.42,48.2 175.42,45.93 174.68,45.19 174.68,41.7 173.53,38.49 173.51,38.44 173.26,37.76 170.27,34.76 167.88,34.76 167.53,35.11 164.69,35.11 162.65,35.11 162.09,34.55 159.72,34.55 157.83,32.67 144.82,32.67 144.25,33.24 135.29,33.24 133.51,35.02 130.8,35.02 130.14,35.68 129.25,35.68 127.62,37.31 124.74,37.31 122.32,39.73 121.54,39.73 120.52,40.76 120.52,41.38 119.76,42.14 112.6,42.14 111.44,40.98 111.44,40.08 104.46,33.1 101.67,33.1 100.67,34.1 76.57,34.1 73.82,31.35 54.38,31.35 53.44,31.35 52.9,30.82 42.56,30.82 41.76,30.02 35.94,30.02 32.85,26.93 29.77,26.93 v1(29.44,26.6)
  BOTTOM w0.076: CPU1.CN7 121.87,102.7 122.12,102.61 122.36,102.61 122.39,102.62 122.41,102.64 123.63,102.64 124.01,102.26 126.26,102.26
  BOTTOM w0.102: R1606.2 135.36,104.48 v2(133.76,104.48) 131.63,104.48 130.79,103.63 127.54,103.63 126.52,102.62 126.52,102.52 v1(126.5,102.5) 126.26,102.26
SATA_LED#_D: length 38.7
  TOP w0.102: 30.48,32.28 30.48,32.13 30.81,31.81 30.81,31.04 30.2,30.43 28.73,30.43 28.12,29.82 27.23,29.82 v2(27.03,29.62) 27.36,29.29 27.36,27.21 27.56,27 27.56,25.02 28.08,24.5 28.08,23.81 27.65,23.38 D6401.3 26.73,23.85 v1(26.34,23.85)
  BOTTOM w0.102: Q6401.S 20.28,33.99 20.28,31.66 17.83,29.21 15.23,29.21 14.7,28.68 14.7,27.9 17.09,25.51 17.09,24.43 18.33,23.19 25.68,23.19 v1(26.34,23.85)
SATA_ODD_DA#_C: length 4.1
  TOP w0.102: v1(185.77,33.8) 185.68,33.71 TP6001.1
  BOTTOM w0.102: v1(185.77,33.8) ODD1.16
SATA_ODD_PRSNT#_R: length 6.1
  TOP w0.102: R6004.2 188.24,37.16 189.31,37.16 AFTP6005.1 189.62,37.47 190.22,37.47 190.27,37.42 v1(190.29,37.42)
  BOTTOM w0.102: v1(190.29,37.42) 188.27,37.42 187.38,38.3 ODD1.7
SD_RCOMP: length 2.5
  TOP w0.203: R1901.1 120.12,87 119.81,86.69 v1(119.81,86.67)
  BOTTOM w0.203: CPU1.CK33 119.76,86.61 v1(119.81,86.67) 120.54,85.94 CPU1.CM34
SD_READ_MODE#: length 141.9
  TOP w0.102: AFTP6610.1 193.46,41.94 192.12,43.28 191.86,43.28 191.83,43.31 v1(191.82,43.31)
  L2SGND w0.102: v1(191.82,43.31) 192.55,44.04 198.08,44.04 198.4,43.71 199.14,43.71 200.1,44.67 204.67,44.67 204.98,44.36 205.34,44.36 205.84,44.87 206.87,44.87 207.52,45.52 207.52,47.16 208.68,48.31 208.68,49.34 208.39,49.63 208.39,51.53 206.96,52.96 205.38,52.96 204.8,53.54 204.8,53.54 204.7,53.65 204.3,53.65 203.89,54.05 199.57,54.05 198.11,55.51 179.92,55.51 176.74,55.51 175.97,54.74 172.19,54.74 157.38,69.55 157.38,71.31 152.99,75.69 150.35,75.69 146.7,79.34 146.7,80.26 146.4,80.56 146.4,81.05 145.75,81.69 145.03,81.69 145.02,81.67 144.5,81.67 144.48,81.69 144.21,81.69 141.49,84.42 137.76,84.42 134.65,87.53 127.91,87.53 127.41,87.03 120.51,87.03 120.24,87.31 118.66,87.31 117.54,86.18 116.03,86.18 115.25,86.96 v1(115.25,87.99)
  BOTTOM w0.102: R6601.1 191.31,41.6 191.88,42.18 191.88,43.25 v1(191.82,43.31) ; v1(115.25,87.99) 115.25,88.07 115.04,88.28 CPU1.CA30
SD_READ_MODE#_R: length 15.3
  BOTTOM w0.102: R6601.2 v2(191.31,39.5) 191.31,39.3 191.81,38.8 192.8,38.8 193.81,37.79 193.81,37.02 194.66,36.17 196.83,36.17 197.73,37.08 201.46,37.08 202.3,37.91 IOBD1.3
SIO_EXT_SMI#: length 14.9
  BOTTOM w0.102: R402.1 135.59,105.41 134.95,104.78 134.39,104.78 134.31,104.85 131.72,104.85 130.8,103.94 127.33,103.94 125.85,102.45 124.18,102.45 123.77,102.87 CPU1.CP7
SIO_EXT_WAKE#: length 195.2
  TOP w0.089: v1(31.04,71.65) 30.94,71.75 30.94,72.3 30.47,72.78 30.43,72.78 29.96,73.25 U2401.116
  L4 w0.089: v1(125.64,99.24) 125.64,99.28 125.57,99.35 125.57,99.66 126.14,100.23 127.74,100.23 129,101.48 133.14,101.48 136.45,98.16 136.45,96.93 136.45,96.7 139.64,93.51 139.64,92.87 144.23,88.27 144.41,88.27 144.76,87.92 144.77,87.92 145.14,87.55 145.32,87.55 149.16,83.71 149.16,83.26 149.45,82.96 149.45,79.79 150.03,79.21 150.03,78.61 150.03,78.61 150.03,77.58 v1(152.71,74.9)
  BOTTOM w0.076: CPU1.CN12 121.38,99.65 121.46,99.54 121.62,99.49 121.82,99.43 122.11,99.43 122.4,99.27 122.76,99.27 123.01,99.46 123.35,99.46 123.51,99.3 124.37,99.3 124.66,99.6 125.28,99.6 v1(125.64,99.24)
  BOTTOM w0.089: v1(152.71,74.9) 154.09,74.9 156.54,72.45 156.54,71.03 156.12,70.62 154.84,70.62 153.27,69.04 152.26,69.04 151.91,69.39 125.07,69.39 123.17,71.29 76.52,71.29 72.13,66.9 55.08,66.9 49.96,72.02 48.94,72.02 47.63,70.71 46.07,70.71 45.87,70.91 45.78,70.91 45.76,70.94 37.78,70.94 37.17,71.55 35.46,71.55 35.4,71.48 31.26,71.48 31.09,71.65 v1(31.04,71.65) ; R2041.2 129.22,100.88 128.95,100.62 128.95,99.79 128.38,99.22 v2(127.87,99.22) 127.45,98.81 126.07,98.81 v1(125.64,99.24)
SIO_PWRBTN#: length 288.5
  TOP w0.102: TP1706.1 112.7,89.3 v1(112.53,89.3) ; v1(27.86,69.86) 27.86,69.78 27.84,69.76 27.84,67.9 29.57,66.17 31.4,66.17 33.77,63.79 33.77,60.74 32.75,59.73 U2401.52
  L4 w0.102: v1(112.53,89.3) 112.05,88.82 112.05,86.84 112.01,86.8 112.01,86.38 113.79,84.59 114.8,84.59 115.78,83.61 116.8,83.61 117.55,82.86 119.84,82.86 120.07,82.63 121.18,82.63 121.92,81.89 121.92,81.54 145.59,57.87 151.56,57.87 158.85,50.58 158.85,43.7 157.24,42.09 132.5,42.09 132.34,42.25 125.17,42.25 122.52,44.9 108.43,44.9 106.81,43.28 105.08,43.28 104.57,43.79 103.28,43.79 103.05,43.56 102.39,43.56 102.17,43.78 101.56,43.78 100.84,43.05 99.65,43.05 99.24,43.46 98.67,43.46 97.65,42.44 95.81,42.44 95.55,42.18 94,42.18 93.9,42.09 92.09,42.09 91.82,42.33 83.04,42.33 82.64,41.92 81.66,41.92 80.86,41.12 73.57,41.12 73.56,41.12 73.2,41.12 73.2,41.12 67.27,41.12 67.26,41.14 64.77,41.14 64.68,41.05 61.14,41.05 59.66,42.53 36.7,42.53 35.74,41.56 35.74,40.74 36.3,40.17 36.3,39.48 36.38,39.41 36.38,38.07 36.3,37.98 36.3,37.69 35.63,37.02 35.63,34.22 31.92,30.51 31.92,29.06 31.23,28.37 29.44,28.37 28.35,29.47 26.75,29.47 26.67,29.38 21.96,29.38 19.76,31.58 19.76,35.47 19.06,36.17 19.06,39.3 18.77,39.59 18.77,40.11 18.32,40.56 18.32,50.16 18.87,50.71 18.87,56.67 23.58,61.38 23.58,65.68 25.72,67.82 25.72,68.28 25.97,68.53 26.43,68.53 27.76,69.86 v1(27.86,69.86)
  BOTTOM w0.102: CPU1.BU28 112.53,89.32 112.53,89.29 v1(112.53,89.3)
SIO_RCIN#: length 23.3
  TOP w0.102: v2(113.07,87.95) 113.42,88.3 v1(113.42,88.63) ; v1(125.34,79.74) 125.34,79.67 125.03,79.36 125.03,76.72 R1820.2
  L4 w0.102: v1(125.34,79.74) 124.73,79.74 122.86,81.61 122.86,82.62 122.23,83.25 122.23,83.49 121.98,83.74 119.73,83.93 116,83.93 114.84,85.09 114.11,85.09 113.07,86.13 113.07,88.27 v1(113.42,88.63)
  BOTTOM w0.102: CPU1.BV29 113.4,88.71 v1(113.42,88.63)
SIO_SLP_A#: length 3.3
  BOTTOM w0.089: CPU1.BU37 112.19,83.82 112.41,83.59 112.41,82.56 112.86,82.12 112.86,81.41 TP1705.1
SIO_SLP_S0#: length 614.1
  TOP w0.089: v1(90.86,41.59) 90.66,41.38 R4040.1 ; v1(153.79,138.63) 153.58,138.41 152.73,138.41 R1739.1 151.76,139.38 149.02,139.38 148.39,140.01 v1(147.35,140.01)
  L3 w0.089: v1(153.79,138.63) 153.79,138.58 154.08,138.29 154.08,122.35 158.58,117.86 158.58,117.2 159.18,116.59 159.18,113.35 159.11,113.28 159.11,112.96 158.82,112.66 158.82,111.44 157.61,110.24 157.61,108.18 156.98,107.55 156.86,107.55 154.84,105.53 154.84,105.1 154.52,104.77 154.52,97.29 154.6,97.21 154.6,96.8 158.14,93.26 158.14,92.18 159.33,90.99 160.38,90.99 163.22,88.16 163.22,86.81 162.99,86.59 162.99,85.69 163.44,85.24 163.44,84.07 164.29,83.22 164.29,81.48 173.81,71.96 173.81,71.27 173.71,71.17 173.71,70.65 175.63,68.73 175.69,68.73 175.81,68.61 177.7,68.61 178.54,67.77 181.98,67.77 183,68.79 187.08,68.79 189.29,66.58 208.71,66.58 209.62,67.49 217.43,67.49 220.25,64.67 220.25,64.63 222.04,62.83 222.04,50.18 220.08,48.21 219.78,48.21 219.17,47.61 219.17,43.41 216.77,41.01 215.4,41.01 212.98,38.59 207.88,38.59 207.45,38.17 200.99,38.17 200.85,38.03 196.6,38.03 195.97,37.4 195.62,37.4 194.8,38.22 192.9,38.22 192.64,38.47 190.18,38.47 186.04,34.33 183.55,34.33 181.57,36.31 170.99,36.31 170.17,37.13 168.62,37.13 167.51,36.02 161.12,36.02 157.51,32.42 148.45,32.42 147.3,33.57 131.93,33.57 130.05,35.45 128.99,35.45 127.35,37.09 127.35,37.09 127.24,37.2 126.42,37.2 124.01,39.61 120.76,39.61 119.72,40.64 110.45,40.64 108.32,38.51 106.79,38.51 106.53,38.25 105.71,38.25 104.64,37.18 103.9,37.18 103.28,36.56 102.37,36.56 100.79,34.98 93.84,34.98 93.51,34.65 92.06,34.65 91.31,33.9 78.24,33.9 73.68,29.34 55.62,29.34 55.26,28.99 46.2,28.99 45.43,29.76 42.54,29.76 41.72,28.94 41.44,28.94 41.41,28.94 35.09,28.94 34.32,28.17 v1(28.71,28.17) 28.47,27.94 28.47,27.89 28.22,27.65 28.12,27.54 27.66,27.54 27.66,27.54 27.52,27.54 27.06,28 25.65,28 24.96,28.68 24.66,28.68 24.66,28.68 23.97,28.68 21.42,31.23 21.42,31.28 21.12,31.58 21.12,37.71 21.64,38.24 21.82,38.41 21.82,40.53 21.48,40.87 19.42,40.87 18.9,41.39 18.9,43.55 18.07,44.38 18.07,44.66 18.07,44.72 18.07,45.86 18.07,45.86 18.07,46.19 18.07,50.03 18.84,50.79 18.84,51.35 18.81,51.37 18.81,51.39 18.67,51.53 18.67,56.7 18.67,56.85 18.67,57.91 18.58,58 18.58,59.3 18.55,59.33 v1(18.55,59.48)
  L4 w0.089: v1(90.86,41.59) 90.53,41.92 88.69,41.92 88.56,41.79 86.01,41.79 85.38,41.16 83.19,41.16 82.82,41.52 81.85,41.52 81.06,40.72 73.74,40.72 73.73,40.72 73.04,40.72 73.03,40.72 67.11,40.72 67.09,40.74 64.93,40.74 64.73,40.53 59.27,40.53 57.67,42.13 36.87,42.13 36.14,41.39 36.14,40.91 36.7,40.34 36.7,39.65 36.78,39.57 36.78,37.9 36.7,37.82 36.7,37.52 36.03,36.85 36.03,34.06 32.32,30.35 32.32,28.9 31.39,27.97 28.91,27.97 v1(28.71,28.17)
  BOTTOM w0.089: R9121.2 147.2,139.86 v1(147.35,140.01) ; v1(18.55,59.48) 18.46,59.57 18.46,59.65 16.66,61.45 15.29,61.45 11.08,65.65 11.08,66.33 11.69,66.93 12.54,66.93 13.54,67.93 14.01,67.93 15.8,69.72 15.8,71.18 17.04,72.42 18.06,72.42 20.55,74.91 20.9,74.91 21.16,74.64 21.16,74.11 21.58,73.69 22.5,73.69 22.72,73.46 24.82,73.46 25.5,74.14 26.78,74.14 28.14,75.5 38.63,75.5 38.77,75.63 41.42,75.63 41.69,75.9 41.69,76.46 41.34,76.81 41.34,77.16 41.58,77.41 41.67,77.41 41.7,77.44 43.46,77.44 44.16,76.74 49.51,76.74 49.87,77.09 50.75,77.09 51.92,78.26 v2(55.43,78.26) 57.16,76.52 76.82,76.52 78.92,74.42 104.77,74.42 107.94,77.58 107.94,78.77 107.98,78.81 107.98,82.91 107.15,83.73 CPU1.BJ37
SIO_SLP_S3#: length 428.4
  TOP w0.102: v1(156.13,139.99) 155.79,140.34 152.05,140.34 151.51,139.8 149.41,139.8 v1(147.32,141.89) ; R4017.1 87.05,41.1 v1(87.05,41.33)
  L3 w0.102: v1(67.69,37.39) 67.91,37.62 72.01,37.62 74.86,40.46 80.32,40.46 81.33,41.48 82.48,41.48 82.95,41.01 83.72,41.01 84.83,42.11 86.26,42.11 v1(87.05,41.33) 87.53,40.84 93.96,40.84 94.7,41.58 95.5,41.58 95.5,41.58 97.01,41.58 98.88,43.46 99.24,43.46 99.56,43.14 100.75,43.14 102.06,44.45 102.8,44.45 103.1,44.15 104.32,44.15 105.25,43.22 105.81,43.22 106.13,43.55 107.4,43.55 108.69,44.84 121.47,44.84 123.64,42.67 127.36,42.67 130.45,39.59 153.47,39.59 155.55,41.67 168.35,41.67 169.06,40.96 170.4,40.96 v1(171.05,41.61) ; v1(139.98,146.53) 139.65,146.53 138.38,147.8 122.33,147.8 119.23,150.91 104.8,150.91 103.04,149.15 99.4,149.15 98.68,149.87 78.76,149.87 72.66,143.77 72.66,138.01 70.95,136.3 70.58,136.3 69.49,137.39 65.05,137.39 60.1,132.44 60.1,129.98 59.75,129.63 59.75,128.72 60.23,128.24 61.16,128.24 v1(61.52,128.6) ; v1(156.13,139.99) 154.13,139.99 154.05,140.07 153.21,140.07 151.92,138.78 151.92,138.58 149.53,136.2 146.94,136.2 144.94,134.19 v1(144.94,133)
  L4 w0.102: v1(58.18,37.97) 58.74,38.53 66.7,38.53 67.69,37.55 v1(67.69,37.39) ; v1(151.95,71.02) 152.66,71.02 154.95,68.72 154.95,67.68 154.97,67.66 154.97,67.17 154.97,66.89 155.6,66.26 155.6,66.19 155.6,66.18 155.6,64.9 157.8,62.71 157.8,62.71 157.97,62.54 158.26,62.54 170.32,50.47 170.32,43.19 171.05,42.47 v1(171.05,41.61) ; v1(157.08,92.79) 157.08,93.38 155.92,94.54 155.11,94.54 153.08,96.57 153.08,99.73 152.84,99.98 152.19,99.98 151.54,100.63 151.54,101.17 150.29,102.41 150.29,106.45 146.43,110.32 146.43,112.25 146.33,112.35 146.33,119.71 142.47,123.57 142.47,130.48 144.94,132.94 v1(144.94,133)
  BOTTOM w0.076: CPU1.BU36 112.18,84.56 112.17,84.55 112.07,84.36 112.07,84.35 111.93,84.1 111.93,83.83 112.23,83.53 112.23,82.75
  BOTTOM w0.089: 112.23,82.75 112.23,82.48 112.26,82.45
  BOTTOM w0.102: v1(87.05,41.33) 87.05,40.92 D4003.K 88.17,40.23 88.87,39.53 U4007.1 ; v1(147.32,141.89) v2(145.71,141.89) 145.13,142.46 145.13,143.53 145.37,143.77 145.37,144.15 142.83,146.69 140.14,146.69 v1(139.98,146.53) ; v1(157.08,92.79) 157.08,92.74 156.7,92.36 156.7,89.05 156.87,88.88 156.87,87.84 157.23,87.48 157.23,85.33 156.66,84.76 155.2,84.76 154.54,84.1 154.28,84.1 152.58,82.4 152.58,78.28 152.19,77.9 152.19,75.36 151.95,75.11 v1(151.95,71.02) 151.75,70.83 125.69,70.83 120.85,75.68 118.22,75.68 115.89,78.01 115.89,78.75 114.82,79.83 113.98,79.83 112.65,81.15 112.65,82.06 112.26,82.45 ; U4001.3 60.68,128.35 C1703.1 61.52,128.47 v1(61.52,128.6) ; U4004.5 58.96,38.24 58.91,38.19 58.4,38.19 v1(58.18,37.97) 58.18,37.86 58.66,37.37 59.04,37.37 59.11,37.44 U4004.3
SIO_SLP_S4#: length 249.2
  TOP w0.089: v1(224.32,68.53) 224.6,68.25 Q9202.G
  L3 w0.089: v1(178.06,65.37) 178.13,65.44 178.13,65.51 178.39,65.76 180.26,65.76 184.14,61.88 187.78,61.88 190.61,64.71 204.56,64.71 v1(205.41,63.86) ; v1(112.53,89.96) 112.5,89.93 112.5,89.89 112.07,89.45 112.07,87.05 112.01,86.99 112.01,86.38 113.23,85.16 115.49,85.16 116.32,84.33 119.58,84.33 119.93,84.68 124.32,84.68 124.71,84.28 125.53,84.28 128.05,81.77 133.88,81.77 134.04,81.62 138.44,81.62 138.96,81.1 138.96,80.99 139.67,80.27 139.68,80.27 141.24,80.27 141.24,80.27 141.98,80.27 142.22,80.04 143.46,80.04 144.3,79.2 144.35,79.2 144.51,79.04 144.51,79.04 146.97,76.58 147.96,76.58 158.42,66.12 158.42,65.42 159.03,64.81 159.03,64.42 164.65,58.8 165.32,58.8 166.22,57.9 166.22,57.23 v1(166.4,57.05)
  L4 w0.089: v1(134.97,128.17) 134.97,126.88 136.55,125.3 137.54,125.3 138.23,124.61 138.23,122.86 143.84,117.25 143.84,113.91 145.03,112.71 145.03,110.47 149.36,106.14 149.36,102.19 150.73,100.82 150.73,100.58 151.94,99.36 151.94,99.01 151.72,98.79 151.72,97.23 155.68,93.27 v1(156.29,93.27) 156.29,92.68 159.07,89.89 160,89.89 162.37,87.52 162.37,87.16 161.92,86.71 161.92,83.97 161.28,83.33 161.28,81.64 173.48,69.44 174.14,69.44 176.75,66.84 177.36,66.84 178.08,66.11 178.08,65.6 178.06,65.58 v1(178.06,65.37)
  BOTTOM w0.089: v1(156.29,93.27) 156.55,93.27 157.48,94.21 157.48,94.77 158.29,95.57 158.29,95.58 158.41,95.7 158.41,96.37 159.18,97.15 159.18,103.32 162.11,106.24 PR5117.2 ; v1(205.41,63.86) 205.41,64.42 205.84,64.85 215.17,64.85 215.67,65.35 215.67,66.72 216.88,67.93 218.85,67.93 219.46,68.53 v1(224.32,68.53) ; v1(166.4,57.05) 166.47,57.05 168.79,59.36 168.79,61.42 169.63,62.28 170.63,63.28 170.63,65.24 171.1,65.72 173.43,65.72 174.13,65.02 177.71,65.02 v1(178.06,65.37) ; CPU1.BU27 112.5,89.97 112.52,89.96 v1(112.53,89.96) ; R4024.1 136.5,128.54 137.02,129.06 C1702.1 137.41,128.81 v2(137.41,128.16) 137.29,128.05 135.12,128.05 135,128.17 v1(134.97,128.17)
SIO_SLP_S5#: length 2.7
  TOP w0.102: v1(111.59,88.6) 112.05,88.13 112.05,86.89 TP1702.1
  BOTTOM w0.102: CPU1.BT29 111.52,88.6 v1(111.59,88.6)
SLEEVE_R: length 15.7
  TOP w1.016: HPMIC1.4 4.82,21.31 15.97,21.31 ED2912.1 16.96,19.94 16.79,19.77 R2911.2
SM_DRAMRST#_CPU: length 136.3
  TOP w0.216: v1(131.26,41.25) 131.41,41.1 v2(131.83,41.1)
  L3 w0.203: v1(131.26,41.25) 131.26,41.47 131.63,41.84 149.45,41.84 150.24,42.62 172.91,42.62 173.7,43.41 174.2,43.41 175.31,44.53 175.31,47.55 173.82,49.04 173.56,49.04 172.8,49.8 172.8,52.33 165.78,59.35 164.88,59.35 159.58,64.65 159.58,65.04 159.26,65.36 159.01,65.61 159.01,66.31 148.19,77.13 147.83,77.13 146.22,78.74 145.59,78.74 144.58,79.76 144.53,79.76 143.69,80.6 143.68,80.6 142.99,81.28 142.32,81.28 142.07,81.03 142.07,81 141.94,80.88 141.27,80.88 140.93,81.21 140.88,81.27 140.88,81.35 140.06,82.17 134.26,82.17 130.23,86.21 128.08,86.21 128.01,86.13 126.37,86.13 125.61,85.37 124.74,85.37 124,86.11 121.72,86.11 120.53,84.91 119.76,84.91 119.42,84.57 116.49,84.57 114.82,86.23 113.6,86.23 113.55,86.18 113.17,86.18 112.91,86.45 112.91,86.83 113.02,86.94 113.02,87.58 112.6,87.99 v1(112.52,87.99)
  BOTTOM w0.216: CPU1.BU31 112.1,87.72 112.37,87.99 v1(112.52,87.99) ; v1(131.26,41.25) 131.26,41.19 131.59,40.86 R504.1 R505.2
SM_INTRUDER#: length 8.2
  BOTTOM w0.076: v2(110.81,81.99) 110.81,83.74 110.72,83.84 110.72,84.75 110.87,85.19 CPU1.BR35
  BOTTOM w0.102: v2(110.81,81.99) 110.81,81.77 113.67,78.91 113.69,78.91 R1730.2
SM_PGCNTL: length 197.4
  L3 w0.254: v1(60.2,91.65) 57.43,91.65 55.45,89.67 55.45,77.16 50.48,72.19 49.41,72.19 44.81,67.59 42.8,67.59 40.36,65.15 38.36,65.15 38.1,65.41 35.99,65.41 35.97,65.43 33.67,65.43 31.66,63.43 31.66,60.88 28.3,57.51 28.3,57.1 27.16,55.96 27.16,54.5 24.2,51.54 24.2,48.59 24.08,48.47 24.08,44.1 24.06,44.07 24.06,42.12 24.32,41.86 24.32,39.76 24.25,39.68 24.25,37.74 25.41,36.57 25.41,31.11 25.35,31.05 25.35,30.63 25.65,30.33 29.98,30.33 30.31,30.66 32.06,30.66 32.95,31.55 62.07,31.55 63.57,33.05 74.64,33.05 78.01,36.41 92.9,36.41 93.02,36.54 100.15,36.54 101.76,38.15 102.57,38.15 103.11,38.69 v1(103.11,38.85)
  BOTTOM w0.127: 79.35,83.69 79.37,83.71 79.37,84.33 79.52,84.49 79.52,84.75 79.22,85.05 CPU1.C35
  BOTTOM w0.254: v1(60.2,91.65) 60.47,91.65 v2(61.25,90.87) 64.8,87.32 64.8,85.31 64.8,85.3 64.8,82.64 66.68,80.76 66.69,80.76 66.8,80.65 72.65,80.65 75.57,83.57 79.23,83.57 79.35,83.69 ; Q501.G 104.22,37.64 103.11,38.75 v1(103.11,38.85)
SM_PGCNTL_Q: length 22.1
  TOP w0.102: R507.2 108.49,38.86 v2(107.66,38.86) 107.63,38.86 v1(107.19,39.3)
  L3 w0.102: v1(111.08,30) 111.08,29.96 110.52,29.4 110.52,28.75 111.66,27.61 115.45,27.61 115.62,27.44 v1(115.62,27.1)
  BOTTOM w0.089: v1(115.62,27.1) 115.7,27.18 PU5102.5
  BOTTOM w0.102: v1(107.19,39.3) 107.3,39.3 107.66,38.94 107.77,38.94 Q502.D 110.34,36.37 110.43,36.37 110.53,36.27 110.53,33.67 109.86,33 109.86,30.58 110.44,30 v1(111.08,30)
SM_RCOMP_0: length 2.3
  TOP w0.305: v2(111.01,88.42) 110.55,88.87 R501.1 109.82,89.3 v1(109.82,89.3)
  BOTTOM w0.254: CPU1.BN28 v1(109.82,89.3)
SM_RCOMP_1: length 2.8
  TOP w0.254: R502.1 v2(108.72,89.33) 109.07,89.33 109.68,89.94 v1(109.82,89.94)
  BOTTOM w0.254: CPU1.BN27 v1(109.82,89.94)
SM_RCOMP_2: length 5.1
  TOP w0.203: R503.1 108.89,86.64 109.45,86.07 110.03,86.07 110.25,86.3 v2(110.25,87) 110.28,87.03 110.28,88.22 109.83,88.67 v1(109.82,88.67)
  BOTTOM w0.254: CPU1.BN29 v1(109.82,88.67)
SMB_ALERT#: length 19.1
  TOP w0.089: R1551.2 135.81,96.18 v2(135.7,96.07) 135.48,96.07 134.24,97.31 133.63,97.31 v1(133.25,96.93)
  L3 w0.089: v1(133.25,96.93) 132.37,96.05 122.91,96.05 122.33,96.63 119.92,96.63 v1(119.48,97.07)
  BOTTOM w0.089: CPU1.CJ15 v1(119.48,97.07)
SML0_ALERT#: length 204.6
  TOP w0.14: v1(51.88,90.08) 51.38,90.08 50.91,90.55 49.36,90.55 48.69,91.21 48.69,92.7 R1806.1 48.05,93.85 v2(48.42,94.21) ; v1(133.88,96.87) 135.34,95.41 R1504.2
  L3 w0.089: 122.15,96.42 119.79,96.42 119.64,96.57 118.69,96.57 v1(118.19,97.07)
  L3 w0.127: v1(152.83,77.53) 151.13,79.23 151.13,81.78 145.02,87.9 144.83,87.9 144.81,87.91 144.8,87.91 143.82,88.88 143.82,89.08 143.82,89.08 143.82,89.13 137.83,95.13 135.63,95.13 v1(133.88,96.87) 132.83,95.81 122.76,95.81 122.15,96.42 ; v1(45.7,70.49) 45.43,70.75 45.43,71.7 45.81,72.07 45.81,72.13 46.81,73.13 46.81,74.32 49.98,77.49 49.98,79.01 52.38,81.41 52.38,89.58 51.9,90.07 51.89,90.07 v1(51.88,90.08)
  BOTTOM w0.089: CPU1.CG15 v1(118.19,97.07)
  BOTTOM w0.14: v1(45.7,70.49) 45.85,70.49 45.87,70.46 47.73,70.46 47.78,70.51 48,70.51 49.25,71.77 49.77,71.77 54.89,66.64 72.56,66.64 76.96,71.04 123.06,71.04 124.96,69.14 151.8,69.14 152.15,68.79 153.37,68.79 154.95,70.37 156.23,70.37 156.79,70.93 156.79,72.56 152.83,76.52 v1(152.83,77.53)
SML0_SMBCLK: length 22.8
  TOP w0.14: v1(132.33,98.76) 132.16,98.93 132.16,99.62 132.29,99.75 132.6,99.75 132.6,99.75 132.97,99.75 133.25,99.47 134.31,99.47 135.14,98.64 RN1807.5
  L3 w0.089: v1(118.21,98.12) 118.3,98.12 118.64,98.46 120.73,98.46 120.97,98.22
  L3 w0.127: v1(132.33,98.76) 132.31,98.73 131.44,98.73 130.61,97.9 130.61,97.3 130.26,96.95 125.96,96.95 124.45,98.47 123.92,98.47 123.68,98.22 120.97,98.22
  BOTTOM w0.14: v1(118.21,98.12) 118.67,98.58 CPU1.CH14 ; v2(132.52,98.14) 132.52,98.56 v1(132.33,98.76)
SML0_SMBDATA: length 23.1
  TOP w0.14: v1(132.67,99.3) 132.83,99.14 134.19,99.14 135.27,98.05 RN1807.6
  L3 w0.089: v1(117.54,97.1) 117.54,98.02 118.12,98.6 118.5,98.6 118.57,98.67 120.87,98.67
  L3 w0.127: 120.87,98.67 120.89,98.65 123.49,98.65 123.56,98.72 124.55,98.72 126.03,97.25 130.06,97.25 130.34,97.53 130.34,97.99 131.65,99.3 v1(132.67,99.3)
  BOTTOM w0.14: v2(133.04,99.76) 133.04,99.67 v1(132.67,99.3) ; v1(117.54,97.1) 117.37,97.26 CPU1.CF15
SML1_SMBCLK: length 139.7
  TOP w0.14: Q2601.3 v2(126.95,117.84) 126.86,117.84 126.59,117.57 126.59,116.34 132.17,110.76 132.17,106.96 131.47,106.27 131.47,106.27 131.47,106.26 131.47,105.15 131.47,105.15 131.47,98.58 132.21,97.84 v1(132.21,97.32) ; v1(209.82,54.83) 209.82,54.84 210.22,55.25 210.72,55.25 210.95,55.02 R2459.1
  L3 w0.127: v1(209.82,54.83) 209.82,55.11 207.83,57.1 206.84,57.1 206.78,57.05 205.04,57.05 204.42,57.67 201.77,57.67 200.63,56.53 192.42,56.53 191.08,55.19 180.34,55.19 179.83,55.7 178.11,55.7 176.87,55.7 176.86,55.7 176.8,55.64 176.57,55.41 176.57,55.41 176.24,55.08 174.84,55.08 174.63,55.08 163.4,66.31 163.4,67.21 163.34,67.28 163.34,67.29 159.57,71.06 159.57,71.65 151.39,79.83 151.39,81.89 145.12,88.15 144.93,88.15 144.92,88.16 144.9,88.16 144.08,88.99 144.08,89.24 137.85,95.47 137.34,95.47 135.49,97.32 133.79,97.32 133.73,97.37 132.26,97.37 v1(132.21,97.32)
  BOTTOM w0.076: 125.23,97.64 125.18,97.59 122.42,97.59 122.36,97.57 122.12,97.57 121.92,97.64 CPU1.CN15
  BOTTOM w0.127: 125.96,97.67 126.62,97.01
  BOTTOM w0.14: 125.96,97.67 125.26,97.67 125.23,97.64 ; RN1811.3 132.21,97.89 v1(132.21,97.32) 131.9,97.01 126.62,97.01
SML1_SMBDATA: length 139.1
  TOP w0.14: v1(131.58,97.5) 131.59,97.49 131.59,97.17 132,96.76 132.32,96.76 132.67,97.11 132.67,97.78 131.75,98.69 131.75,105.26 131.75,105.27 131.75,106.15 132.45,106.85 132.45,110.94 129.17,114.22 v2(129.17,114.94) Q2601.6 ; v1(210.47,54.79) 210.67,54.59 211.36,54.59 211.84,54.1 R2447.1
  L3 w0.127: v1(131.58,97.5) 131.84,97.77 133.78,97.77 133.98,97.57 135.88,97.57 137.72,95.73 137.94,95.73 144.33,89.34 144.33,89.09 145.01,88.42 145.02,88.42 145.04,88.41 145.23,88.41 151.69,81.94 151.69,79.89 159.82,71.75 159.82,71.16 163.59,67.39 163.59,67.38 163.66,67.32 163.66,66.42 174.74,55.34 176.14,55.34 176.46,55.67 176.47,55.67 176.69,55.89 176.7,55.89 176.76,55.96 176.77,55.96 179.93,55.96 180.44,55.45 190.98,55.45 192.31,56.78 200.52,56.78 201.66,57.92 204.53,57.92 205.14,57.3 206.68,57.3 206.73,57.36 207.93,57.36 210.47,54.82 v1(210.47,54.79)
  BOTTOM w0.076: 122.63,98.08 121.28,98.08 121.15,98.03 CPU1.CM15
  BOTTOM w0.14: 122.63,98.08 123.66,98.08 124.03,98.45 124.49,98.45 124.97,97.97 126.01,97.97 126.72,97.26 130.82,97.26 131.05,97.5 131.55,97.5 131.55,97.5 v1(131.58,97.5) 131.55,97.52 131.55,97.53 130.96,98.13 RN1811.4
SML1ALERT#: length 7.5
  BOTTOM w0.076: CPU1.CC34 116.06,85.88 116.32,85.34 116.32,84.34 116.39,84.22 116.39,84.21 116.42,84.15 116.42,83.77 116.25,83.59 116.25,82.88 116.8,82.33
  BOTTOM w0.089: 116.8,82.33 116.8,81.96 117.43,81.33
  BOTTOM w0.14: R1837.2 118.24,79.86 117.86,80.24 v2(117.85,80.24) 117.85,80.27 117.43,80.69 117.43,81.33 117.43,81.33
SPI_CLK_CPU: length 37.7
  TOP w0.14: v1(149.02,86.74) 148.71,87.06 148.71,89.57 v1(149.08,89.94)
  BOTTOM w0.14: v1(149.08,89.94) 149.47,90.34 151.11,90.34 153.05,92.28 153.06,92.4 153.06,93.74 154.54,95.22 R2508.2 154.82,95.63 154.82,97.51 156.47,99.16 156.47,100.25 157.64,101.41 157.64,102.27 154.7,105.21 154.7,106.02 156.42,107.74 156.9,107.74 157.09,107.93 157.69,107.93 159.26,109.5 R2513.2 v2(158.39,110.75) 157.82,110.75 157.58,110.99 157.58,113.15 R9138.1 ; R1842.1 148.94,86.66 v1(149.02,86.74)
SPI_CLK_CPU_R: length 42.1
  BOTTOM w0.076: CPU1.CH37 118.72,83.79 118.72,83.32 118.85,83.19
  BOTTOM w0.14: R1842.2 149.26,84.07 149.26,83.33 148.14,82.21 148.14,81.48 147.97,81.31 147.97,80.31 v2(147.77,80.1) 147.77,77.35 146.96,76.54 146.03,76.54 144.57,75.07 127.63,75.07 121.43,81.27 121.43,81.54 121.05,81.92 120.12,81.92 118.85,83.19
SPI_CLK_ROM: length 4.8
  BOTTOM w0.14: BIOS1.6 152.43,93.82 153.67,95.06 R2508.1 154.36,96.03 EC2503.1 154.36,96.93 v2(154.26,97.03)
SPI_CLK_ROM2: length 3.3
  BOTTOM w0.14: 158.91,108.19 159.52,108.81 159.52,108.93 R2513.1 ; R2513.1 160.47,108.67 v2(160.47,108.59) ; R2513.1 160.49,109.89 EC2504.1
SPI_CLK_ROM_TPM: length 40.3
  L4 w0.127: v1(153.05,117.34) 151.87,117.34 149.55,119.66 149.55,120.35 145.42,124.49 v1(145.42,130.05)
  BOTTOM w0.14: v1(153.05,117.34) 153.06,117.35 155.65,117.35 156.35,116.65 156.69,116.65 v2(157.46,115.88) 157.46,114.21 R9138.2 ; v1(145.42,130.05) 145.98,130.61 145.98,132.92 145.27,133.63 145.27,134.6 146.61,135.94 149.48,135.94 150.15,135.26 151.53,135.26 152.07,135.8 152.11,135.8 152.37,136.06 152.37,136.44 152.11,136.7 152.08,136.7 151.93,136.86 151.93,138.28 151.47,138.74 U9103.19
SPI_CS2#_IC: length 49.5
  L4 w0.127: v1(144.22,129.77) 144.52,129.48 144.52,123.42 147.87,120.07 147.87,114.47 148.24,114.1 148.24,110.22 151.53,106.93 151.53,102.94 151.83,102.64 151.94,102.64 152.28,102.31 152.28,102.29 152.72,101.84 152.72,101.34 152.12,100.74 v1(152.05,100.74)
  BOTTOM w0.14: v1(144.22,129.77) 145.39,130.93 v2(145.39,131.86) 144.75,132.49 144.75,132.49 144.43,132.82 144.43,134.55 146.43,136.55 150.52,136.55 R9148.2 150.94,137.66 150.94,138.32 150.97,138.34 U9103.20 ; v1(152.05,100.74) 151.89,100.74 R9130.2
SPI_CS_CPU_N0: length 55.2
  BOTTOM w0.14: R2519.2 155.05,86.06 BIOS1.1 154.97,86.92 154.79,87.09 153.3,87.09 153.05,86.84 153.05,85.39 152.83,85.18 151.98,85.18 150.75,83.95 v2(150.68,83.95) 150.68,82.97 149.4,81.69 149.4,80.96 149.35,80.91 149.35,79.65 149.65,79.35 149.65,75.77 147.72,73.84 147.69,73.81 127.11,73.81 118.06,82.86 118.06,83.14 117.87,83.33 CPU1.CG36
SPI_CS_CPU_N1: length 69.5
  BOTTOM w0.076: 118.25,83.45 118.1,83.59 118.1,84.14 118.13,84.24 118.13,84.36 arc(118.11,84.46) 118.05,84.55 arc(118,84.61) 117.99,84.69 117.99,84.84 CPU1.CG35
  BOTTOM w0.14: BIOS2.1 155.12,100.81 155.12,100.01 154.55,99.44 154.5,99.44 153.97,98.92 153.97,98.91 153.14,98.08 153.04,98.08 152.91,97.96 151.9,96.95 151.67,96.95 147.62,92.89 147.62,91.91 147.16,91.46 147.16,90 147.58,89.59 147.58,89.47 147.76,89.28 147.76,88.19 148.63,87.33 149.31,87.33 v2(149.58,87.05) 150.56,86.08 150.56,85.48 150.2,85.12 150.2,83.09 148.98,81.87 148.98,81.13 148.88,81.03 148.88,79.82 R2521.2 149.23,79.15 149.23,75.94 147.54,74.26 147.51,74.23 127.28,74.23 121.53,79.99 121.4,79.99 118.29,83.1 118.29,83.4 118.25,83.45
SPI_CS_CPU_N2: length 114
  L3 w0.127: v1(153.25,105.31) 153.26,105.3 153.26,104.7 153.23,104.67 153.23,103.42 152.62,102.8 152.62,102.43 153.05,102 153.05,99.19 152.45,98.59 v1(152.15,98.59)
  L4 w0.127: v1(157.03,138.93) 156.99,138.89 156.99,136.75 159.48,134.26 159.48,127.83 160.64,126.66 160.64,118.2 162.02,116.82 162.02,112.7 156.27,106.95 155.39,106.95 153.74,105.31 v1(153.25,105.31)
  BOTTOM w0.076: CPU1.CH34 118.26,85.46 118.26,85.18 118.32,85.04 118.4,84.95 118.7,84.95 118.84,84.81 118.84,84.55 118.88,84.51 118.88,84.33 arc(118.89,84.26) 118.93,84.21 119.12,84.01 119.12,84
  BOTTOM w0.089: 119.64,83.01 119.56,83.01 119.2,83.38 119.2,83.92 119.12,84
  BOTTOM w0.14: 119.64,83.01 119.87,82.78 121.05,82.78 122.61,81.22 122.61,81.2 123.98,79.84 123.99,79.84 126.65,77.19 127.91,77.19 128.21,77.49 129.83,77.49 130.79,76.53 131.76,76.53 132.41,75.87 144.08,75.87 145.54,77.34 146.62,77.34 146.91,77.62 146.91,80.06 146.57,80.4 146.57,81.04 147.34,81.81 147.34,82.55 148.28,83.49 148.28,86.93 147.34,87.87 147.34,89.11 147.16,89.29 147.16,89.32 146.59,89.89 146.59,93.16 150.44,97.01 150.55,97.01 151.32,97.78 151.34,97.78 v1(152.15,98.59) 152.16,98.6 152.48,98.92 152.79,98.92 153.06,99.19 153.06,99.56 152.78,99.84 152.21,99.84 R9130.1 ; R9118.2 156.16,141.66 v2(156.97,140.85) 157.45,140.36 157.45,139.26 157.13,138.93 157.03,138.93 v1(157.03,138.93)
SPI_HOLD_CPU: length 4.6
  BOTTOM w0.14: R2503.2 155.35,97.18 v2(155.65,97.48) 156.1,97.93 157.01,97.93 R1846.1 157.91,98.83 ; 157.91,98.83 R1510.2 ; 157.91,98.83 R2511.2
SPI_HOLD_CPU_R: length 64.8
  TOP w0.14: v1(149.55,89.5) 149.86,89.18 149.86,85.93 150.1,85.69 v1(150.1,85.66)
  BOTTOM w0.076: CPU1.CG34 117.87,85.38 118.08,85.17 118.14,85.03 118.14,84.92 118.21,84.85 118.21,84.73 arc(118.23,84.61) 118.27,84.5 118.28,84.47 arc(118.29,84.45) 118.29,84.43 118.29,84.14 118.27,84.09 118.27,84.05 118.27,83.8 118.55,83.51 118.55,83.16 118.75,82.96
  BOTTOM w0.14: 118.75,82.96 120.02,81.69 120.96,81.69 121.21,81.44 121.21,80.9 127.45,74.65 144.81,74.65 146.28,76.12 147.13,76.12 148.22,77.21 148.22,79.92 148.46,80.16 148.46,81.21 148.56,81.3 v2(148.56,82.04) 149.78,83.26 149.78,85.34 v1(150.1,85.66) ; v1(149.55,89.5) 149.66,89.61 152.58,89.61 154.41,91.44 154.41,93.82 154.41,93.85 155.8,95.24 155.8,96.67 156.59,97.45 157.4,97.45 R1846.2
SPI_HOLD_ROM: length 3.4
  BOTTOM w0.14: BIOS1.7 153.7,93.74 154.38,94.41 v2(154.38,94.44) 154.42,94.48 154.44,94.48 155.35,95.39 R2503.1
SPI_HOLD_ROM2: length 13.1
  BOTTOM w0.14: BIOS2.7 159.52,107.01 156.28,107.01 155.12,105.85 155.12,105.38 158.07,102.43 158.07,101.23 157.48,100.64 v2(157.43,100.64) 157.43,99.98 R2511.1
SPI_IRQ#_TPM2: length 71.2
  TOP w0.14: v1(140.36,87.11) 140.02,86.77 R9151.1 138.43,87.37 R9152.1
  L4 w0.127: v1(151.87,102.08) 151.85,102.08 151.15,102.78 151.15,106.77 147.84,110.07 147.84,113.8 147.22,114.42 147.22,120.07 144.07,123.21 v1(144.07,128.83)
  BOTTOM w0.14: v1(144.07,128.83) 144.99,128.83 v2(146.54,130.38) 146.54,133.41 147.82,134.7 151.8,134.7 152.93,135.83 152.93,136.06 153.65,136.78 153.65,136.96 R9119.1 153.05,136.96 152.49,137.52 152.49,138.39 151.97,138.9 U9103.18 ; v1(140.36,87.11) 140.36,87.14 139.98,87.52 139.98,88.07 140.58,88.66 140.58,88.67 144.04,92.13 144.04,92.39 149.66,98.01 149.94,98.01 150.94,99.01 150.94,100.39 151.83,101.28 151.83,102.04 v1(151.87,102.08)
SPI_SI_CPU: length 45.4
  TOP w0.14: v1(148.65,90.42) 149.26,90.42 150.29,89.39 150.29,86.38 151.41,85.26 151.41,81.08 v1(150.64,80.31)
  BOTTOM w0.14: R9133.1 153.72,111.81 v2(154.6,110.94) 155.34,110.94 156.44,109.83 R2512.2 157.05,109.5 157.05,108.96 156.99,108.91 156.99,108.42 156.73,108.16 156.25,108.16 154.28,106.2 154.28,105.03 157.22,102.1 157.22,101.59 155.98,100.36 155.98,99.33 154.92,98.27 154.52,98.27 153.49,97.24 153.49,97.24 153.38,97.24 152.25,96.11 152.02,96.11 150.57,94.67 R2509.2 150.57,91.37 150.01,90.8 149.04,90.8 v1(148.65,90.42) ; R1506.2 151.68,80.72 R1844.1 150.95,80 v1(150.64,80.31)
SPI_SI_CPU_R: length 45.8
  BOTTOM w0.076: 117.38,82.7 117.38,82.85 117.27,82.95 117.27,83.53 116.97,83.84 116.97,84.12 117.22,84.58 CPU1.CF36
  BOTTOM w0.14: 117.38,82.7 117.38,82.35 118.18,81.55 118.18,80.97 v2(119.64,79.51) 126.59,72.56 148.21,72.56 148.24,72.58 151.36,75.71 151.36,78.84 R1844.2
SPI_SI_ROM: length 3.7
  BOTTOM w0.14: EC2501.1 152.49,94.83 152.01,95.31 v2(151.87,95.31) 151.44,94.87 R2509.1 151.16,94.19 BIOS1.5
SPI_SI_ROM2: length 3.6
  BOTTOM w0.14: 158.01,109.09 158.01,109.76 R2512.1 156.77,111 EC2505.1 157.02,111.42 157.02,111.84 v2(157.17,111.99)
SPI_SI_ROM_TPM: length 38.8
  L4 w0.127: v1(144.3,130.53) 144.91,129.92 144.91,123.67 148.25,120.33 148.25,119.55 151.61,116.19 153.2,116.19 153.5,115.89 154.49,115.89 v1(154.61,116.01)
  BOTTOM w0.14: R9133.2 v2(154.59,113.69) 154.59,113.77 153.57,114.79 153.57,115.16 154.42,116.01 154.6,116.01 v1(154.61,116.01) ; v1(144.3,130.53) 144.86,131.09 144.86,131.79 144.07,132.58 144.07,134.79 146.3,137.01 149.81,137.01 150.47,137.66 U9103.21
SPI_SO_CPU: length 28.2
  TOP w0.14: v1(150.5,81.05) 150.04,81.51 150.04,82.52 150.33,82.81 150.33,84.18 147.62,86.89 147.62,90.66 147.62,90.67 147.62,90.87 147.04,91.44 v1(147.04,92.1)
  BOTTOM w0.14: v1(147.04,92.1) 147.04,93.02 v2(147.67,93.65) 147.78,93.65 151.5,97.37 151.72,97.37 152.5,98.14 152.5,98.15 152.86,98.5 152.97,98.5 153.55,99.09 153.55,99.72 R9132.1 153.36,100.1 R2501.1 ; R1843.1 150.88,79.33 150.19,80.01 150.19,80.57 150.5,80.87 v1(150.5,81.05) 150.97,81.53 150.97,82.01 R2502.1
SPI_SO_CPU_R: length 42.9
  BOTTOM w0.076: CPU1.CF37 117.45,83.75 117.45,83.12 117.61,82.97 117.61,82.7
  BOTTOM w0.14: R1843.2 150.9,75.84 148.06,73 148.03,72.98 126.76,72.98 118.82,80.91 v2(118.82,80.98) 118.76,80.98 118.52,81.22 118.52,81.53 117.61,82.44 117.61,82.7
SPI_SO_ROM: length 4.3
  BOTTOM w0.14: R2502.2 151.36,83.82 EC2502.1 152.28,84.74 v2(153.07,84.74) 153.7,85.36 BIOS1.2
SPI_SO_ROM2: length 3.3
  BOTTOM w0.14: BIOS2.2 154.33,101.82 153.89,101.82 EC2506.1 153.85,101.71 R2501.2 154.41,101.07 154.69,100.79 154.69,100.17 v2(154.68,100.16)
SPI_SO_ROM_TPM: length 46.8
  L4 w0.127: v1(144.35,131.6) 142.9,130.15 142.9,123.72 146.83,119.8 146.83,112.38 146.94,112.27 146.94,110.44 150.76,106.61 150.76,102.56 151.8,101.53 v1(152.28,101.53)
  BOTTOM w0.14: v1(144.35,131.6) 143.67,132.28 143.67,134.97 146.72,138.02 v2(147.37,138.02) 148.66,139.32 U9103.24 ; v1(152.28,101.53) 152.28,101.24 152.75,100.77 R9132.2
SPI_WP_CPU: length 6.1
  BOTTOM w0.14: R2510.1 R2507.1 R1845.1 149.31,91.24 148.84,91.24 148.11,90.51 148.11,90.24 148.41,89.93 148.41,89.82 v2(148.42,89.82) 148.92,89.31 R1508.2
SPI_WP_CPU_R: length 59.1
  TOP w0.14: v1(150.49,81.79) 151,82.3 151,84.11 150.38,84.73 150.38,84.73 148.04,87.07 148.04,90.84 148.03,90.84 v1(148.03,91.09)
  BOTTOM w0.076: 117.83,82.73 117.83,82.97 117.62,83.19 117.62,84.06 117.48,84.21 117.48,85.68 CPU1.CF34
  BOTTOM w0.14: v1(150.49,81.79) v2(149.91,81.21) 149.82,81.12 149.82,80.78 149.77,80.74 149.77,79.82 150.12,79.48 150.12,75.65 147.89,73.42 147.86,73.39 126.94,73.39 118.98,81.35 118.98,81.45 117.83,82.59 117.83,82.73 ; v1(148.03,91.09) 148.64,91.7 R1845.2
SPI_WP_ROM: length 10.7
  BOTTOM w0.14: BIOS1.3 152.43,86.94 151.63,87.75 148.85,87.75 148.21,88.39 148.18,88.43 148.18,89.46 148,89.64 148,89.76 147.58,90.17 147.58,91.27 148.03,91.72 v2(148.03,91.97) 148.09,91.97 148.57,92.46 R2507.2
SPI_WP_ROM2: length 16.2
  BOTTOM w0.14: R2510.2 148.9,93.42 v2(149.66,94.18) 149.66,94.34 151.84,96.53 152.07,96.53 153.21,97.66 153.31,97.66 154.39,98.74 154.39,98.74 154.56,98.91 154.97,98.91 155.57,99.51 155.57,100.53 156.8,101.76 156.8,101.92 154.81,103.91 154.63,103.91 BIOS2.3
SPKR: length 259.1
  TOP w0.254: R2740.1 22.47,26.53 22.47,27.3 23.19,28.03 v2(23.77,28.03) 26.37,30.63 26.37,32.4 28.31,34.34 v1(29.42,34.34)
  L3 w0.254: v1(29.61,45.35) 29.61,45.33 29.39,45.11 29.39,44.39 29.95,43.83 51.25,43.83 52.83,45.41 53.97,45.41 54.84,44.54 54.84,44.39 55.4,43.83 81.4,43.83 81.62,44.05 92.41,44.05 92.63,43.83 95.99,43.83 97.94,45.78 98.66,45.78 100.03,47.14 101.86,47.14 102.12,47.14 102.4,47.14 103.78,45.77 106.79,45.77 107.64,46.62 122.24,46.62 122.61,46.25 124.33,44.53 128.1,44.53 129.96,42.67 149.36,42.67 149.94,43.26 172.65,43.26 173.43,44.04 v1(173.71,44.04)
  L4 w0.254: v1(29.42,34.34) 29.42,35.45 31.57,37.6 31.57,39.61 30.32,40.85 30.32,42.01 30.32,43.26 29.61,43.98 v1(29.61,45.35) ; v1(173.71,44.04) 173.71,44.38 173.28,44.81 173.28,46.07 173.36,46.15 173.36,46.68 173.35,46.71 173.31,46.9 173.31,47.23 173.32,47.28 173.36,47.32 173.38,47.36 173.38,47.8 173.38,47.8 173.38,49.3 172.88,49.8 172.88,50.96 167.65,56.19 167.65,56.64 165.94,58.35 165.49,58.35 159.67,64.17 158.06,64.17 156.87,65.36 156.87,66.05 157.04,66.22 157.04,67.61 151.24,73.41 149.74,73.41 v1(149.73,73.41)
  BOTTOM w0.076: 117.06,82.65 117.06,83.5 116.8,83.75 116.8,84.16 116.85,84.25 116.9,84.34 116.9,84.97 CPU1.CF35
  BOTTOM w0.254: v1(149.73,73.41) 149.73,73.23 148.59,72.08 126.39,72.08 118.6,79.88 118.6,80.11 117.81,80.9 117.81,81.39 117.06,82.14 117.06,82.65
SRTC_RST#: length 79.5
  TOP w0.102: v1(141.02,86.62) 140.8,86.84 140.8,87.48 140.87,87.55 140.87,87.99 v2(140.45,88.41) 140.38,88.48 ED1801.2 139.58,89.46 C1805.1 139.31,89.35 138.96,89.69 137.58,89.69 137.22,90.05 RN1801.3
  L3 w0.102: v1(141.02,86.62) 141.48,86.16 141.64,86.16 142.08,85.72 142.14,85.65 142.4,85.4 142.4,85.39 142.52,85.27 142.52,85.26 142.52,85.13 143.86,83.79 145,83.79 147.84,80.95 147.84,78.85 154.26,72.44 v1(154.71,72.44)
  BOTTOM w0.076: CPU1.BR37 111,83.96 111,83.72 111,83.32
  BOTTOM w0.102: 111,83.32 111,83.09 111.25,82.84 111.36,82.84 111.62,82.58 111.62,81.65 113.82,79.45 114.66,79.45 115.51,78.59 115.51,77.81 118.05,75.27 120.58,75.27 125.48,70.37 152.24,70.37 154.3,72.44 v1(154.71,72.44)
SSD2_DEVSLP: length 9.6
  BOTTOM w0.076: 126.96,102.01 126.86,101.91 123.79,101.91 123.38,102.31 122.66,102.31 CPU1.CR8
  BOTTOM w0.102: R1619.1 129.66,102.35 129.79,102.48 129.79,102.91 129.54,103.16 127.6,103.16 127.18,102.74 127.18,102.23 126.96,102.01
SSD_CLK_CPU_N_4: length 134.5
  L4 w0.114: v1(101.02,109.05) 101.02,109.06 99.39,110.69 76.99,110.69 69.85,103.56 68.58,103.56 66.88,101.85 66.88,99.49 64.09,96.7 64.09,91.69 61.58,89.18 61.58,85.24 52.35,76.02 52.35,75.2 45.65,68.5 45.65,68.3 45.04,67.69 44.4,67.69 43.08,66.37 42.64,66.37 38.34,62.06 38.34,61.64 37.57,60.88 36.62,60.88 33.92,58.19 33.04,58.19 31.98,57.13 31.98,55.93 31.1,55.06 31.1,53.39 28.93,51.22 28.93,49.81 27.48,48.36 27.48,45.11 29.5,43.08 29.5,37.95 26.62,35.07 25.08,35.07 24.03,34.01 23.4,34.01 v1(23.17,34.24)
  BOTTOM w0.127: CPU1.BA1 102,106.65 102,108.59 101.72,108.86 101.2,108.86 v1(101.02,109.05) ; v1(23.17,34.24) 23.17,34.21 23.33,34.05 23.35,34.05 23.61,33.79 23.61,33.42 23.45,33.26 SSD1.53
SSD_CLK_CPU_P_4: length 134.4
  L4 w0.114: v1(101.02,108.41) 100.54,108.89 100.54,109.22 99.29,110.46 77.08,110.46 69.95,103.33 68.68,103.33 67.11,101.76 67.11,99.4 64.32,96.61 64.32,91.59 61.81,89.09 61.81,85.15 52.58,75.92 52.58,75.11 45.88,68.41 45.88,68.2 45.13,67.46 44.5,67.46 43.18,66.14 42.74,66.14 38.57,61.97 38.57,61.55 37.67,60.65 36.71,60.65 34.02,57.96 33.13,57.96 32.21,57.03 32.21,55.84 31.33,54.96 31.33,53.29 29.16,51.12 29.16,49.72 27.71,48.26 27.71,45.2 29.73,43.18 29.73,37.85 26.72,34.84 25.18,34.84 24.12,33.78 23.35,33.78 v1(23.17,33.61)
  BOTTOM w0.127: v1(101.02,108.41) 101.23,108.62 101.62,108.62 101.76,108.49 101.76,106.24 CPU1.BA2 ; SSD1.55 22.95,33.39 v1(23.17,33.61)
SSD_DEVSLP: length 14.3
  BOTTOM w0.076: 123.62,102.36 123.51,102.47 122.49,102.47 122.41,102.45 122.07,102.45 121.8,102.55 121.79,102.55 121.1,102.55 CPU1.CM8
  BOTTOM w0.089: R1618.1 132.01,101.7 v2(132.22,101.91) 132.22,102.11 130.98,103.36 127.54,103.36 127,102.81 127,102.43 126.64,102.08 123.91,102.08 123.62,102.36
SSD_DEVSLP_R: length 233.1
  TOP w0.089: v1(32.21,35.15) 32.18,35.12 31.88,35.12 29.96,33.2 28.04,33.2 v2(27.88,33.03) 26.81,31.96 26.81,30.39 26.02,29.59 R6301.1
  L3 w0.089: v1(171.2,61.06) 171.2,61.88 167.42,65.66 167.42,66.52 161.91,72.03 161.91,72.67 153.8,80.78 153.8,83.14 152.73,84.2 152.73,85.22 149.6,88.35 149.07,88.35 138.25,99.17 137.34,99.17 133.56,102.94 133.55,102.94 133.31,103.19 133.31,103.2 133.1,103.41 v1(133.1,103.43) ; v1(32.21,35.15) 34.15,35.15 36.38,32.93 56.71,32.93 58.16,34.37 61.05,34.37 62.44,35.76 71.02,35.76 75.11,39.85 84.53,39.85 84.77,40.09 97.26,40.09 99.74,42.57 100.99,42.57 101.73,43.3 102.08,43.3 102.33,43.05 103.33,43.05 v1(103.64,43.36)
  BOTTOM w0.089: R1619.2 130.53,101.51 131.2,100.83 R1618.2 131.64,100.83 132.53,101.72 132.93,101.72 133.58,102.37 133.58,102.72 133.1,103.2 v1(133.1,103.43) ; v1(103.64,43.36) 103.64,43.36 103.64,46.15 103.18,46.6 103.18,51.1 105,52.91 110.26,52.91 110.31,52.96 110.68,52.96 111.49,53.77 111.5,53.77 111.53,53.8 144.35,53.8 144.45,53.7 144.45,53.69 144.79,53.35 146.79,53.35 147.23,52.92 157.12,52.92 157.95,53.75 164.58,53.75 164.93,53.75 166.27,55.09 167.21,55.09 168.18,56.06 168.18,56.69 171.13,59.64 171.13,60.99 v1(171.2,61.06)
SSD_ODD_SATA_RX_N12: length 31
  TOP w0.127: R1616.2 v1(124.33,120.2)
  L4 w0.114: v1(124.33,120.2) 124.04,120.49 123.24,120.49 121.01,118.26 114.99,118.26 112.37,115.65 112.37,110.31 111.82,109.75 110.56,109.75 109.43,108.62 109.43,103.35 v1(109.02,102.95)
  BOTTOM w0.127: CPU1.BL6 v1(109.02,102.95) ; v2(124.97,120.17) v1(124.33,120.2)
SSD_ODD_SATA_RX_P12: length 31.5
  TOP w0.127: R1609.2 125.11,121.11 124.64,120.64 124.46,120.64 124.33,120.76 v1(124.33,121.03)
  L4 w0.114: v1(124.33,121.03) 124.33,120.85 124.2,120.72 123.14,120.72 120.91,118.49 114.89,118.49 112.14,115.74 112.14,110.41 111.72,109.98 110.47,109.98 109.2,108.71 109.2,103.79 v1(108.99,103.58)
  BOTTOM w0.127: v1(124.33,121.03) v2(125,121.39) ; CPU1.BL5 108.81,103.95 108.96,103.85 v1(108.99,103.58)
SSD_ODD_SATA_TX_N12: length 27.7
  TOP w0.127: R1610.2 124.78,122.61 v1(124.49,122.32)
  L4 w0.114: v1(124.49,122.32) 124.29,122.12 123.17,122.12 120.3,119.24 114.68,119.24 111.43,116 111.43,115.64 111.43,115.53 111.43,112.87 110.72,112.16 110.72,111.66 v1(110.23,111.18)
  BOTTOM w0.076: CPU1.BN2 109.07,106.5 109.07,107.87 109.46,108.26 109.46,108.84 109.43,108.87 109.43,108.89
  BOTTOM w0.127: 109.43,108.89 109.43,110.37 109.69,110.63 ; 109.69,110.63 v1(110.23,111.18) ; 109.69,110.63 v2(109.6,110.72)
SSD_ODD_SATA_TX_P12: length 27
  TOP w0.127: R1611.2 125.02,122 124.8,122 124.48,121.68 v1(124.47,121.68)
  L4 w0.114: v1(124.47,121.68) 124.27,121.89 123.27,121.89 120.39,119.02 114.77,119.02 111.66,115.91 111.66,115.63 111.66,115.53 111.66,112.78 110.95,112.07 110.95,111.57 110.83,111.45 110.83,110.91 110.46,110.54 v1(110.24,110.54)
  BOTTOM w0.076: 109.67,108.89 109.67,108.87 109.64,108.84 109.64,108.19 109.25,107.8 109.25,106.86 109.3,106.74 109.35,106.63 CPU1.BN1
  BOTTOM w0.127: v1(110.24,110.54) 109.94,110.54 109.67,110.27 109.67,109.48 ; 109.67,109.48 109.67,108.89 ; 109.67,109.48 v2(109.81,109.48)
SSD_PCIE_RX_N13: length 193.8
  L4 w0.114: v1(108.1,103.5) 108.31,103.7 108.53,103.7 108.89,104.07 108.89,108.97 109.76,109.84 109.76,115.74 105.99,119.51 73.68,119.51 72.95,118.78 67.48,118.78 59.17,110.48 59.17,107.1 59.17,107.09 58.8,106.73 58.8,101.24 54.64,97.08 54.64,92.74 54.06,92.15 54.06,85.66 49.81,81.41 49.33,81.41 42.07,74.15 42.07,73.78 40.78,72.5 40.49,72.5 39.16,71.17 35.77,71.17 35.22,70.62 33.83,70.62 30.9,67.69 29.54,67.69 27.26,65.41 27.26,59.54 25.21,57.49 25.21,56.66 24.47,55.92 24.47,54.81 21.75,52.08 21.75,49.73 21.19,49.17 21.19,41.43 20.6,40.83 20.6,39.88 20.96,39.51 20.96,38.12 20.53,37.68 20.53,32.31 21.98,30.86 24.87,30.86 25.81,31.8 31.01,31.8 32.98,33.77 32.98,35.87 33.84,36.73 33.84,38.09 v1(34.13,38.38)
  BOTTOM w0.127: SSD1.5 35.45,33.3 35.33,33.42 35.33,33.94 34.52,34.76 34.52,37.6 34.13,37.99 v1(34.13,38.38) ; CPU1.BK6 v1(108.1,103.5)
SSD_PCIE_RX_N14: length 194
  L4 w0.114: v1(107.18,103.49) 107.65,104.05 107.71,104.36 108.22,104.87 108.22,109.19 109.14,110.11 109.14,115.5 105.74,118.9 73.93,118.9 73.21,118.17 67.79,118.17 60,110.38 60,101.54 56.11,97.66 56.11,92.54 54.67,91.1 54.67,85.35 50.09,80.77 49.56,80.77 42.77,73.99 42.77,73.56 41.09,71.89 40.74,71.89 39.39,70.54 38.82,70.54 38.1,69.83 33.89,69.83 30.36,66.3 29.11,66.3 27.94,65.13 27.94,59.36 25.82,57.24 25.82,56.4 25.08,55.67 25.08,54.56 22.36,51.83 22.36,49.43 21.87,48.94 21.87,39.39 21.7,39.22 21.7,37.88 21.14,37.31 21.14,32.69 22.28,31.55 24.69,31.55 25.56,32.41 30.46,32.41 31.04,32.99 31.04,34.9 33.23,37.09 33.23,39.02 33.91,39.69 v1(34.09,39.69)
  BOTTOM w0.127: v1(34.09,39.69) 32.59,39.69 32.38,39.47 31.89,39.47 31.61,39.19 31.61,34.47 32.44,33.63 32.44,33.31 32.45,33.3 SSD1.17 ; CPU1.BJ6 v1(107.18,103.49)
