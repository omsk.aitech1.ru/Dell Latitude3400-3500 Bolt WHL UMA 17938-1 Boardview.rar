# Allegro board 17938-1.1228WZS1107.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQS_DN2: length 91.9
  L2SGND w0.089: v1(96.11,87.34) 96.11,87.14 95.96,86.99 95.76,86.99 95.48,86.7 95.48,85.81 96.36,84.93 96.84,84.93 97.47,84.3 98.96,82.81 98.96,82.76
  L2SGND w0.127: v1(157.22,46.35) 157.56,46.35 157.69,46.47 157.69,49.46 156.51,50.63 156.16,50.63 142.34,64.45 141.33,65.46 108.9,65.46 98.96,75.4 98.96,82.76
  BOTTOM w0.089: v1(96.11,87.34) 96.11,87.54 96.02,87.63 CPU1.AL31
  BOTTOM w0.216: DM2.198 157.78,44 157.93,44.15 157.93,46.19 157.65,46.47 157.34,46.47 v1(157.22,46.35)
M_B_DQS_DN3: length 92.3
  L2SGND w0.089: v1(99.75,87.33) 99.75,85.98 101.26,84.47 102.26,84.47 103.29,83.44 103.29,80.61 102.97,80.28 102.97,77.94 103.37,77.55 103.96,77.55 104.04,77.47 104.04,77.44 104.04,77.44
  L2SGND w0.127: v1(163.96,48.38) 162.85,48.38 162.59,48.64 162.59,49.26 162.84,49.51 163.04,49.51 163.16,49.64 163.16,49.95 162.86,50.25 162.53,50.25 161.95,50.83 161.95,51.23 161.5,51.69 161.09,51.69 160.51,52.27 160.51,52.67 159.86,53.32 159.46,53.32 158.88,53.9 158.88,54.3 158.42,54.76 158.02,54.76 157.44,55.34 157.44,55.74 144.04,69.14 110.47,69.14 105.08,74.54 105.08,75.14 104.72,75.5 104.72,76.76 104.04,77.44
  BOTTOM w0.089: CPU1.AU31 99.47,87.63 99.75,87.35 v1(99.75,87.33)
  BOTTOM w0.216: v1(163.96,48.38) 163.73,48.38 163.11,49 163.11,50.13 163.03,50.21 DM2.219
M_B_DQS_DN4: length 49.7
  L4 w0.089: 109.41,72 109.41,72.03 103.57,77.87 103.57,78.45 104.08,78.96 104.08,79.38 v1(103.92,79.55)
  L4 w0.165: v1(119.52,49.21) 119.5,49.22 119.5,59.36 118.92,59.95 118.69,59.95 118.46,59.72 118.02,59.72 117.52,60.22 117.52,60.67 117.74,60.89 117.74,61.13 117.39,61.48 117.16,61.48 116.93,61.25 116.49,61.25 115.99,61.75 115.99,62.2 116.21,62.42 116.21,62.65 115.86,63 115.63,63 115.39,62.76 114.98,62.76 114.43,63.31 114.43,63.7 114.69,63.95 114.69,64.18 114.34,64.53 114.1,64.53 113.86,64.29 113.45,64.29 112.91,64.84 112.91,65.23 113.16,65.48 113.16,65.71 109.41,69.46 109.41,72
  BOTTOM w0.076: CPU1.BB35 102.77,85.19 102.84,85.26 102.91,85.26 102.97,85.2 102.98,85.17 102.99,85.14 103.01,85.08 103.02,85.06 103.02,84.89 102.99,84.73 102.99,84.54 103.02,84.39 103.02,84.23 102.99,84.09 102.98,83.69 102.98,83.13 102.99,82.56 103.18,81.4 103.36,80.64 103.53,80.19 103.54,80.15 103.54,80.09 v1(103.92,79.55)
  BOTTOM w0.216: v1(119.52,49.21) 119.52,49.41 119.52,49.41 119.52,49.82 119.53,49.83 DM2.53
M_B_DQS_DN5: length 59.4
  L4 w0.089: v1(107.58,79.61) 108.28,79.61 108.52,79.37 108.52,77.38 111.35,74.55 114.11,74.55 114.79,73.87 115.5,73.87 115.6,73.77 115.6,73.76 115.89,73.47 115.91,73.47 115.98,73.39
  L4 w0.165: v1(125.47,47.33) 125.47,47.34 125.64,47.51 125.67,47.51 125.68,47.52 126.61,47.52 127.16,48.06 127.16,50.58 127.32,50.74 127.6,50.74 127.91,51.06 127.91,51.76 127.6,52.08 127.32,52.08 127.16,52.24 127.16,52.74 127.32,52.9 127.6,52.9 127.91,53.22 127.91,53.92 127.6,54.24 127.32,54.24 127.16,54.4 127.16,62.22 115.98,73.39
  BOTTOM w0.076: CPU1.BF34 105.3,85.61 105.34,85.6 105.41,85.6 105.61,85.4 105.63,85.32 105.66,85.24 105.68,85.2 105.7,85.14 105.72,85.09 105.72,84.86 105.68,84.72 105.68,84.55 105.72,84.44 105.72,84.19 105.69,84.09 105.67,83.98 105.64,83.93 105.64,82.42 106.28,81.79 106.28,80.01 106.93,79.35 107.32,79.35 v1(107.58,79.61)
  BOTTOM w0.216: DM2.74 124.78,43.9 124.93,44.06 124.93,45.39 125.97,46.43 125.97,47.36 125.85,47.48 125.62,47.48 v1(125.47,47.33)
M_B_DQS_DN6: length 95.4
  L2SGND w0.089: v1(103.44,87.37) 103.48,87.37 103.7,87.15 103.7,87.13 103.71,87.13 103.71,86.45 104.07,86.09 104.53,86.09 105.86,84.75 105.86,84.75 106.08,84.53 106.68,84.53 106.93,84.53 107.57,83.9 107.57,82.61 107.82,82.36 107.82,82.33 107.86,82.29 107.86,82.26 107.87,82.26
  L2SGND w0.127: 107.87,82.26 108.56,81.56 108.56,77.25 112.79,73.03 146.61,73.03 170.01,49.63 170.01,45.35 169.88,45.22 169.68,45.22 v1(169.27,45.63)
  BOTTOM w0.089: v1(103.44,87.37) 103.39,87.58 103.2,87.69 CPU1.BC31
  BOTTOM w0.216: DM2.240 168.28,43.66 168.38,43.76 168.38,45.45 168.56,45.63 v1(169.27,45.63)
M_B_DQS_DN7: length 71.6
  L4 w0.089: 115.62,77.99 115.61,77.99 115.59,78.01 115.37,78.01 115.36,78 112.66,78 111.27,79.4 111.27,80.3 108.38,83.18 108.38,84.05 107.52,84.91 107.52,86.14 107.42,86.24 107.42,86.82 107.4,86.84 107.4,87.31 107.34,87.37 v1(107.09,87.37)
  L4 w0.165: 115.62,77.99 119.63,77.99 120.56,77.06 120.56,76.82 120.45,76.71 120.45,76.27 120.95,75.77 121.39,75.77 121.5,75.88 121.74,75.88 122.09,75.53 122.09,75.3 121.97,75.18 121.97,74.74 122.47,74.24 122.92,74.24 123.03,74.35 123.27,74.35 123.62,74 123.62,73.77 123.5,73.65 123.5,73.21 124,72.71 124.45,72.71 124.56,72.82 124.79,72.82 125.38,72.24 125.38,71.34 143.69,53.02 148.18,53.02 151.64,49.56 151.64,48.32 151.95,48.01 v1(152.73,48.01)
  BOTTOM w0.216: CPU1.BH31 v1(107.09,87.37) ; DM2.177 152.53,50.08 152.52,50.06 152.48,49.98 152.48,49.98 152.38,49.88 152.38,48.86 152.36,48.84 152.36,48.36 152.63,48.08 152.66,48.08 v1(152.73,48.01)
M_B_DQS_DP0: length 51.2
  L4 w0.089: 98.76,71.47 98.76,71.48 98.74,71.52 99.07,72.32 99.07,79.52 98.02,80.57 97.41,80.57 v1(97.23,80.75)
  L4 w0.165: v1(109.22,48.77) 109.22,49.3 109.32,49.4 109.32,49.91 107.81,51.42 102.85,51.42 102.26,52.01 101.82,52.01 101.5,51.68 101.27,51.68 100.91,52.03 100.91,52.27 101.24,52.59 101.24,53.03 100.74,53.53 100.29,53.53 99.97,53.21 99.74,53.21 99.39,53.56 99.39,53.8 99.71,54.12 99.71,54.56 98.45,55.82 98.45,70.81 98.76,71.11 98.76,71.47
  BOTTOM w0.076: v1(97.23,80.75) 97.59,81.1 97.59,81.67 97.6,81.68 97.67,82.45 97.67,83.14 97.52,83.53 97.34,83.76 97.34,84.08 97.3,84.18 97.3,84.44 97.34,84.54 97.34,84.73 97.3,84.83 97.3,85.09 97.35,85.21 97.37,85.23 97.46,85.32 97.54,85.36 97.55,85.36 97.63,85.4 97.67,85.42 97.74,85.48 CPU1.AP34
  BOTTOM w0.216: DM2.13 109.53,50.23 109.37,50.07 109.37,49.14 109.22,49 v1(109.22,48.77)
M_B_DQS_DP1: length 49.3
  L4 w0.089: 102.66,73.22 102.65,73.22 101.94,73.93 101.94,78.19 101.94,78.19 101.94,78.64 v1(101.57,79.02)
  L4 w0.165: v1(113.95,48.06) 114.25,48.06 114.38,48.19 114.38,48.65 113.89,49.14 113.89,52.24 111.63,54.49 111.63,55.67 104.08,63.22 104.08,71.8 102.66,73.22
  BOTTOM w0.076: v1(101.57,79.02) 101.17,79.42 101.17,79.82 101.17,79.83 100.98,80.03 100.97,80.04 100.96,80.05 100.5,81.71 100.5,83.43 100.47,83.93 100.47,84.07 100.48,84.12 100.48,84.13 100.51,84.24 100.51,84.39 100.47,84.53 100.47,84.74 100.51,84.88 100.51,85.06 100.5,85.08 100.48,85.14 100.46,85.19 100.44,85.23 100.42,85.26 100.33,85.26 100.25,85.19 CPU1.AV35
  BOTTOM w0.216: DM2.34 114.78,43.84 114.62,44 114.62,47.59 114.15,48.06 v1(113.95,48.06)
M_B_DQS_DP2: length 92
  L2SGND w0.089: v1(96.15,88.02) 95.63,87.5 95.63,87.12 95.62,87.11 95.29,86.78 95.29,85.73 96.28,84.74 96.76,84.74 97.33,84.17 98.73,82.76 98.73,82.6
  L2SGND w0.127: v1(157.23,46.98) 157.46,47.21 157.46,49.36 156.42,50.4 156.07,50.4 141.24,65.23 108.81,65.23 98.73,75.31 98.73,82.6
  BOTTOM w0.089: v1(96.15,88.02) CPU1.AL30
  BOTTOM w0.216: DM2.200 158.28,46.33 157.82,46.79 157.82,46.79 157.61,47 157.24,47 v1(157.23,46.98)
M_B_DQS_DP3: length 92.4
  L2SGND w0.089: 104.2,77.6 104.07,77.74 103.44,77.74 103.16,78.02 103.16,80.2 103.48,80.53 103.48,83.52 102.33,84.66 101.33,84.66 99.94,86.06 99.94,86.95 100.15,87.16 100.15,87.66 v1(99.79,88.02)
  L2SGND w0.127: 104.2,77.6 104.95,76.85 104.95,75.59 105.31,75.24 105.31,74.63 110.57,69.37 144.14,69.37 157.67,55.84 157.67,55.44 158.12,54.99 158.52,54.99 159.1,54.4 159.1,54 159.56,53.55 159.96,53.55 160.74,52.77 160.74,52.37 161.19,51.91 161.59,51.91 162.18,51.33 162.18,50.93 162.63,50.48 162.96,50.48 163.39,50.05 163.39,49.54 163.13,49.28 162.94,49.28 162.82,49.17 162.82,48.74 162.95,48.61 163.56,48.61 163.77,48.83 163.78,48.83 v1(163.97,49.02)
  BOTTOM w0.089: v1(99.79,88.02) CPU1.AU30
  BOTTOM w0.216: v1(163.97,49.02) 163.58,49.02 163.45,49.14 163.45,50.15 163.53,50.22 DM2.221
M_B_DQS_DP4: length 49.5
  L4 w0.089: v1(103.96,80.18) 104.32,79.83 104.32,79.38 104.27,79.34 104.27,78.89 103.76,78.38 103.76,77.95 109.47,72.24 109.56,72.24 109.66,72.13
  L4 w0.165: v1(120,49.61) 119.76,49.86 119.76,59.47 119.02,60.2 118.58,60.2 118.36,59.98 118.12,59.98 117.77,60.33 117.77,60.56 118,60.79 118,61.23 117.5,61.73 117.05,61.73 116.83,61.51 116.6,61.51 116.24,61.86 116.24,62.09 116.47,62.31 116.47,62.76 115.97,63.26 115.52,63.26 115.29,63.02 115.08,63.02 114.69,63.41 114.69,63.59 114.94,63.84 114.94,64.29 114.44,64.79 114,64.79 113.75,64.54 113.56,64.54 113.16,64.94 113.16,65.12 113.41,65.37 113.41,65.82 109.66,69.56 109.66,72.13
  BOTTOM w0.076: CPU1.BB34 102.89,85.6 103.09,85.4 103.13,85.29 103.16,85.2 103.18,85.14 103.2,85.08 103.2,84.87 103.17,84.71 103.17,84.56 103.2,84.41 103.2,84.21 103.17,84.06 103.15,83.69 103.15,83.13 103.17,82.58 103.36,81.43 103.53,80.7 103.7,80.25 103.7,80.24 103.76,80.18 v1(103.96,80.18)
  BOTTOM w0.216: DM2.55 120.03,50.33 119.87,50.17 119.87,49.75 v1(120,49.61)
M_B_DQS_DP5: length 59.4
  L4 w0.089: v1(107.58,78.98) 108.02,79.42 108.2,79.42 108.33,79.29 108.33,77.3 111.27,74.35 114.03,74.35 114.71,73.68 115.41,73.68 115.68,73.4 115.68,73.33 115.8,73.21
  L4 w0.165: 115.8,73.21 126.9,62.11 126.9,54.3 127.22,53.98 127.49,53.98 127.66,53.82 127.66,53.32 127.49,53.16 127.22,53.16 126.9,52.84 126.9,52.14 127.22,51.82 127.49,51.82 127.66,51.66 127.66,51.16 127.49,51 127.22,51 126.9,50.68 126.9,48.16 126.51,47.77 125.69,47.77 125.49,47.96 v1(125.48,47.96)
  BOTTOM w0.076: CPU1.BF35 105.29,85.19 105.36,85.26 105.45,85.26 105.48,85.23 105.49,85.19 105.5,85.18 105.51,85.14 105.53,85.08 105.54,85.06 105.54,84.88 105.51,84.74 105.51,84.53 105.54,84.39 105.54,84.24 105.52,84.13 105.52,84.12 105.51,84.07 105.46,83.97 105.46,82.35 106.1,81.72 106.1,79.94 106.86,79.17 107.38,79.17 v1(107.58,78.98)
  BOTTOM w0.216: v1(125.48,47.96) 125.49,47.96 125.63,47.83 125.99,47.83 126.32,47.5 126.32,46.29 125.28,45.25 DM2.76
M_B_DQS_DP6: length 95.2
  L2SGND w0.089: v1(103.44,88.02) 103.9,87.56 103.9,86.53 104.15,86.28 104.61,86.28 106.05,84.83 106.16,84.72 106.6,84.72 107.01,84.72 107.76,83.97 107.76,82.69 108.03,82.42
  L2SGND w0.127: 108.03,82.42 108.79,81.66 108.79,77.34 112.88,73.25 146.71,73.25 166.17,53.79 170.23,49.73 170.23,45.25 169.97,44.99 v1(169.27,44.99)
  BOTTOM w0.089: v1(103.44,88.02) CPU1.BC30
  BOTTOM w0.216: DM2.242 168.78,43.73 168.72,43.78 168.72,44.91 168.81,44.99 v1(169.27,44.99)
M_B_DQS_DP7: length 71.5
  L4 w0.089: 115.62,78.24 115.57,78.24 115.53,78.2 115.29,78.2 115.28,78.2 112.74,78.2 111.46,79.48 111.46,80.38 111.4,80.44 111.24,80.6 108.58,83.26 108.58,84.13 107.71,84.99 107.71,86.22 107.61,86.32 107.61,86.9 107.59,86.92 107.59,87.51 v1(107.09,88.02)
  L4 w0.165: 115.62,78.24 119.74,78.24 120.81,77.16 120.81,76.72 120.7,76.6 120.7,76.37 121.05,76.02 121.28,76.02 121.4,76.13 121.84,76.13 122.34,75.63 122.34,75.19 122.23,75.08 122.23,74.84 122.58,74.49 122.81,74.49 122.93,74.61 123.37,74.61 123.87,74.11 123.87,73.66 123.76,73.55 123.76,73.32 124.11,72.96 124.34,72.96 124.45,73.08 124.9,73.08 125.63,72.34 125.63,71.44 143.79,53.28 148.28,53.28 151.9,49.66 151.9,48.43 152.06,48.26 152.2,48.26 152.57,48.64 v1(152.85,48.64)
  BOTTOM w0.216: v1(152.85,48.64) 152.73,48.76 152.73,49.74 153.03,50.04 DM2.179 ; v1(107.09,88.02) 106.94,87.98 106.67,88.13 CPU1.BH30
M_B_PARITY: length 86.1
  L2SGND w0.114: v1(140.06,52.56) 139.75,52.87 137.81,52.87 136.67,54 136.67,54.17 137.71,55.2 137.71,55.34 137.53,55.52 137.38,55.52 136.35,54.49 136.19,54.49 135.99,54.68 135.99,54.84 137.07,55.92 137.07,56.06 136.89,56.24 136.75,56.24 135.67,55.17 135.51,55.17 135.34,55.33 135.34,55.49 136.27,56.42 136.27,56.58 136.11,56.74 135.94,56.74 135.02,55.82 134.86,55.82 134.7,55.98 134.7,56.14 134.99,56.43 134.99,56.59 134.84,56.74 134.65,56.74 134.37,56.46 134.21,56.46 133.94,56.74 104.83,56.74 100.66,60.91 100.13,60.91 100.11,60.94 91.8,69.24 91.8,75.78 92.3,76.28 92.3,77.55 91.87,77.98 91.87,78.99 v1(91.32,79.55)
  BOTTOM w0.076: CPU1.AE34 92.05,85.73 91.74,85.42 91.74,84.35 91.62,84.14 91.62,83.76 91.82,83.57 91.82,83.2 91.42,82.8 91.42,80.05 91.32,79.95 v1(91.32,79.55)
  BOTTOM w0.216: DM2.143 142.03,51.89 141.94,51.98 141.94,52.07 141.8,52.21 140.41,52.21 v1(140.06,52.56)
M_VREF_CA_DIMMA: length 4.2
  TOP w0.305: v1(73.03,44.56) 72.62,44.97 C1229.1
  BOTTOM w0.305: v1(72.47,41.64) 72.48,41.66 72.7,41.66 72.72,41.68 73.08,42.03 DM1.164 73.08,44.52 v1(73.03,44.56)
  vias: v2(72.47,42.27)
M_VREF_CA_DIMMB: length 1.6
  BOTTOM w0.203: v1(149.23,44.43) 149.28,44.39 DM2.164
  vias: v2(148.8,42.8)
MASK_SATA_LED#: length 100.7
  TOP w0.102: U2401.56 34.35,59.55 35.07,60.26 v1(35.07,60.37) ; v1(65.41,39.08) 65.41,41.15 64.6,41.96 61.67,41.96 v1(61.32,41.61) ; v1(20.03,36.52) 19.71,36.52 19.59,36.65 19.59,39.29 19.88,39.58 19.99,39.58 20.42,40.02 20.42,40.21 22.81,42.6 22.81,44.08 22.8,44.09 22.8,47.09 22.81,47.1 22.81,47.14 24.9,49.23 v2(25.68,49.23) 27.34,49.23 v1(27.94,49.84)
  L3 w0.102: v1(65.41,39.08) 65.26,38.93 61.84,38.93 61.03,38.12 61.03,36.26 60.31,35.54 56.57,35.54 55.91,35.54 54.46,34.09 40.85,34.09 40.31,34.63 40.31,37.34 38.74,38.91 35.91,38.91 34.1,40.72 33.69,40.72 33.68,40.71 33.65,40.71 33.43,40.5 33.39,40.5 33.35,40.46 32.52,40.46 31.93,41.05 29.49,41.05 26.6,43.94 26.6,48.57 27.87,49.84 v1(27.94,49.84) 27.71,50.07 27.71,51.36 30.5,54.15 30.5,54.32 30.5,57.26 32.37,59.13 33.83,59.13 v1(35.07,60.37)
  BOTTOM w0.089: v1(61.32,41.61) 61.88,41.61 62,41.48 R6403.2
  BOTTOM w0.102: v1(20.03,36.52) 20.03,36.31 22.04,34.31 Q6401.G
MCT:
  vias: v1(25.47,85.57) v1(26.11,85.61) v1(26.76,85.61) v2(25.53,86.23)
MCT0: length 2.5
  TOP w0.102: XF3201.3 28.56,86.53 27.73,87.36 RN3201.1
MCT1: length 8.5
  TOP w0.089: RN3201.2 v1(26.4,88.04)
  TOP w0.102: v1(27.59,82.44) 27.86,82.72 XF3201.4
  L3 w0.102: v1(26.4,88.04) 26.4,87.14 27.66,85.88 27.66,82.63 27.66,82.52 v1(27.59,82.44)
MCT2: length 10
  TOP w0.089: v1(25.77,88.04) 25.79,88.01 25.79,87.48 RN3201.3
  L3 w0.102: v1(25.77,88.04) 26.08,87.72 26.08,87.05 27.4,85.73 27.4,82.93 27.15,82.67 27.15,82.12 v1(27.52,81.75)
  BOTTOM w0.102: v1(27.52,81.75) 28.49,82.72 XF3202.3
MCT3: length 5
  TOP w0.102: v1(27.61,86.81) 27.55,86.87 25.58,86.87 25.31,87.14 RN3201.4
  BOTTOM w0.102: XF3202.4 27.89,86.53 v1(27.61,86.81) 27.16,87.27 v2(27.16,87.28)
MDO0+: length 20.6
  BOTTOM w0.089: XF3202.6 28.21,89.07 28.12,88.98 28.12,88.66 27.99,88.53 27.3,88.53 26.91,88.93 25.28,88.93 24.79,88.44 ; RJ1.1 13.74,80.22 13.94,80.42 16.23,80.42 21.97,86.16 22.51,86.16 24.79,88.44 ; 24.79,88.44 AFTP3204.1
MDO0-: length 20.4
  BOTTOM w0.089: 23.41,86.75 22.6,85.94 22.06,85.94 16.32,80.2 14.03,80.2 13.91,80.08 13.91,79.24 RJ1.2 ; 23.41,86.75 25.37,88.71 26.82,88.71 27.21,88.32 28.01,88.32 28.12,88.21 28.12,87.89 28.21,87.8 XF3202.5 ; 23.41,86.75 AFTP3201.1
MDO1+: length 18.9
  BOTTOM w0.089: 26.24,81.13 AFTP3202.1 ; 26.24,81.13 26.42,80.95 28,80.95 28.08,81.04 28.08,81.33 28.21,81.45 XF3202.2 ; 26.24,81.13 25.76,81.61 22.58,81.61 18.73,77.76 14.97,77.76 14.54,78.18 RJ1.3
MDO1-: length 19.4
  BOTTOM w0.089: AFTP3208.1 24.46,81.4 ; 24.46,81.4 25.67,81.4 26.33,80.73 27.94,80.73 28.08,80.59 28.08,80.3 28.21,80.18 XF3202.1 ; 24.46,81.4 22.67,81.4 18.82,77.54 15.05,77.54 14.96,77.45 14.96,76.13 RJ1.6
MDO2+: length 26.6
  TOP w0.089: 26.58,84.6 24.32,82.34 21.28,82.34 15.3,76.36 13.97,76.36 13.87,76.46 13.87,77.08 RJ1.4 ; 26.58,84.6 26.67,84.68 30.43,84.68 30.74,85 30.74,88.11 30.55,88.3 30.28,88.3 30.19,88.21 30.19,87.89 30.1,87.8 XF3201.2 ; 26.58,84.6 AFTP3205.1
MDO2-: length 27.6
  TOP w0.089: 19.16,79.91 15.39,76.14 RJ1.5 ; 19.16,79.91 AFTP3207.1 ; 19.16,79.91 21.37,82.12 24.41,82.12 26.76,84.47 30.52,84.47 30.96,84.91 30.96,88.2 30.59,88.57 30.28,88.57 30.19,88.66 30.19,88.98 30.1,89.07 XF3201.1
MDO3+: length 27.6
  TOP w0.089: XF3201.6 30.1,80.18 30.19,80.27 30.19,80.57 30.3,80.68 31,80.68 31.3,80.98 31.3,82.93 30.34,83.88 27.32,83.88 24.78,81.34 22.21,81.34 18.74,77.87 ; 18.74,77.87 15.17,74.3 14.17,74.3 13.97,74.1 RJ1.7 ; 18.74,77.87 AFTP3209.1
MDO3-: length 26.6
  TOP w0.089: AFTP3206.1 26.11,82.37 ; 26.11,82.37 27.41,83.67 30.25,83.67 31.08,82.84 31.08,81.07 30.91,80.89 30.37,80.89 30.19,81.08 30.19,81.36 30.1,81.45 XF3201.5 ; 26.11,82.37 24.87,81.13 22.3,81.13 15.26,74.08 14.26,74.08 13.95,73.77 RJ1.8
ME_FWP: length 63
  TOP w0.102: 16.51,39.75 16.84,39.42 AFTP6803.1 16.44,38.38 14.89,39.93 12.63,39.93 11.48,41.07 v1(10.19,41.07) ; v1(36.07,64.65) 35.72,65 35.72,66.17 35.97,66.42 36.99,66.42 37.26,66.14 37.26,65.96 37.52,65.71 37.98,65.71 38.36,66.09 U2401.80
  L3 w0.102: v1(36.07,64.65) 35.59,65.13 33.79,65.13 31.97,63.3 31.97,60.65 28.76,57.44 28.76,54.81 28.65,54.71 28.65,54.7 28.39,54.43 27.64,54.43 24.92,51.72 24.92,50.96 25.29,50.6 v1(25.35,50.6)
  BOTTOM w0.102: v1(25.35,50.6) 25.85,50.11 25.85,49.52 25.62,49.3 25.06,49.3 24.13,50.23 24.13,50.92 23.79,51.26 18.99,51.26 17.62,49.89 17.62,48.95 17.4,48.73 16.7,48.73 16.57,48.85 14.93,48.85 13.55,47.47 12.91,47.47 12.7,47.27 12.7,45.92 12.4,45.62 12.4,45.2 12.34,45.07 12.31,44.91 12.31,44.74 12.34,44.58 12.4,44.45 12.4,44.04 12.94,43.5 12.94,42.81 12.3,42.17 12.3,41.43 11.94,41.07 MESW1.3 v1(10.19,41.07)
ME_FWP_R: length 44.4
  TOP w0.102: R1909.1 26.7,22.17 26.7,21.71 v1(26.52,21.53) ; v1(10.19,42.57) 10.42,42.57 12.71,40.29 14.56,40.29 15.7,41.43 16.21,41.43 AFTP6802.1 16.41,40.72 R6878.2
  L3 w0.102: v1(10.19,42.57) 10.85,42.57 12.5,40.92 13.77,40.92 16.39,38.3 16.39,30.68 15.67,29.97 15.67,29.56 15.93,29.31 17.73,29.31 20.36,26.68 20.36,23.92 21.98,22.3 25.68,22.3 26.45,21.53 v1(26.52,21.53)
  BOTTOM w0.102: MESW1.2 v1(10.19,42.57)
ME_SUS_PWR_ACK_R: length 9.3
  TOP w0.102: R1738.2 115.93,90.15 v2(115.92,90.15) 115.72,90.35 115.13,90.35 114.81,90.03 114.81,87.88 114.28,87.35 R1708.1 114.16,87.35 113.78,87.72 113.36,87.72 113.32,87.68 113.3,87.68 113.22,87.6 113.22,87.6 112.89,87.27 v1(112.52,87.27)
  BOTTOM w0.102: CPU1.BV34 113.13,85.9 113.13,86.45 112.52,87.06 v1(112.52,87.27)
MEC_XTAL1_R: length 3.7
  TOP w0.14: U2401.123 27.15,74.56 27.34,74.74 27.37,74.74 27.37,74.75 27.5,74.75 27.73,74.98 27.73,75.13 27.74,75.13 C2425.2 27.8,75.62 28.06,75.84 28.06,75.88 28.41,76.23 X2401.1
MEC_XTAL2: length 4.7
  TOP w0.14: R2461.2 25.17,76.96 X2401.2 25.95,75.68 C2424.2 26.35,75.28 26.35,75.25 26.44,75.17 26.44,74.79 26.4,74.74 26.4,74.71 26.35,74.67 U2401.125
MEM_SMBCLK: length 30.1
  TOP w0.14: RN1807.7 135.29,97.55 134.24,98.6 v1(133.51,98.6)
  L3 w0.102: v1(119.54,98.06) 119.96,97.64 120.73,97.64 120.77,97.68 121.41,97.68
  L3 w0.127: 121.41,97.68 123.61,97.68 124.75,96.54 130.35,96.54 130.88,97.07 130.88,97.58 130.88,97.8 131.35,98.27 133.18,98.27 v1(133.51,98.6)
  BOTTOM w0.14: Q1801.3 137.87,105.96 138.26,105.57 138.26,104.05 136.85,102.63 135.62,102.63 135.02,102.04 135.02,101.9 134.8,101.68 134.8,101.68 134.17,101.05 v2(134.17,99.26) v1(133.51,98.6) ; v1(119.54,98.06) 119.67,98.1 CPU1.CK14
MEM_SMBDATA: length 29.6
  TOP w0.14: v1(134.19,98.01) 134.33,98.01 135.37,96.97 RN1807.8
  L3 w0.102: v1(118.84,97.07) 119.25,97.48 119.65,97.48 119.68,97.45 120.8,97.45 120.87,97.37 121.35,97.37
  L3 w0.127: 121.35,97.37 123.53,97.37 124.62,96.28 130.45,96.28 131.13,96.96 131.13,97.68 131.47,98.02 134.04,98.02 134.05,98.01 v1(134.19,98.01)
  BOTTOM w0.127: CPU1.CH15 v1(118.84,97.07)
  BOTTOM w0.14: Q1801.6 139.23,104.13 137.18,102.08 135.85,102.08 135.58,101.81 135.58,99.83 v2(135.8,99.62) v1(134.19,98.01)
MESW1_B: length 29.7
  TOP w0.254: v1(15.47,30.41) 16.46,31.4 AFTP6801.1 17.25,31.37 R6877.1 ; R6804.1 16.49,42.65 13.75,42.65 13.73,42.66 12.96,43.42 12.93,43.43 12.61,43.56 11.28,43.56 v1(10.87,43.97)
  L3 w0.254: v1(10.87,43.97) 10.77,43.97 9.68,42.88 9.68,42.34 10.11,41.91 10.92,41.91 12.37,40.46 13.79,40.46 15.29,38.96 15.29,30.58 v1(15.47,30.41)
  BOTTOM w0.254: MESW1.1 11.4,44.49 v1(10.87,43.97)
MIC2_VREFO: length 14
  TOP w0.203: v1(25.89,10.49) 25.89,10.59 25.93,10.63 HDA27.23
  TOP w0.254: RN2901.2 20.73,16.34 20.72,16.35 20.3,16.35 19.99,16.66 v1(19.82,16.66) 20.18,17.02 20.72,17.02 20.73,17.01 RN2901.1
  L3 w0.254: v1(25.89,10.49) 25.86,10.52 25.86,10.64 24.69,11.81 24.69,15.8 23.83,16.66 v1(19.82,16.66)
MIC_CAP: length 5.7
  TOP w0.203: 23.12,13.97 HDA27.15
  TOP w0.254: 23.12,13.97 22.77,13.97 v2(21.84,14.89) 21.39,15.34 19.92,15.34 C2715.1
MODEL_ID: length 9.9
  TOP w0.102: R2442.2 39.6,77.17 C2407.2 38.48,77.17 v2(38.2,76.89) 38.2,76.79 37.35,75.93 36.67,75.93 R2441.1 35.87,76.07 35.87,76.04 35.55,75.72 33.35,75.72 33.07,75.44 32.95,75.44 32.69,75.19 32.69,74.63 32.75,74.56 U2401.109
MSATA_DEVSLP_R: length 3.9
  TOP w0.102: v1(26.22,26.82) 25.89,27.15 v2(25.89,27.4) 25.89,28.19 R6301.2
  BOTTOM w0.089: v1(26.22,26.82) 26.47,26.82 27.2,26.09 SSD1.38
MUX_CRT_AUX_CPU_N: length 1.4
  TOP w0.127: U5802.29 55.84,119.23 56.24,119.64 R5825.2
MUX_CRT_AUX_CPU_P: length 1.2
  TOP w0.127: R5824.2 56.22,118.83 U5802.28
MUX_HPD_PD: length 2.6
  TOP w0.102: R7118.1 23.27,110.29 22.6,109.62 U7101.23
MUX_SAI: length 1.3
  TOP w0.102: R7127.2 33,120.84 32.64,120.36 U7102.14
MUX_SAO: length 1
  TOP w0.102: R7129.2 32.24,120.71 U7102.15
MUX_SBI: length 2.6
  TOP w0.102: R7128.2 35.05,120.37 34.87,120.37 34.72,120.22 34.11,120.22 34.01,120.32 33.63,120.32 33.44,120.13 U7102.12
MUX_SBO: length 1.8
  TOP w0.102: R7130.2 35.16,120.16 35,120.16 34.83,119.98 34,119.98 U7102.11
NB_MUTE#: length 102.8
  TOP w0.102: U2401.119 28.76,73.13 28.98,72.9 28.98,71.83 28.62,71.48 25.75,71.48 25.28,71.95 25.28,72.37 23.91,73.74 23.91,74.19 23.09,75.01 22.56,75.01 21.97,75.59 21.97,76.3 21.72,76.56 21.25,76.56 20.12,75.43 v2(20.12,75.06) 20.12,74.63 19.15,73.66 18.98,73.66 18.52,73.2 v1(18.52,72.21) ; R2717.2 31.09,16.71 31.78,17.4 R2712.1 32.29,17.4 32.53,17.15 v1(32.53,17.09)
  L3 w0.102: v1(11.51,65.94) 11.41,65.84 11.41,64.97 13.68,62.71 13.68,59.8 13.98,59.5 13.98,58.44 13.99,58.43 13.99,58.12 14.98,57.13 14.98,52.36 15.14,52.2 15.14,50.34 14.44,49.64 14.44,44.21 14.13,43.89 12.47,43.89 11.97,44.4 10.7,44.4 9.38,43.08 9.38,42.19 9.96,41.61 10.77,41.61 12.22,40.16 13.54,40.16 14.99,38.71 14.99,29.96 16.45,28.5 17.67,28.5 19.75,26.42 19.75,24.04 21.78,22.01 25.38,22.01 26.8,20.59 28.51,20.59 29.82,19.28 31.83,19.28 32.54,18.57 32.54,17.1 v1(32.53,17.09)
  BOTTOM w0.102: v1(18.52,72.21) 17.11,72.21 16,71.09 16,69.64 14.09,67.73 13.62,67.73 12.62,66.73 11.76,66.73 11.51,66.47 v1(11.51,65.94)
NC_AUX_EN_WOWL_EC: length 18.2
  TOP w0.102: R2409.1 19.04,57.22 19.17,57.34 19.82,57.34 20.19,57.72 20.19,58.06 21,58.87 24.11,58.87 24.67,58.3 24.67,57.8 25.27,57.2 25.27,55.74 v1(26.36,54.64) 26.82,54.64 27.1,54.92 v2(27.1,54.99) 27.3,55.19 27.3,55.84 28.36,56.9 U2401.41
  BOTTOM w0.102: R2403.1 25.34,53.61 v1(26.36,54.64)
NCT7718_DXN: length 87
  TOP w0.254: U2601.3 133.37,125.4 C2607.2 134.22,125.4 C2606.2 135.11,124.81 135.11,123.7 134.55,123.14 134.55,121.86 135.82,120.59 135.82,112.81 136.24,112.38 136.24,104.07 139.61,100.7 139.61,97.85 147.04,90.43 147.04,86.65 149.75,83.94 149.75,83.1 149.46,82.81 149.46,81.27 150.04,80.69 150.04,78.59 152.45,76.18 152.91,76.18 160.31,68.79 ; 160.31,68.79 v2(160.35,68.84) ; 160.31,68.79 161.07,68.03 161.42,68.03 v1(161.53,68.14)
  BOTTOM w0.254: v1(161.53,68.14) 161.79,68.39 161.79,73.21 163.66,75.08 165.73,75.08 167.03,76.38 167.03,78.14 166.64,78.53 Q2603.E
NCT7718_DXP: length 89.6
  TOP w0.254: U2601.2 133.12,124.75 C2607.1 134.12,124.49 C2606.1 134.5,124.1 134.5,123.81 134.04,123.35 134.04,121.65 135.31,120.38 135.31,112.6 135.74,112.17 135.74,103.86 139.11,100.49 139.11,97.64 146.54,90.21 146.54,86.44 149.1,83.87 149.1,83.87 149.24,83.73 149.24,83.31 148.95,83.02 148.95,81.06 149.53,80.48 149.53,78.37 152.23,75.67 152.7,75.67 159.16,69.22 ; v1(161.99,67.68) 161.83,67.52 160.86,67.52 159.16,69.22 ; 159.16,69.22 v2(159.08,69.14)
  BOTTOM w0.254: v1(161.99,67.68) 162.04,67.73 162.04,67.84 162.3,68.1 162.3,73 163.87,74.57 165.94,74.57 167.54,76.17 167.54,78.14 167.94,78.53 Q2603.B 168.06,79.73 Q2603.C
NRB_BIT: length 38.5
  L4 w0.102: v1(117.1,88.62) 117.53,88.19 117.53,87.26 117.93,86.86 118.96,86.86 119.24,87.14 120.98,87.14 121.07,87.05 123.87,87.05 126.33,84.59 126.33,83.12 128.75,80.7 130.36,80.7 132.47,78.58 132.47,77.87 132.48,77.86 132.48,77.86 132.59,77.75 132.59,77.72 133.45,76.86 v1(133.45,76.47)
  BOTTOM w0.089: CPU1.CE29 116.96,88.62 v1(117.1,88.62)
  BOTTOM w0.102: R1502.2 144.87,78.42 v2(144,78.42) 144,78.11 144.61,77.5 144.61,77.19 144.53,76.89 143.93,76.29 143.29,76.29 143.27,76.28 142.27,76.28 142.07,76.47 138.59,76.47 138.39,76.27 133.65,76.27 v1(133.45,76.47)
NUVOTON_PP: length 1.6
  BOTTOM w0.102: TP9104.1 151.24,145.26 150.47,144.48 U9103.4
NXP3290_FO: length 17.8
  TOP w0.102: U7403.C4 42.01,122.43 42.01,121.81 41.23,121.03 40.95,121.03 40.77,120.85 40.3,120.85 R7402.1 39.97,120.43 39.65,120.12 39.64,120.12 39.54,120.02 39.54,119.36 39.64,119.26 39.68,119.26 40.04,118.89 v1(40.04,117.95) ; v1(41.29,107.78) 41.33,107.83 U7201.23
  L4 w0.102: v1(41.29,107.78) 41.29,107.83 41.41,107.95 41.41,114.02 41.42,114.04 41.42,116.15 40.04,117.53 v1(40.04,117.95)
NXP3290_ILIM: length 2.6
  TOP w0.102: U7403.A3 43.18,123.05 43.51,122.71 43.51,121.84 42.83,121.16 R7418.1
NXP3290CAP: length 3.6
  TOP w0.254: C7405.1 39.37,121.01 39.61,121.01 39.61,121.01 39.91,121.01 40.16,121.26 40.57,121.26 v2(40.59,121.29) 40.72,121.41 41.07,121.41 41.63,121.97 U7403.D4
ODD_SATA_RX_CON_N: length 8.3
  TOP w0.127: 187.36,39.27 186.01,40.62 185.83,40.62 v1(185.67,40.46) ; 187.36,39.27 187.61,39.02 188.42,39.02 C6010.2 ; 187.36,39.27 AFTP6003.1
  BOTTOM w0.127: v1(185.67,40.46) 185.47,40.25 185.47,39.96 185.63,39.8 ODD1.4
ODD_SATA_RX_CON_P: length 7.3
  TOP w0.127: 186.22,40.75 186.07,40.91 185.42,40.91 185.04,40.52 v1(185.04,40.41) ; 186.22,40.75 AFTP6004.1 ; 186.22,40.75 187.71,39.26 188.36,39.26 C6011.2
  BOTTOM w0.127: ODD1.5 185.79,39.3 185.23,39.86 185.23,40.22 v1(185.04,40.41)
ODD_SATA_RX_N12: length 179.8
  TOP w0.127: v1(191.74,37.97) 191.74,38.34 191.29,38.79 190.48,38.79 ; 190.48,38.79 v2(190.48,38.65) ; 190.48,38.79 C6010.1 ; R1616.1 126.46,120.3 126.71,120.04 126.71,119.63 126.32,119.24 125.34,119.24 v1(125.02,119.56)
  L4 w0.114: v1(191.74,37.97) 191.94,37.77 191.94,37.77 192.19,37.51 192.25,37.51 192.72,37.04 193.42,37.04 195.09,38.71 206.94,38.71 207.13,38.71 208.17,39.76 209.32,39.76 209.95,40.4 209.95,40.86 209.95,41.01 211.99,43.05 212.48,43.05 213.23,43.8 213.23,45.89 217.35,50.02 217.35,61.67 216.69,62.32 211.14,62.32 210.51,61.7 205.88,61.7 204.2,60.02 189.75,60.02 187.94,58.21 180.51,58.21 176.51,62.22 175.5,62.22 157.64,80.09 157.64,86.02 143.67,99.99 143.67,104.67 139.7,108.64 139.7,113.17 136.82,116.06 130.37,116.06 129.26,117.16 129.26,118.03 128.06,119.23 125.35,119.23 v1(125.02,119.56)
ODD_SATA_RX_P12: length 180.4
  TOP w0.127: 191.77,38.65 192.37,38.05 192.37,37.95 v1(192.38,37.95) ; 191.77,38.65 v2(191.87,38.76) ; 191.77,38.65 191.39,39.03 190.1,39.03 189.97,39.16 189.97,39.41 189.84,39.55 C6011.1 ; R1609.1 126.09,121.11 126.95,120.2 126.95,119.53 126.42,119 125.07,119 v1(124.97,118.9)
  L4 w0.114: v1(124.97,118.9) 125.07,119 127.97,119 129.04,117.93 129.04,117.07 130.27,115.83 136.73,115.83 139.47,113.08 139.47,108.54 143.44,104.58 143.44,99.9 157.41,85.93 157.41,79.99 175.41,61.99 176.41,61.99 180.42,57.99 188.03,57.99 189.84,59.79 204.3,59.79 205.97,61.47 210.61,61.47 211.23,62.09 216.6,62.09 217.12,61.57 217.12,50.11 213,45.99 213,43.89 212.38,43.28 211.9,43.28 209.72,41.11 209.72,40.94 209.72,40.49 209.22,39.99 208.08,39.99 207.03,38.94 195,38.94 193.32,37.26 192.82,37.26 192.38,37.71 v1(192.38,37.95)
ODD_SATA_TX_CON_N: length 9.2
  TOP w0.127: v1(190.35,40.79) 190.1,41.04 189,41.04 ; C6013.2 192.15,42.39 192.15,42.55 191.95,42.75 188.77,42.75 188.33,42.31 188.33,41.44 188.73,41.04 189,41.04 ; 189,41.04 AFTP6002.1
  BOTTOM w0.127: ODD1.2 190.34,40.8 v1(190.35,40.79)
ODD_SATA_TX_CON_P: length 10.5
  TOP w0.127: C6014.2 191.91,42.25 191.91,42.45 191.85,42.51 190.35,42.51 ; v1(190.2,41.68) 190.2,41.46 190.02,41.28 188.83,41.28 188.58,41.54 188.58,42.21 188.87,42.51 190.35,42.51 ; 190.35,42.51 AFTP6001.1
  BOTTOM w0.127: v1(190.2,41.68) 190.2,41.43 190.07,41.3 ODD1.1
ODD_SATA_TX_N12: length 179.9
  TOP w0.127: 192.99,38.78 193.42,38.35 194.58,38.35 194.88,38.05 194.92,38.05 195.19,37.78 195.19,37.14 v1(195.18,37.14) ; 192.99,38.78 v2(193.09,38.89) ; 192.99,38.78 191.86,39.91 191.86,40.09 192.31,40.53 192.31,40.98 C6013.1 ; R1610.1 126.26,122.38 128.52,122.38 128.53,122.38 128.82,122.38 v1(128.88,122.31)
  L4 w0.114: v1(195.18,37.14) 196.14,37.14 197.11,38.1 207.38,38.1 208.43,39.15 209.57,39.15 210.56,40.14 210.56,40.6 210.56,40.76 212.14,42.34 213.93,42.34 214.39,42.8 214.39,46.2 217.96,49.77 217.96,61.92 216.84,63.04 209.54,63.04 208.83,62.33 205.65,62.33 203.95,60.63 189.49,60.63 187.69,58.82 180.77,58.82 176.71,62.89 175.69,62.89 158.25,80.34 158.25,86.28 144.28,100.25 144.28,104.93 140.31,108.89 140.31,113.46 137.55,116.23 137.55,118.69 134.34,121.9 129.3,121.9 v1(128.88,122.31)
ODD_SATA_TX_P12: length 179.4
  TOP w0.127: 194.06,38.11 193.32,38.11 191.62,39.81 191.62,40.19 192.07,40.63 192.07,40.8 C6014.1 ; 194.06,38.11 v2(194.06,37.92) ; 194.06,38.11 194.48,38.11 194.74,37.85 v1(194.74,37.6) ; R1611.1 126.34,122.14 128.18,122.14 128.4,121.92 v1(128.4,121.67)
  L4 w0.114: v1(194.74,37.6) 195.4,37.6 195.63,37.36 196.05,37.36 197.01,38.33 207.28,38.33 208.33,39.38 209.47,39.38 210.33,40.24 210.33,40.7 210.33,40.85 212.04,42.57 213.83,42.57 214.16,42.89 214.16,46.29 217.73,49.86 217.73,61.82 216.74,62.81 209.63,62.81 208.92,62.1 205.75,62.1 204.05,60.4 189.59,60.4 187.78,58.6 180.68,58.6 176.61,62.66 175.6,62.66 158.02,80.24 158.02,86.18 144.05,100.15 144.05,104.83 140.08,108.79 140.08,113.37 137.32,116.13 137.32,118.59 134.24,121.67 v1(128.4,121.67)
OUT1_CA_DET: length 4.8
  TOP w0.102: U5802.43 v1(49.7,120.99)
  BOTTOM w0.102: v1(49.7,120.99) 51.08,120.99 51.38,120.69 52.22,120.69 v2(52.4,120.88) 52.68,120.6 R5818.1
OUT2_CA_DET: length 3
  TOP w0.102: U5802.33 53.7,120.64 53.37,120.97 v1(52.96,120.97)
  BOTTOM w0.102: v1(52.96,120.97) 53.2,121.21 v2(53.61,121.21) 53.61,120.43 R5819.1
PANEL_BKEN: length 229.2
  TOP w0.089: RN5503.3 222.58,36.39 222.44,36.25 RN5502.2 221.55,36.25 221.34,36.04 221.34,35.38 221.16,35.21 v2(219.76,35.21) 219.66,35.1 218.14,35.1 217.93,35.31 216.61,35.31 v1(216.39,35.08)
  L3 w0.089: v1(21.29,40.13) 21.47,39.95 21.47,38.31 20.94,37.79 20.94,31.98 20.51,31.55 20.51,30.93 22.94,28.51 24.87,28.51 25.63,27.74 27.06,27.74 27.44,27.36 33.79,27.36 35.2,28.77 41.4,28.77 41.42,28.77 41.79,28.77 42.61,29.59 45.36,29.59 46.13,28.81 55.34,28.81 55.69,29.17 73.78,29.17 78.34,33.73 91.38,33.73 92.13,34.48 93.59,34.48 93.92,34.8 100.86,34.8 102.44,36.38 103.36,36.38 103.98,37 104.71,37 105.79,38.08 106.6,38.08 106.86,38.34 108.4,38.34 110.52,40.46 119.65,40.46 120.68,39.43 123.9,39.43 126.31,37.02 127.17,37.02 128.91,35.28 129.97,35.28 132.33,32.92 137.24,32.92 137.64,33.32 146.02,33.32 146.17,33.32 147.46,32.03 169.11,32.03 170.72,33.64 175.31,33.64 176.52,32.42 189.71,32.42 190.21,31.92 197.17,31.92 197.43,32.18 208.59,32.18 209.22,31.56 211.98,31.56 215.16,34.73 215.16,35.06 215.41,35.31 216.16,35.31 v1(216.39,35.08)
  BOTTOM w0.089: D2401.3 20.56,40.33 20.76,40.13 v1(21.29,40.13)
PANEL_BKEN_EC: length 45.3
  TOP w0.102: U2401.117 29.56,73.21 29.19,72.84 29.19,71.71 28.59,71.11 27.53,71.11 27.36,71.27 25.67,71.27 24.85,72.1 v1(24.85,72.19)
  L3 w0.102: v1(20.41,42.54) 20.4,42.55 20.4,42.99 18.66,44.74 18.66,44.91 18.66,44.91 18.66,44.97 18.66,45.95 18.66,45.95 18.66,49.71 19.15,50.2 19.15,50.21 19.43,50.49 19.43,51.6 19.26,51.78 19.26,56.46 19.26,56.6 19.26,57.97 19.68,58.39 19.68,59.36 19.57,59.47 19.57,60.33 18.87,61.03 18.87,62.18 18.31,62.75 18.31,64.01 19.15,64.86 19.74,64.86 20.95,66.06 20.95,66.58 20.68,66.84 20.68,67.44 21.13,67.89 21.19,67.89 21.44,68.14 21.44,68.2 24.85,71.6 v1(24.85,72.19)
  BOTTOM w0.102: D2401.1 21.06,41.37 v2(20.52,41.91) 20.52,42.43 v1(20.41,42.54)
PANEL_MONITOR: length 444.2
  TOP w0.089: R5545.1 148.05,130.37 v2(148.39,130.04) 149.38,130.04 150.72,131.38 151.26,131.38 151.6,131.73 151.6,131.83 152.66,132.88 v1(152.66,134.9) ; v1(36.6,74.96) 37.11,74.96 37.55,74.51 U2401.97
  L3 w0.089: v1(152.66,134.9) 153.55,134.01 153.55,122.38 158.22,117.71 158.22,117.07 159,116.29 159,113.42 158.93,113.35 158.93,113.03 156.08,110.18 156.08,108.04 153.99,105.94 153.99,105.45 153.65,105.1 153.65,99 153.12,98.47 153.12,96.59 155.55,94.15 156.01,94.15 156.71,93.45 156.71,93.09 156.65,93.03 156.65,92.47 158.98,90.14 159.74,90.14 162.37,87.52 162.37,87.16 162.14,86.94 162.14,85.34 162.59,84.89 162.59,83.64 163.41,82.82 163.41,81.15 171.74,72.83 171.74,71.68 173.88,69.54 174.56,69.54 175.55,68.55 175.61,68.55 175.73,68.43 177.63,68.43 178.47,67.59 182.05,67.59 183.08,68.61 187,68.61 189.22,66.4 208.82,66.4 209.73,67.31 217.35,67.31 220.07,64.59 220.07,64.54 221.87,62.75 221.87,50.25 220,48.39 219.7,48.39 218.99,47.68 218.99,43.49 216.69,41.19 215.32,41.19 212.9,38.77 207.8,38.77 207.39,38.35 200.92,38.35 200.8,38.23 196.4,38.23 196.21,38.42 192.94,38.42 192.71,38.65 189.94,38.65 189.08,37.79 189.08,37.69 185.9,34.51 183.65,34.51 181.68,36.49 171.06,36.49 170.24,37.31 168.55,37.31 167.44,36.2 166.07,36.2 164.74,37.53 161.97,37.53 157.04,32.6 149.04,32.6 145.82,35.82 128.92,35.82 127.21,37.53 126.38,37.53 124.12,39.78 120.88,39.78 120.02,40.64 120.02,41.31 119.6,41.74 110.34,41.74 109.32,40.71 109.32,40 108.01,38.69 106.71,38.69 106.45,38.43 105.64,38.43 104.57,37.36 103.83,37.36 103.21,36.74 102.3,36.74 100.72,35.16 100.39,35.16 100.38,35.16 93.76,35.16 93.43,34.83 91.99,34.83 91.24,34.08 78.13,34.08 73.95,29.9 55.51,29.9 54.77,29.17 46.59,29.17 45.81,29.94 42.46,29.94 41.64,29.12 41.46,29.12 41.34,29.13 34.97,29.13 34.44,28.6 28.53,28.6 28.28,28.35 28.28,27.97 28.03,27.72 27.59,27.72 27.13,28.18 25.73,28.18 25.04,28.86 24.59,28.86 24.04,28.86 21.6,31.3 21.6,31.35 21.3,31.65 21.3,37.64 21.99,38.33 21.99,40.6 20.53,42.06 20.28,42.06 19.98,42.37 19.98,43.13 18.46,44.65 18.46,44.82 18.46,44.83 18.46,45.7 18.46,46.03 18.46,49.8 19.23,50.57 19.23,51.52 19.06,51.69 19.06,56.54 19.06,56.68 19.06,56.69 19.06,58.05 19.48,58.47 19.48,59.28 19.12,59.64 19,59.64 18.68,59.96 18.68,62.1 18.11,62.67 18.11,64.1 19.07,65.05 19.66,65.05 20.75,66.14 20.75,66.5 20.02,67.22 20.02,68.23 20.68,68.89 20.68,69.32 22.43,71.07 22.43,71.63 22.3,71.76 22.3,72.11 22.55,72.36 23.82,72.36 25.59,74.14 35.79,74.14 v1(36.6,74.96)
PANEL_PWRGD_R: length 10.3
  TOP w0.102: 146.36,128.95 146.68,128.62 148,128.62 148.7,129.32 149.77,129.32 Q5504.3 ; 146.36,128.95 146.58,129.17 146.58,129.88 v2(146.7,130.01) 147.19,130.49 R5545.2 147.92,131.74 147.92,132.58 R5549.2 C5529.1 147.49,133.82 R5547.1 ; 146.36,128.95 Q5505.3
PBAT_CHG_SMBCLK: length 271.3
  TOP w0.114: RN4302.2 136.36,36.95 135.94,36.53 ; 135.94,36.53 EC4309.1 ; 135.94,36.53 v1(135.94,36.45)
  TOP w0.14: U2401.9 22.78,69.29 22.61,69.46 v1(21.98,69.46) 21.88,69.56 RN2402.3 ; v2(30.45,31.19) 30.21,30.94 v1(29.88,30.94)
  L2SGND w0.127: v1(21.98,69.46) 21.99,69.44 21.99,69.42 22.16,69.26 22.16,67.4 22.04,67.29 22.04,66.92 20.78,65.66 20.65,65.66 20.61,65.62 20.03,65.62 20,65.66 19.78,65.66 18.5,64.38 18.5,62.83 18.76,62.57 19.13,62.57 19.23,62.66 19.8,62.66 20.21,62.25 20.21,61.65 20.1,61.54 20.1,58.75 18.34,56.99 18.34,52.49 19.22,51.61 19.22,50.51 18.87,50.17 18.87,46.05 18.88,46.04 18.88,45.95 18.9,45.94 18.9,45.9 21.57,43.22 21.57,41.43 22.53,40.47 22.53,38.61 22.86,38.28 24.76,38.28 25.15,37.9 25.73,37.9 26.67,36.96 26.67,35.31 26.19,34.82 26.19,33.35 27.82,31.73 29.09,31.73 v1(29.88,30.94)
  L3 w0.127: v1(207,48.72) 207.16,48.57 207.16,46.58 206.75,46.17 206.39,46.17 205.95,45.73 205.95,44.6 205.35,43.99 200.23,43.99 199.37,43.13 198.32,43.13 197.67,42.49 196.44,42.49 195.91,41.96 195.7,41.96 192.48,41.96 190.88,40.35 189.1,40.35 188.47,39.71 183.83,39.71 182.53,38.41 172.82,38.41 171.53,39.7 169.06,39.7 168.39,39.04 154.47,39.04 154.16,38.72 127.26,38.72 125.58,40.4 v1(125.58,40.85) 125.58,41.27 125.3,41.55 123.06,41.55 120.86,43.76 109.14,43.76 107.85,42.47 106.58,42.47 105.96,41.85 102.76,41.85 102.4,41.49 101.24,41.49 100.98,41.24 100.98,39.64 100.35,39 98.33,39 97.73,38.4 92.32,38.4 92.1,38.19 91.17,38.19 90.35,39.01 85.28,39.01 85.04,38.77 75.58,38.77 71.37,34.57 64.79,34.57 64.19,33.97 62.75,33.97 62.48,33.7 62.48,32.63 61.71,31.87 32.82,31.87 32.35,31.4 30.34,31.4 v1(29.88,30.94)
  BOTTOM w0.114: v1(207,48.72) 206.54,48.25 206.15,48.25 205.96,48.44 PU4401.22
  BOTTOM w0.14: v1(135.94,36.45) 135.61,36.12 130.31,36.12 130.1,35.91 128.66,35.91 127.89,36.68 127.23,36.68 125.71,38.2 125.71,39.09 125.58,39.22 v1(125.58,40.85) 125.58,41.19 125.29,41.48 123.83,41.48 ED4306.3
PBAT_CHG_SMBDAT: length 271.4
  TOP w0.114: v1(137.11,35.23) 136.73,35.23 135.95,36.01 135.7,36.01 EC4310.1
  TOP w0.14: v2(28.92,31.41) 28.92,31.24 v1(29.24,30.91) ; U2401.8 23.12,69.69 22.74,70.08 22.74,70.18 22.72,70.2 22.72,70.42 v1(22.69,70.45) 22.45,70.21 RN2402.4 ; v1(137.11,35.23) 137.72,35.84 137.72,36.3 137.87,36.45 RN4302.3
  L2SGND w0.127: v1(22.69,70.45) 22.38,70.15 21.99,70.15 21.49,69.65 21.49,68.05 20.95,67.51 20.95,66.32 20.51,65.88 20.14,65.88 20.1,65.91 19.68,65.91 18.25,64.48 18.25,62.72 18.66,62.31 19.24,62.31 19.33,62.41 19.69,62.41 19.95,62.15 19.95,61.76 19.85,61.65 19.85,58.86 18.09,57.1 18.09,52.38 18.96,51.5 18.96,50.62 18.62,50.27 18.62,45.94 18.63,45.93 18.63,45.84 18.64,45.83 18.64,45.79 21.31,43.12 21.31,41.33 22.28,40.36 22.28,38.5 22.76,38.03 24.66,38.03 25.04,37.64 25.63,37.64 26.42,36.85 26.42,35.41 25.94,34.93 25.94,33.25 27.79,31.4 28.76,31.4 v1(29.24,30.91)
  L3 w0.127: v1(29.24,30.91) 29.24,31.35 29.54,31.66 32.25,31.66 32.71,32.12 61.54,32.12 62.2,32.79 62.2,33.95 63.21,34.96 71.35,34.96 71.37,34.98 71.42,34.98 75.47,39.03 84.93,39.03 85.19,39.28 92.08,39.28 92.68,38.68 97.62,38.68 98.25,39.31 100.24,39.31 100.7,39.76 100.7,41.39 101.06,41.75 102.29,41.75 102.65,42.1 105.86,42.1 106.48,42.72 107.74,42.72 109.03,44.01 121.04,44.01 123.25,41.81 125.78,41.81 126.24,41.35 v1(126.24,40.81) 126.24,40.36 127.62,38.98 154.05,38.98 154.36,39.29 168.29,39.29 168.95,39.96 171.64,39.96 172.93,38.67 182.39,38.67 183.69,39.97 188.36,39.97 189.63,41.24 191.41,41.24 192.38,42.21 195.81,42.21 196.34,42.74 197.57,42.74 198.21,43.38 199.24,43.38 200.1,44.25 205.24,44.25 205.67,44.67 205.67,45.8 206.28,46.42 206.64,46.42 206.91,46.68 206.91,48.12 v1(206.33,48.69)
  BOTTOM w0.114: v1(206.33,48.69) 206.33,48.7 206.33,48.71 206.2,48.84 PU4401.21
  BOTTOM w0.14: v1(137.11,35.23) 136.77,35.57 136.77,36.27 136.64,36.4 136.63,36.4 136.13,36.9 135.76,36.9 135.26,36.4 129.8,36.4 ED4305.3 129.7,37.08 128.71,38.08 127.32,38.08 126.95,38.44 126.95,40.09 v1(126.24,40.81)
PBAT_PRES1#: length 6.3
  TOP w0.089: RN4302.5 139.58,35.86 v1(140.21,35.23) 139.83,34.85 AFTP4309.1
  BOTTOM w0.089: BATT1.6 139.07,37.76 140.21,36.63 v1(140.21,35.23)
PBAT_PRES#: length 263.2
  TOP w0.089: EC4306.2 135.64,35.61 v1(136.02,35.23) 136.15,35.23 136.6,34.77 137.44,34.77 138.3,35.63 RN4302.4 ; PR4409.2 205.21,45.61 v1(205.05,45.77) ; U2401.29 23.02,61.29 22.74,61.58 22.74,61.71 R2415.1 21.65,62.79 20.96,62.79 20.13,61.96 v1(19.51,61.96) ; v1(27.23,30.89) v2(27.23,31.47)
  L2SGND w0.089: v1(27.23,30.89) 27.23,31.62 25.7,33.15 25.7,35.03 26.18,35.51 26.18,36.76 25.53,37.41 24.94,37.41 24.56,37.79 22.66,37.79 22.04,38.41 22.04,40.27 21.07,41.24 21.07,42.95 18.41,45.6 18.41,45.73 18.4,45.75 18.4,45.83 18.38,45.85 18.38,50.37 18.63,50.62 18.63,51.49 17.85,52.28 17.85,57.19 19.61,58.95 19.61,61.86 v1(19.51,61.96)
  L3 w0.089: v1(205.05,45.77) 205.05,45.29 204.43,44.67 199.91,44.67 199.21,43.96 196.88,43.96 195.55,42.63 191.86,42.63 191.73,42.76 189.61,42.76 188.3,41.44 188.14,41.28 184.11,41.28 182.13,39.3 173.19,39.3 171.9,40.58 168.69,40.58 168.06,39.96 166.46,39.96 165.83,40.58 165.83,40.85 165.57,41.12 155.32,41.12 153.6,39.39 129.25,39.39 v1(127.78,40.86) 127.78,41.31 126.62,42.48 123.56,42.48 121.39,44.64 108.77,44.64 107.48,43.35 106.22,43.35 105.6,42.73 102.39,42.73 102.03,42.37 99.93,42.37 97.47,39.91 84.93,39.91 84.67,39.66 75.21,39.66 71.16,35.61 71.11,35.61 71.09,35.59 62.56,35.59 61.17,34.2 58.24,34.2 56.79,32.75 32.45,32.75 31.98,32.28 28.63,32.28 v1(27.23,30.89)
  BOTTOM w0.089: v1(127.78,40.86) 127.78,41.31 127.26,41.84 123.23,41.84 122.49,41.09 122.49,39.42 123.84,38.07 124.76,38.07 ED4304.3 127.03,36.42 127.79,36.42 128.6,35.61 130.27,35.61 130.53,35.87 135.39,35.87 v1(136.02,35.23)
PBAT_SMBCLK1: length 9.2
  TOP w0.114: v1(141.58,35.23) 142.57,36.23 AFTP4311.1 141.98,37.29 140.24,37.29 139.89,36.95 RN4302.7
  BOTTOM w0.114: BATT1.4 v1(141.58,35.23)
PBAT_SMBDAT1: length 7.5
  TOP w0.114: RN4302.6 140.16,36.45 AFTP4310.1 141.16,36.41 141.16,35.54 v1(140.85,35.23)
  BOTTOM w0.114: v1(140.85,35.23) 140.85,36.98 140.33,37.5 BATT1.5
PC10: length 3.5
  TOP w0.102: U5802.56 45.7,117.63 v2(45.11,117.04) 45.11,116.92 R5808.2 44.2,116.41 R5807.2
PC11: length 2.3
  TOP w0.102: U5802.55 45.64,118.03 45.39,117.78 R5811.2
PC20: length 3.3
  TOP w0.102: U5802.54 45.59,118.43 45.4,118.25 v2(45.32,118.25) 45.31,118.24 45.14,118.24 45.14,118.24 44.53,118.24 R5810.2 44.2,119.15 R5809.2
PC21: length 3.8
  TOP w0.102: R5814.2 44.28,120.33 R5813.2 44.85,119.76 44.85,119.17 44.89,119.13 45.06,119.13 45.36,118.83 U5802.53
PCH_BATLOW#: length 34.5
  L3 w0.102: v1(113.16,82.91) 114.36,82.91 115.42,81.85 119.83,81.85 120.11,82.13 121.5,82.13 121.91,81.72 123.45,81.72 123.68,81.95 v1(123.7,81.95)
  BOTTOM w0.076: CPU1.BV36 112.84,84.19 113.01,84.02 113.01,83.06 v1(113.16,82.91)
  BOTTOM w0.102: v1(123.7,81.95) 123.98,81.95 124.45,81.49 124.45,81.25 126.55,79.15 126.88,79.15 127.21,78.82 131.07,78.82 134.08,81.82 134.08,83.2 134.47,83.59 134.73,83.59 134.86,83.72 v2(136.54,83.72) 137.12,84.3 139.49,84.3 139.68,84.5 139.68,84.86 139.81,84.99 RN1704.8
PCH_ESPI_CLK: length 6.6
  BOTTOM w0.076: 114.13,82.75 114.13,82.77 113.69,83.21 113.69,83.73 113.77,83.82 113.77,86.22 CPU1.BV32
  BOTTOM w0.14: 114.13,82.75 114.71,82.17 v2(114.71,82.12) 114.78,82.05 R1805.1
PCH_ESPI_IO0: length 22.3
  TOP w0.14: v2(129.01,77.34) v1(128.43,78.37) 128.4,78.34 128.4,77.57 128.07,77.24 RN1806.1
  L4 w0.089: v1(115.29,88.67) 115.65,88.31 115.65,88.16 115.65,88.15 115.65,87.84 115.62,87.81 115.62,86.03
  L4 w0.127: v1(128.43,78.37) 128.43,78.86 124.49,83.73 123.88,84.33 123.24,84.61 116.42,85.24 115.62,86.03
  BOTTOM w0.089: CPU1.CA29 v1(115.29,88.67)
PCH_ESPI_IO1: length 23
  TOP w0.14: v1(114.39,88.67) 114.16,88.67 v2(113.89,88.94) ; RN1806.2 127.46,77.39 127.54,77.47 127.54,77.49 127.58,77.53 127.59,77.53 127.62,77.56 127.75,77.56 128.02,77.82 128.02,78.19 127.75,78.46 127.12,78.46 v1(127.07,78.4)
  L4 w0.089: 114.79,86.08 114.79,87.06 113.98,87.87 113.98,88.27 114.32,88.61 114.33,88.61 114.39,88.67 v1(114.39,88.67)
  L4 w0.127: v1(127.07,78.4) 127.07,79.61 124.52,82.79 124.41,82.92 123.83,83.61 123.73,83.73 123.7,83.76 123.59,83.9 122.98,84.19 116.11,84.76 114.79,86.08
  BOTTOM w0.14: CPU1.BY29 114.12,88.93 114.38,88.67 v1(114.39,88.67)
PCH_ESPI_IO2: length 22.6
  TOP w0.14: RN1806.3 126.98,77.68 127.26,77.95 127.46,77.95 127.51,78.01 v1(127.57,78.01)
  L4 w0.127: v1(127.57,78.01) 127.57,79.41 124.12,83.7 123.88,83.96 123.71,84.13 123.12,84.4 116.35,85 115.17,86.18 115.17,87.12 114.81,87.48 114.81,89.51 v1(114.38,89.94)
  BOTTOM w0.089: CPU1.BY27 v1(114.38,89.94)
PCH_ESPI_IO3: length 22.3
  TOP w0.14: RN1806.4 v1(126.51,78.71)
  L4 w0.089: 114.21,86.2 113.98,86.43 113.86,87.54 113.78,87.82 113.78,88.42 113.87,88.5 113.87,89.54 v1(113.47,89.94)
  L4 w0.127: v1(126.51,78.71) 126.29,80.04 123.8,83.3 123.57,83.58 123.47,83.68 122.78,83.96 115.87,84.54 114.21,86.2
  BOTTOM w0.089: CPU1.BV27 v1(113.47,89.94)
PCH_JTAG_TCK: length 27.9
  TOP w0.14: R318.1 71.33,100.28 v2(70.85,99.8) 70.28,99.8 v1(69.7,100.38)
  L4 w0.127: v1(88.7,102.85) 88.22,103.33 88.22,104.94 85.65,107.51 77.52,107.51 71.9,101.89 71.34,101.89 69.84,100.38 v1(69.7,100.38)
  BOTTOM w0.114: CPU1.W6 88.61,102.9 88.65,102.9 v1(88.7,102.85)
PCH_JTAG_TDI: length 25.5
  TOP w0.14: v1(87.78,104.14) 87.79,104.14 v2(87.79,104.78)
  L4 w0.127: v1(87.78,104.14) 87.78,104.63 86.02,106.39 79.97,106.39 79.18,105.6 75.95,105.6 70.31,99.96 69.18,99.96 v1(69.12,100.03)
  BOTTOM w0.114: CPU1.U5 v1(87.78,104.14)
  BOTTOM w0.14: v1(69.12,100.03) 69.27,99.87 69.88,99.87 70.36,100.36 R312.1
PCH_JTAG_TDO: length 28.9
  L4 w0.127: v1(88.69,103.52) 89.12,103.95 89.12,104.34 85.74,107.72 77.43,107.72 72.64,102.93 71.29,102.93 70.99,102.63 70.99,101.94 69.91,100.86 69.35,100.86 69.22,100.73 v1(69.1,100.73)
  BOTTOM w0.114: CPU1.W5 88.63,103.53 88.67,103.53 v1(88.69,103.52)
  BOTTOM w0.14: R313.1 68.28,100.03 68.57,100.32 68.57,101.03 v2(68.81,101.27) 69.1,100.99 v1(69.1,100.73)
PCH_JTAG_TMS: length 26
  L4 w0.127: v1(67.82,96.7) 68.09,96.43 69,96.43 69.73,97.16 69.73,98.23 70.38,98.88 71.23,98.88 77.03,104.68 78.26,104.68 78.26,104.68 78.62,104.68 80.01,104.68 80.13,104.8 82.78,104.8 82.87,104.89 84.83,104.89 85.58,104.14 v1(85.93,104.14)
  BOTTOM w0.114: CPU1.P5 v1(85.93,104.14)
  BOTTOM w0.14: v1(67.82,96.7) 67.73,96.61 66.79,96.61 R314.1 66.04,97.36 v2(65.31,97.36)
PCH_PLTRST#: length 7.3
  BOTTOM w0.102: R1713.2 108.27,78.91 108.27,83.33 107.5,84.1 107.5,84.96 107.18,85.29 CPU1.BJ35
PCH_POPIRCOMP: length 2.4
  TOP w0.305: v1(113.62,91.59) 113.67,91.54 R305.1 113.7,90.79 v2(114.56,91.01)
  BOTTOM w0.254: CPU1.BW25 113.62,91.48 v1(113.62,91.59)
PCH_RSMRST#: length 12.8
  TOP w0.102: EC1712.1 20.09,64.65 v2(20.09,64.01) 20.09,63.55 R1702.2 22.06,63.09 22.28,62.87 22.28,62.67 22.86,62.09 U2401.27 24.6,62.09 24.75,61.95 v1(25.24,61.95)
  BOTTOM w0.102: R6414.2 24.87,60.07 24.21,60.73 23.51,60.73 23.41,60.84 23.41,61.11 23.4,61.11 23.4,61.54 23.91,62.04 25.14,62.04 v1(25.24,61.95)
PCH_SMBCLK: length 232
  TOP w0.14: U7001.1 141.13,79.22 140.92,79.43 140.92,80.53 v1(140.38,81.07) ; RN1810.3 173.54,48.99 172.91,48.37 v1(172.87,48.37) ; AFTP1202.1 197.69,57.63 v1(197.69,57.74)
  L3 w0.127: v1(133.56,100.03) 135.76,97.82 135.99,97.82 137.82,95.99 138.33,95.99 144.74,89.57 144.74,89.52 v1(144.74,89.51) 144.74,89.04 145.11,88.67 145.32,88.67 151.94,82.05 151.94,79.99 160.07,71.86 160.07,71.27 163.85,67.5 163.85,67.49 163.92,67.42 163.92,67.29 163.91,67.28 163.91,66.52 174.52,55.92 v1(174.81,55.92) 175.14,55.59 176.03,55.59 176.36,55.92 176.36,55.92 176.59,56.15 176.59,56.15 176.65,56.21 176.66,56.21 180.04,56.21 180.55,55.7 190.87,55.7 192.21,57.04 196.99,57.04 v1(197.69,57.74)
  L4 w0.127: v1(101.99,40.95) 102.41,40.95 102.68,41.22 108.32,41.22 110.14,43.04 121.09,43.04 122.93,41.19 122.93,41.06 125.14,38.85 148.35,38.85 151.88,35.32 161.6,35.32 162.1,35.82 168.1,35.82 168.46,35.46 169.98,35.46 172.66,38.14 172.82,38.58 172.83,38.61 172.85,38.69 172.88,38.77 172.89,38.78 173.71,41.08 173.71,42.09 172.15,43.65 172.15,47.65 v1(172.87,48.37)
  BOTTOM w0.14: VGABD1.16 196.95,58.25 197.21,57.99 197.44,57.99 v1(197.69,57.74) ; v1(101.99,40.95) 101.99,41.18 97.8,45.37 97.8,45.95 96.54,47.22 95.9,47.22 95.33,47.8 DM1.253 ; v1(140.38,81.07) 140.41,81.05 141.69,81.05 141.95,81.32 141.95,81.76 142.85,82.66 142.85,84.29 143.23,84.67 143.23,85.18 143.91,85.86 143.91,86.22 144.41,86.72 144.85,86.72 145.55,87.42 145.55,87.58 144.41,88.72 144.41,89.19 144.74,89.51 v1(144.74,89.51) ; Q1801.4 138.94,105.96 138.54,105.56 138.54,103.87 137.03,102.35 135.74,102.35 135.3,101.92 135.3,101.79 135.11,101.6 v2(135.11,100.74) 135.11,99.57 133.69,98.15 133.32,98.15 133.05,98.42 133.05,98.93 133.56,99.43 v1(133.56,100.03) ; DM2.253 171.53,48.49 171.65,48.37 v1(172.87,48.37) 173.32,48.37 174.2,49.24 174.2,55.3 v1(174.81,55.92)
PCH_SMBDATA: length 233.2
  TOP w0.14: v1(196.83,57.73) 196.83,57.63 AFTP1201.1 ; RN1810.4 173.62,48.02 173.62,47.8 173.49,47.67 172.93,47.67 172.89,47.71 v1(172.87,47.71) ; v1(139.86,80.7) 139.78,80.62 139.78,80.06 138.97,79.25 138.97,78.77 138.85,78.64 138.85,76.8 139.09,76.56 141,76.56 141.56,77.12 U7001.4
  L3 w0.127: v1(132.55,100.2) 132.86,100.2 133.13,100.47 133.75,100.47 137.95,96.27 138.62,96.27 145.27,89.62 v1(145.27,89.15) 145.27,89.09 152.2,82.16 152.2,80.1 160.33,71.97 160.33,71.37 164.1,67.6 164.1,67.59 164.17,67.52 164.17,67.18 164.16,67.18 164.16,66.63 174.43,56.36 175.21,56.36 v1(175.53,56.03) 175.55,56.02 176.1,56.02 176.25,56.17 176.48,56.4 176.55,56.47 176.56,56.47 178.43,56.47 178.43,56.47 180.14,56.47 180.65,55.96 190.69,55.96 192.03,57.29 196.38,57.29 v1(196.83,57.73)
  L4 w0.127: v1(172.87,47.71) 172.41,47.25 172.41,46.65 172.41,46.65 172.41,43.75 173.97,42.19 173.97,41.03 173.94,40.96 173.09,38.59 173.07,38.53 173.07,38.53 172.88,38 170.08,35.21 168.18,35.21 167.82,35.56 162.25,35.56 161.75,35.06 151.6,35.06 148.06,38.6 125.04,38.6 122.68,40.96 122.68,41.09 120.98,42.78 110.26,42.78 108.44,40.96 102.79,40.96 102.32,40.5 101.54,40.5 v1(101.53,40.51)
  BOTTOM w0.14: v1(196.83,57.73) 196.83,57.89 196.45,58.27 VGABD1.17 ; v1(145.27,89.15) 145.27,89.14 145.26,89.14 145.26,88.49 145.83,87.92 145.83,87.3 144.97,86.44 144.53,86.44 144.19,86.11 144.19,85.75 143.51,85.06 143.51,84.55 143.13,84.18 143.13,82.54 142.23,81.64 142.23,81.2 141.8,80.77 141.08,80.77 140.93,80.62 139.93,80.62 v1(139.86,80.7) ; Q1801.1 137.58,103.82 136.67,102.91 135.5,102.91 v2(134.65,102.06) 134.65,101.93 132.91,100.2 v1(132.55,100.2) ; v1(175.53,56.03) 175.53,55.87 174.48,54.81 174.48,49.04 173.14,47.7 172.9,47.7 172.89,47.71 v1(172.87,47.71) 172.83,47.67 172.46,47.67 171.81,47.03 171.81,43.96 171.78,43.92 DM2.254 ; DM1.254 95.58,43.71 95.68,43.82 95.68,46.18 96.08,46.57 96.7,46.57 97.47,45.8 97.47,45.31 101.37,41.4 101.37,40.67 v1(101.53,40.51)
PCH_TPAN_VDD_EN: length 121.3
  TOP w0.102: R5562.1 209.63,49.2 209.5,49.33 v2(209.5,49.35) 209.5,49.91 v1(209.58,49.99)
  L2SGND w0.102: v1(116.23,87.99) 116.34,87.99 116.67,88.32 116.67,88.8 116.95,89.08 119.23,89.08 120.04,88.27 120.8,88.27 121.17,87.89 121.17,87.64 121.28,87.54 127.35,87.54 127.73,87.92 131.12,87.92 132.14,88.94 132.14,90.06 132.39,90.31 132.78,90.31 133.72,89.37 140.25,89.37 142.87,86.75 143.19,86.75 143.44,86.49 143.44,85.75 143.57,85.62 144.23,85.62 146.17,83.68 146.17,83.37 147.65,81.89 147.65,79.28 150.48,76.45 153.05,76.45 157.95,71.54 157.95,69.79 172.43,55.31 175.73,55.31 176.5,56.08 198.62,56.08 200.08,54.62 204.15,54.62 204.4,54.38 207.78,54.38 209.28,52.88 209.28,52.36 209.5,52.14 209.5,51.82 209.94,51.38 209.94,50.35 v1(209.58,49.99)
  BOTTOM w0.102: v1(116.23,87.99) 115.94,88.28 CPU1.CC30
