# Allegro board 17938-1.1228WZS1107.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
3D3V_S0_C: length 279.8
  TOP w0.102: v1(34.68,39.44) v2(34.68,40.01)
  L3 w0.089: v1(34.68,39.44) 35.04,39.44 35.77,38.71 38.66,38.71 40.11,37.26 40.11,34.55 40.76,33.89 54.54,33.89 56,35.34 56.48,35.34 60.43,35.34 61.28,36.19 61.28,38.09 61.92,38.74 65.05,38.74 65.19,38.59 67.93,38.59 68.2,38.32 71.46,38.32 74.34,41.2 79.52,41.2 80.95,42.64 81.89,42.64 82.11,42.86 91.92,42.86 92.14,42.64 96.51,42.64 98.45,44.58 99.19,44.58 100.41,45.8 100.45,45.8 100.45,45.8 100.81,45.8 100.81,45.8 101.41,45.8 v1(101.63,45.58)
  L4 w0.089: v1(175.54,69.42) 175.68,69.55 175.68,69.96 164.75,80.89 164.75,88.21 160.07,92.89 159.63,92.89 156.58,95.94 156.58,105.15 163.73,112.29 163.73,117.43 161.78,119.37 161.78,126.82 160.45,128.15 160.45,128.28 ; 159,143.4 v1(159.86,144.26)
  L4 w0.102: 160.45,128.28 160.45,128.29 160.45,136.5 159.36,137.58 159.36,137.59 159.11,137.84 158.92,137.84 157.87,138.89 157.87,141.36 158.01,141.49 158.01,142.41 159,143.4
  BOTTOM w0.089: v1(175.54,69.42) 175.71,69.42 175.83,69.54 176.33,69.54 176.67,69.2 176.67,66.2 176.12,65.65 174.39,65.65 173.72,66.32 170.77,66.32 170,65.55 170,63.57 169.93,63.5 169.76,63.32 168.2,61.74 168.16,61.7 168.16,60.09 163.24,55.17 157.36,55.17 156.53,54.34 147.82,54.34 147.38,54.78 145.49,54.78 145.02,55.25 110.89,55.25 110,54.36 109.73,54.36 109.69,54.31 104.13,54.31 101.68,51.86 101.68,45.63 v1(101.63,45.58) ; v1(34.68,39.44) 35.51,38.61 35.51,35.17 36.87,33.81 38.08,33.81 38.87,33.02 38.87,32.01 39.22,31.65 41.89,31.65 42.22,31.32 R9313.2
  BOTTOM w0.102: R9328.2 160.97,142.16 PMBD1.5 160.97,144.41 160.76,144.61 160.21,144.61 v1(159.86,144.26)
3D3V_S5: length 543.4
  TOP w0.127: PR4472.1 207.8,42.72 207.78,42.69 v1(207.78,42.22)
  TOP w0.203: R2442.1 41.2,77.78 41.2,78 41.96,78.76 42.45,78.76 42.73,78.48 42.73,78.03 42.51,77.81 C2416.1 42.98,77.65 v2(43.54,78.21) 43.76,78.21 46.35,75.61 v1(46.35,73.62) ; v1(39.47,72.98) 39.34,73.11 39.34,75.05 R6404.2
  TOP w0.305: R506.1 109.83,37.95 110.95,36.83 110.95,33.73 110.54,33.33 110.54,29.64 110.09,29.19 v1(110.06,29.19) ; 220.63,68.58 221.29,69.24 R9212.1 222.32,69.24 Q9201.S ; 100.13,31.75 100.13,30.91 99.93,30.71 99.93,30.11 98.98,29.16 v1(98.78,29.16) ; 100.13,31.75 100.28,31.9 RN2406.4 ; 100.13,31.75 99.63,32.25 RN2406.3 ; D4302.2 25.83,93.84 v1(25.83,93.99) ; v1(35,122.54) 35,122.36 35.41,121.95 R7126.1 ; R2434.1 18.02,70.55 R3618.2 18.2,70.72 18.78,70.72 v1(18.87,70.8) ; v1(88.06,38.51) 88.06,39.3 R4010.1 ; v1(15.24,130.14) 15.19,130.14 14.08,129.04 14.08,128.7 13.98,128.6 PR4431.1 ; v1(224.62,47.83) 224.62,46.28 225,45.9 225,43.82 224.69,43.51 R2068.1
  TOP w0.381: D7202.A 55.61,127.19 55.8,127.38 55.81,127.38 55.81,128.37 54.82,129.36 53.72,129.36 53.15,129.93 53.15,131.03 52.66,131.52 45.06,131.52 R7216.1 ; v1(38.64,119.2) 38.33,119.51 R7427.1 ; PR4432.2 v1(13.8,123.01)
  TOP w0.406: R7424.1 R7427.1 ; R4378.1 37.62,117.17 37.89,117.44 U4302.2 38.88,117.44 v1(39.27,117.83) ; v1(43.54,133.07) 43.54,132.97 43.69,132.82 43.69,132.79 44.18,132.31 R7216.1
  TOP w0.508: PR5101.1 110.65,27.71 109.99,28.37 109.99,29.08 110.06,29.16 v1(110.06,29.19) ; v3(95.22,32.13) 95.22,32.03 95.85,31.4 C6503.1 95.99,28.84 v1(95.99,28.84) ; R4304.1 25.96,94.11 v1(25.83,93.99) ; FC8920.1 214.42,46.04 212.25,46.04 212.03,46.26 212.03,46.29 211.99,46.33 211.99,49.14 v1(211.59,49.55)
  TOP w1.016: v3(181.45,70.42) 181.77,70.1 181.77,68.81 180.9,67.95 180.9,63.68 183.67,60.91 191.6,60.91 193.25,62.56 194.64,62.56 195.94,63.86 200.21,63.86 201.83,65.48 207.37,65.48 209.38,67.49 v1(219.79,67.49) ; 55.68,104.22 55.7,104.2 55.7,99.39 54.11,97.79 v3(54.11,93.24)
  L2SGND w0.305: v1(31.92,72.52) 31.92,73.01 31.26,73.67 22.98,73.67 v1(21.98,74.67)
  L2SGND w0.508: v1(138.23,92.82) 138.91,92.82 144.1,87.63 144.1,87.07 143.92,86.89 v1(143.87,86.89)
  L2SGND w1.016: v1(180.53,70.63) 181.23,70.63 v3(181.45,70.42) 181.53,70.42 182.98,68.96 187.02,68.96 189.26,66.73 208.77,66.73 209.35,67.31 218.32,67.31
  L3 w0.305: v1(22.76,121.72) 21.22,120.18 19.1,120.18 16.97,122.31 15.38,122.31 14.68,123.01 v1(13.8,123.01) ; v1(21.98,74.67) 21.98,74.33 20.73,73.08 20.73,72.67 v1(18.87,70.8)
  L3 w0.508: v1(25.83,93.99) 25.94,94.09 25.94,94.31 24.77,95.48 24.77,96.25 26.83,98.31 26.83,101.41 25.18,103.05 22.26,103.05 22.26,103.05 19.69,103.05 19.52,103.23 18.98,103.23 18.55,102.8 16.84,102.8 16.48,103.15 16.48,109.7 17.45,110.67 v1(17.45,110.75) ; v1(38.64,119.2) 38.64,119.86 38.94,120.17 39.47,120.17 40.34,121.03 41.79,121.03 42.86,122.11 44.34,122.11 44.91,122.68 44.91,123.76 48.79,127.64 54.36,127.64 55.78,126.22 v3(56.47,126.22) ; v1(15.24,130.14) 15.36,130.02 20.4,130.02 22.58,127.84 26.65,127.84 27,128.2 27.13,128.2 30.1,131.17 30.1,132.21 31.17,133.28 34.55,133.28 34.93,133.66 42.95,133.66 v1(43.54,133.07)
  L3 w0.762: v3(153.14,139.02) 153.11,138.99 152.92,138.99 152.48,138.54 152.48,138.35 149.96,135.83 149.96,119.97 151.77,118.16 151.77,115.4 150.68,114.31 v1(150.68,110.42)
  L4 w0.127: v1(211.59,49.55) 211.59,48.01 209.9,46.33 208.55,46.33 208.39,46.17 208.39,43.8 208.39,43.79 208.39,43.49 207.78,42.87 v1(207.78,42.22)
  L4 w0.508: 101.65,30.01 101,29.36 99.29,29.36 99.09,29.16 v1(98.78,29.16) 98.36,29.16 97.93,29.59 96.74,29.59 v1(95.99,28.84) ; 101.65,30.01 v1(101.65,30.25) ; 101.65,30.01 102.58,29.08 109.95,29.08 v1(110.06,29.19) ; v1(17.45,110.75) 17.63,110.57 19.18,110.57 19.47,110.86 21.83,110.86 24.21,113.24 24.21,116.73 22.76,118.18 v1(22.76,121.72)
  L4 w0.762: v3(148.21,144.13) 148.42,143.92 148.42,140 148.9,139.52 151.95,139.52 152.45,139.02 v3(153.14,139.02)
  L5SGND w0.381: v1(159.62,94.92) 159.72,94.82 159.72,94.21 163.33,90.6 163.33,88.7 165.18,86.84 165.18,81.79 176.84,70.13 v1(177.24,70.13)
  L5SGND w0.762: v3(165.41,109.32) 165,109.73 v1(164.03,109.73) 161.5,109.73 160.81,109.04 160.81,104.83 159.16,103.18 159.16,95.38 v1(159.62,94.92)
  BOTTOM w0.254: v1(21.98,74.67) 21.99,74.67 21.99,74.95 22.14,75.1 22.86,75.1 23.22,75.47 Q2416.2 Q2416.5 ; R1721.1 139.09,79.55 139.3,79.75 139.3,80.86 139.64,81.21 139.77,81.21 140.57,82.01 141.63,82.01 142.52,82.89 142.52,84.43 142.89,84.81 142.89,85.32 143.58,86 143.58,86.55 143.87,86.84 v1(143.87,86.89)
  BOTTOM w0.305: U4007.5 90.5,38.9 90.5,38.3 89.94,37.75 89.24,37.75 ; v1(31.92,72.52) 31.92,72.4 32.33,71.98 35.19,71.98 35.95,72.75 38.76,72.75 38.99,72.98 v1(39.47,72.98) 39.7,72.75 45.48,72.75 v1(46.35,73.62) ; 89.24,37.75 88.48,38.51 v1(88.06,38.51) ; 89.24,37.75 89.06,37.57 89.06,36.24 88.67,35.85 88.67,35.05 89.73,33.99 91.49,33.99 93.27,32.21 95.14,32.21 v3(95.22,32.13) 95.27,32.18 PG5302.2 ; U5501.5 209.82,49.29 209.32,49.29 209.07,49.03 PR4435.1 ; R6611.1 67.03,36.66 v1(66.13,37.57) R4031.1 ; v1(101.65,30.25) 101.65,31.16 100.26,32.55 100.26,33.81 PR5301.1 ; R2514.1 160.07,94.46 v1(159.62,94.92) 159.36,94.67 R2520.1
  BOTTOM w0.381: v1(17.45,110.75) 16.84,110.14 L7101.1
  BOTTOM w0.406: v1(39.27,117.83) 38.64,118.47 v1(38.64,119.2)
  BOTTOM w0.508: U2502.5 144.48,87.46 143.92,86.89 v1(143.87,86.89) ; 36.15,123.19 36.8,122.54 36.88,122.54 38.64,120.79 v1(38.64,119.2) ; U5501.5 210.75,49.53 211.57,49.53 v1(211.59,49.55) ; v1(22.76,121.72) 24.46,121.72 25.63,122.89 29.04,122.89 29.63,123.48 32.96,123.48 33.25,123.19 34.45,123.19 ; v1(164.03,109.73) 164.03,109.7 163.99,109.65 PR5112.1 ; Q6502.S 94.06,27.81 94.78,28.53 94.96,28.53 94.99,28.56 95.71,28.56 v1(95.99,28.84) ; v1(138.23,92.82) 138.81,93.4 R1910.1 139.13,94.07 139.13,94.17 147.52,102.57 147.52,105.76 150.4,108.64 150.4,109.22 150.73,109.55 150.73,110.36 v1(150.68,110.42)
  vias: v1(42.22,69.17) v1(220.63,67.82) v1(224.62,49.1) v1(224.62,48.46) v3(54.6,105.5) v3(54.61,104.61) v3(57.32,126.18) v3(58.21,126.17) v3(60.64,130.57) v3(60.88,128.97) v3(61.03,129.81) v3(76.3,36.45) v3(77.07,36.83) v3(79.15,30.63) v3(79.99,30.63) v3(153.5,148.16) v3(153.62,146.89) v3(154.46,148.13)
3D3V_S5_PCH: length 486.6
  TOP w0.203: v1(140.36,86.46) 140.02,86.12 137.65,86.12 137.25,85.73 136.16,85.71 R2047.1
  TOP w0.254: v1(130.89,122.81) 131.12,123.04 131.12,123.84 130.46,124.5 130.46,126.28 131.2,127.03 132.82,127.03 133.73,127.94 v1(133.73,128.17) ; v1(153.55,105.87) 154.87,105.87 154.92,105.82 v1(155.73,105.82)
  TOP w0.305: v1(140.36,86.46) 140.74,86.08 141.24,86.08 141.3,86.13 141.88,86.13 142.45,86.7 142.45,87.63 142.25,87.83 141.86,87.83 141.55,88.14 141.55,88.58 141.86,88.89 142.31,88.89 142.48,89.06 142.48,91.71 141.99,92.2 140.74,92.2 139.7,93.24 138.97,93.24 ; v1(133.73,103.37) 133.78,103.42 133.78,103.77 134.07,104.06 134.07,104.07 134.19,104.19 134.19,105.67 133.86,105.99 133.8,105.99 133.3,106.49 133.3,111.5 130.07,114.73 130.07,117.46 v1(130.03,117.5) ; R6877.2 v2(16.36,28.91) 16.36,28.48 15.91,28.03 15.91,27.81 15.6,27.5 15.38,27.5 14.81,26.93 14.81,26.47 v1(15.01,26.26) ; 150.28,73.02 150.72,73.45 151.06,73.45 157.91,66.6 159.48,66.6 163.08,63 163.08,62.49 162.74,62.15 162.74,61.71 173.37,51.08 174.16,51.08 v1(175.2,50.03) ; 150.28,73.02 v1(150.16,72.9) ; 150.28,73.02 150.28,73.69 147.95,76.02 146.79,76.02 146.46,75.7 v1(146.46,75.67) ; v1(83.26,38.3) v1(83.26,30.68) ; v1(176.05,57.68) 176.53,57.68 176.86,57.35 185.4,57.35 186.46,58.42 200.61,58.42 200.89,58.14 203.7,58.14 204.69,57.15 206.4,57.15 207.47,58.21 207.47,58.83 207.07,59.22 207.07,59.29 207.07,59.68 207.07,61.23 207.87,62.03 208.67,62.03 209.56,62.92 210.89,62.92 R1922.1 211.13,62.65 211.13,61.81 R2061.1
  L2SGND w0.305: v1(175.2,50.03) 175.69,49.54 175.69,42.12 174.5,40.92 169.5,40.92 168.95,41.46 154.48,41.46 154.36,41.58 152.35,41.58 151.94,41.18 134.37,41.18 133.73,41.81 122.72,41.81 v1(122.02,41.11)
  L3 w0.254: v1(153.55,105.87) 153.48,105.94 146.05,105.94 143.53,108.46 143.53,109.97 142.07,111.42 v1(142.07,111.48)
  L3 w0.305: v1(130.89,122.81) 130.61,122.53 130.61,117.94 130.17,117.5 v1(130.03,117.5) ; v1(83.26,38.3) 83.87,37.7 92.1,37.7 92.25,37.85 92.43,38.03 97.85,38.03 98.48,38.66 100.49,38.66 101.64,39.81 101.74,39.81 102.13,39.81 103.82,41.5 106.11,41.5 106.73,42.12 107.99,42.12 109.28,43.42 120.54,43.42 122.02,41.93 v1(122.02,41.11)
  L4 w0.305: v1(83.26,30.68) 83.26,30.88 82.33,31.81 77.77,31.81 75.24,29.29 75.21,29.29 74.98,29.06 53.99,29.06 53.88,29.16 43.24,29.16 42.43,28.35 36.71,28.35 33.05,24.69 29.34,24.69 27.92,23.27 24.18,23.27 24.08,23.37 22.25,23.37 22.13,23.24 18.37,23.24 15.34,26.26 v1(15.01,26.26) ; v1(140.36,86.46) 140.36,85.69 141.66,84.39 142.2,84.39 143.4,83.19 143.4,82.8 143.69,82.51 143.69,82 144.71,80.98 144.71,80.3 v1(144.94,80.08) 144.94,79.77 145.81,78.9 145.81,76.32 v1(146.46,75.67) ; v1(151.05,135.83) 150.77,135.83 150.35,136.25 146.48,136.25 140.55,130.32 139.49,130.32 137.88,128.71 134.75,128.71 134.21,128.17 v1(133.73,128.17)
  BOTTOM w0.203: R2521.1 148.72,76.91 147.33,75.52 146.61,75.52 v1(146.46,75.67) ; R1510.1 157.97,100.08 158.52,100.64 158.52,103.68 156.39,105.82 v1(155.73,105.82) ; R2041.1 130.46,100.88 131.03,100.3 131.03,100.01 131.05,99.99
  BOTTOM w0.254: 149.71,72.45 148.86,71.6 148.83,71.57 126.13,71.57 118.91,78.79 R1837.1
  BOTTOM w0.305: RN1811.2 131.63,99.96 131.78,100.1 ; 149.71,72.45 149.71,72.45 v1(150.16,72.9) 150.4,73.14 150.4,74.03 151.86,75.5 151.86,78.03 152.25,78.42 152.25,81.13 151.78,81.6 R1506.1 152.14,82.07 152.14,82.43 154.14,84.43 154.38,84.43 155.04,85.09 156.24,85.09 156.9,85.75 156.9,86.41 156.39,86.92 R2519.1 156.37,87.58 R2515.1 155.51,87.7 154.82,88.39 R1508.1 ; v1(136.1,101.62) 136.19,101.71 137.33,101.71 137.47,101.86 137.49,101.86 140.77,105.13 140.77,106.34 140.77,106.43 139.83,107.37 R1554.1 ; 139.86,108.41 139.86,110.39 R406.1 ; 131.78,100.1 132.01,100.34 132.01,100.74 132.62,101.35 133.35,101.35 133.9,101.89 133.9,103.2 v1(133.73,103.37) ; 131.78,100.1 131.16,100.1 131.05,99.99 131.05,99.87 131.04,99.86 131.04,99.77 130.96,99.7 RN1811.1 ; R9148.1 151.29,136.06 v1(151.05,135.83) ; v1(175.2,50.03) 175.12,50.11 175.12,54.53 176.64,56.05 176.64,57.15 176.24,57.56 176.18,57.56 176.05,57.68 v1(176.05,57.68) ; v1(142.07,111.48) 141.95,111.61 141.12,111.61 140.24,110.73 R406.1 ; R1502.1 144.94,79.28 v1(144.94,80.08) ; R406.1 140.13,110.73 R405.1
  BOTTOM w0.508: R1103.1 135.61,93.29 136.39,93.29 136.51,93.41 136.72,93.41 v1(136.78,93.47) ; R2516.2 140.77,85.98 140.76,85.98 140.39,86.35 140.39,86.36 140.36,86.39 v1(140.36,86.46) 139.32,86.46 R1522.1 R2062.1 R1513.1
3D3V_S5_PCH_R: length 4.4
  BOTTOM w0.254: Q401.2 140.83,113.93 140.95,113.8 140.95,113.44 140.79,113.28 Q401.3 140.05,112.93 140.51,112.47 140.55,112.47 v2(140.57,112.46) 140.55,112.44 140.55,112.24 140.2,111.89 R406.2
3D3V_SPIVCC1: length 22.1
  BOTTOM w0.254: 160.71,106.4 158.88,104.57 158.88,97.59 158.25,96.95 157.33,96.95 156.59,96.22 C2501.1
  BOTTOM w0.305: C2501.1 156.52,95.25 156.01,94.74 C2502.1 155.7,94.44 155,93.73 BIOS1.8 154.97,92.89 155.3,92.56 v2(156.24,92.56) 156.24,88.68 R2515.2
3D3V_SSD:
  vias: v1(18.49,23.9) v1(18.58,26.56) v1(19.15,23.88) v2(18.85,25.06) v2(39.81,30.28)
3D3V_SSD_C: length 276
  TOP w0.089: v2(101.46,44.44) 101.2,44.7 v1(101.2,45.1)
  L3 w0.089: v1(101.2,45.1) 100.72,45.58 100.54,45.58 99.32,44.36 98.56,44.36 96.62,42.42 92.05,42.42 91.84,42.63 82.19,42.63 81.98,42.42 81.1,42.42 79.66,40.98 74.43,40.98 71.5,38.06 68.2,38.06 67.86,38.4 65.11,38.4 64.97,38.55 62,38.55 61.48,38.02 61.48,36.08 60.54,35.15 56.41,35.15 56.07,35.15 54.62,33.7 40.68,33.7 39.8,34.58 39.8,37.24 38.52,38.52 35.58,38.52 35.36,38.74 v1(34.77,38.74)
  L4 w0.089: 160.68,128.35 160.68,128.24 161.97,126.94 161.97,119.51 163.94,117.54 163.94,112.2 156.8,105.06 156.8,96 159.71,93.08 160.15,93.08 164.94,88.29 164.94,80.97 175.87,70.04 175.87,69.79 176.05,69.61 v1(176.05,69.04) ; 159.55,143.19 v1(160.53,144.18)
  L4 w0.102: 159.55,143.19 158.22,141.86 158.22,141.41 158.08,141.27 158.08,138.98 159.01,138.05 159.19,138.05 159.56,137.67 159.56,137.67 160.65,136.58 160.65,128.37 160.68,128.35
  BOTTOM w0.089: v1(176.05,69.04) 176.46,68.63 176.46,66.29 176.03,65.86 174.45,65.86 173.8,66.51 170.65,66.51 169.79,65.64 169.79,63.75 169.72,63.68 167.94,61.88 167.94,60.18 163.15,55.39 157.27,55.39 156.45,54.56 147.91,54.56 147.47,55 145.57,55 145.11,55.46 110.77,55.46 109.88,54.58 109.68,54.58 109.61,54.5 104.01,54.5 101.42,51.91 101.42,45.98 101.2,45.76 v1(101.2,45.1) ; v1(34.77,38.74) 35.29,38.21 35.29,35.08 36.78,33.59 37.99,33.59 38.64,32.93 38.64,31.9 39.1,31.45 41.18,31.45 R9314.2
  BOTTOM w0.102: v1(160.53,144.18) 160.57,144.15 PMBD1.7 160.57,142.07 R9327.2
3D3V_TP_CT2: length 1.8
  TOP w0.102: v1(213.68,44.3) 213.66,44.28 213.48,44.28 213.08,43.88 C5540.1
  BOTTOM w0.102: v1(213.68,44.3) 213.66,44.31 213.66,44.47 213.35,44.79 U5502.10
3D3V_TPM: length 17.1
  TOP w0.508: v1(155.25,138.59) 155.29,138.63 v2(155.29,139.15)
  L3 w0.508: v3(153.98,142.72) 153.98,142.45 150.77,139.25 150.77,139.16 149.96,138.35 v1(149.96,138.3)
  L4 w0.508: v1(155.25,138.59) 155.25,138.55 154.86,138.16 154.86,137.84 154.18,137.16 152.8,137.16 152.54,137.42 150.85,137.42 v1(149.96,138.3)
  BOTTOM w0.305: v1(155.25,138.59) 155.25,138.55 154.77,138.06 R9150.2 154.77,137.21 R9119.2 ; C9113.1 149.96,137.87 v1(149.96,138.3) 149.96,138.79 149.97,138.79 U9103.22
3D3V_VCCDSW: length 35.8
  TOP w0.305: C2230.1 111.01,91.48 v1(111.01,91.58) v1(111.01,92.41)
  L3 w0.254: v1(141.23,87.25) 140.96,87.51 140.96,87.95 140.22,88.7 127.18,88.7 127.05,88.57 122.69,88.57 120.37,90.88 111.67,90.88 111.01,91.54 v1(111.01,91.58)
  L4 w0.508: v1(111.01,92.41) v1(111.01,91.58)
  BOTTOM w0.203: CPU1.BT23 v1(111.01,92.41) ; CPU1.BR24 v1(111.01,91.58)
  vias: v2(142.55,87.81)
3D3V_VCCPRIM: length 35.3
  TOP w0.254: 111.01,94.01 v1(111.01,94.09) ; 111.01,94.01 111.01,93.99 C2228.1 ; 111.01,94.01 110.36,93.36 v1(110.36,93.25)
  TOP w0.305: v3(131.23,90.86) 130.73,90.36 130.73,89.03 129.7,87.99 127.74,87.99 125.47,85.72 124.35,85.72 123.83,85.2 123.83,83.04 122.86,82.07 120.83,82.07 119.43,80.68 119.43,77.73 v1(119.26,77.55)
  BOTTOM w0.127: CPU1.CP29 122.15,89 122.25,89.09 v1(123.27,89.09)
  BOTTOM w0.254: R1731.1 117.11,79.69 117.29,79.69 118.74,78.23 118.75,78.23 119.26,77.73 v1(119.26,77.55)
  BOTTOM w0.305: CPU1.BP23 v1(110.36,93.25) ; v1(116.21,93.25) CPU1.CC22 v1(115.56,93.25) ; v1(116.21,93.25) CPU1.CD23 v1(116.86,93.25) CPU1.CD22 v1(116.21,93.25) ; v1(116.21,93.25) CPU1.CC23 v1(115.56,93.25) ; v1(115.56,93.25) CPU1.CB22 ; v1(115.56,93.25) CPU1.CB23 ; CPU1.BV23 v1(112.96,92.41) CPU1.BW23 ; CPU1.BT20 v1(111.01,94.09) ; CPU1.CB16 v1(115.56,96.61)
  vias: v2(131.83,91.77)
3D3V_VCCPRTC: length 38.2
  TOP w0.254: v1(110.36,92.41) 110.36,92.28 109.74,91.65 C2229.1 109.73,91.49 C2222.1
  TOP w0.508: R2204.2 137.79,88.65 138,88.44 138.18,88.44 C2221.1 138.75,88.32 139.19,87.89 v2(139.3,87.89) 139.64,87.54 v1(139.64,87.22)
  L3 w0.254: v1(139.64,87.22) 138.57,88.29 127.31,88.29 127.21,88.19 122.58,88.19 120.29,90.48 110.78,90.48 109.88,91.37 109.88,91.82 110.36,92.3 v1(110.36,92.41)
  BOTTOM w0.254: CPU1.BR23 v1(110.36,92.41)
3D3V_WLAN:
  vias: v1(48.41,107.12) v2(52.75,100.4) v3(45.67,106.36) v3(48.41,106.39) v4(52.16,104.34)
+DC_IN:
  vias: v2(25.06,128.89) v3(23.3,129.83) v3(23.32,128.96) v3(24.21,129.82) v3(24.21,128.91) v3(27.49,130.46) v3(27.77,131.3) v3(28.35,130.46) v3(28.59,131.5)
+DC_IN_C:
  vias: v2(19.67,126.75) v2(23.84,124.4) v3(21.28,126.89) v3(21.72,126.16) v3(22.14,126.89) v3(22.61,126.16) v3(23.63,126.14)
+RTC_CELL_VBAT: length 16.2
  TOP w0.178: U2401.122 27.55,73.26 27.09,72.8 26.75,72.8 26.6,72.65 v1(26.54,72.65)
  TOP w0.508: R2451.2 17.07,71.55 v1(16.91,71.4)
  BOTTOM w0.203: v1(16.91,71.4) 18.17,71.4 18.49,71.72 19.76,71.72 21.11,70.38 21.93,70.38 21.97,70.42 22.2,70.65 v2(22.2,70.74) 22.39,70.93 23.39,70.93 R2472.1
  BOTTOM w0.305: C2428.1 24.31,72.03 24.35,71.99 24.35,71.55 R2476.1 ; R2476.1 24.16,71.43 23.71,70.98 R2472.1 ; R2476.1 24.53,71.12 24.6,71.12 24.96,70.77 25.72,70.77 26.03,71.07 R2496.2 26.38,71.42 26.54,71.59 v1(26.54,72.65)
+RTC_VCC: length 132.3
  TOP w0.305: AFTP6615.1 142.5,110.26 v1(142.55,110.21)
  L3 w0.305: v1(162.8,81.87) 162.77,81.9 162.77,82.74 162.08,83.42 162.08,84.68 161.64,85.12 161.64,86.51 161.13,87.02 161.13,87.02 160.69,87.46 160.69,87.46 143.12,105.03 143.12,109.76 142.67,110.21 v1(142.55,110.21) ; v1(169.92,36.06) 169.92,36.02 170.47,35.46 174.75,35.46 176.95,33.27 186.53,33.27 189.9,36.63 190.6,36.63 191.37,37.39 192.55,37.39 192.86,37.09 193.24,37.09 193.73,36.6 v1(196.53,36.6)
  L4 w0.305: v1(169.92,36.06) 172.04,38.18 172.04,39.93 173.31,41.2 173.31,41.89 171.81,43.38 171.81,49.81 157.99,63.63 157.84,63.63 156.34,65.14 156.34,66.68 v1(156.13,66.89)
  BOTTOM w0.254: v1(142.55,110.21) 142.67,110.21 143.34,110.87 Q2505.G
  BOTTOM w0.305: v1(162.8,81.87) 162.77,81.84 162.64,81.84 161.62,80.82 R2504.1 160.21,80.82 158.61,79.22 157.9,79.22 D2501.2 156.83,78.16 156.83,77.25 159.35,74.74 159.35,69.87 157.29,67.81 156.92,67.81 156.76,67.65 156.76,67.53 v1(156.13,66.89) ; v1(196.53,36.6) 197.3,37.37 IOBD1.13
+SDC_IN: length 34.4
  TOP w0.305: PR4434.2 203.81,55.25 203.1,54.54 201.43,54.54 199.4,56.56 195.98,56.56 194.78,57.77 186.7,57.77 185.68,56.74 176.78,56.74 176.38,57.15 175.79,57.15 175.5,57.44 175.5,58.29 176.58,59.36
  TOP w0.457: R4318.1 35.92,126.21 35.4,125.7
  vias: v1(181.69,61.55) v1(181.67,60.57) v1(182.13,61.06) v1(182.2,60.15) v1(182.63,60.65) v1(182.83,60.01) v1(183.46,60.01) v2(62.62,136.88) v2(84.45,148.73) v2(119.26,147.52) v2(163.11,90.97) v2(163.53,148.85) v2(164.44,116) v2(179.37,59.87) v3(32.29,125.68) v3(33.18,126.49) v3(33.23,125.6) v3(34.17,125.58) v3(57.2,138.08) v3(57.2,137.19) v3(58.09,138.08) v3(58.09,137.19) v3(72.39,147.09) v3(73,147.73)
+SDC_IN_SW_R1: length 21.6
  TOP w0.102: R4334.1 38.46,126.52 38.46,127.71 37.11,129.05 v1(36.86,129.05) ; v2(27.66,119.15) 27.77,119.15 28.09,119.47 v1(28.09,119.52) 28.09,119.67 27.84,119.91 Q4349.3
  L4 w0.102: v1(28.09,119.52) 28.1,119.53 28.1,124.08 29.21,125.2 29.21,127.74 30.36,128.88 36.69,128.88 v1(36.86,129.05)
+V_VREF_PATH1: length 1.8
  TOP w0.305: v2(70.32,43.17) 70.84,42.65 R1209.1
  TOP w0.508: C1222.2 R1209.1
+V_VREF_PATH2:
  vias: v2(145.54,43.56)
AC_DIS: length 113.6
  TOP w0.102: R4481.2 25.67,119.49 R4312.1 25.67,120.43 v1(25.47,120.63) ; v1(40.03,61.49) 39.83,61.69 U2401.69 ; Q4304.B 27.61,123.42 27.28,123.09 25.89,123.09 v2(25.48,122.68) 25.48,122.02 v1(25.58,121.92)
  L4 w0.102: v1(25.58,121.92) 25.5,121.92 25.23,121.64 25.23,120.87 v1(25.47,120.63) 26.06,120.04 26.06,116.28 27.16,115.19 27.16,114.43 26.39,113.67 26.39,111.41 26.09,111.1 26.09,103.53 28.76,100.86 31.84,100.86 36.22,96.48 36.22,94.69 38.74,92.18 38.74,81.04 37.77,80.08 37.77,78.39 38.23,77.93 38.23,77.54 37.06,76.38 28.45,76.38 27.66,77.17 24.12,77.17 22.33,75.38 21.01,75.38 18.95,73.32 18.95,71.5 18.4,70.95 18.4,70.13 17.96,69.69 17.96,67.4 v1(17.65,67.1)
  BOTTOM w0.102: v1(40.03,61.49) 40.03,61.78 39.53,62.28 35.84,62.28 33.85,64.28 32.17,64.28 31.25,65.2 27.73,65.2 26.08,66.85 25.68,66.85 25.08,67.45 22.15,67.45 21.86,67.74 21.33,67.74 20.69,67.1 v1(17.65,67.1)
AC_IN#_G: length 25.7
  TOP w0.254: v1(39.4,117.02) 39.91,117.02 40.59,117.7 40.59,118.14 U4302.5 40.92,118.47 R4377.1 ; v1(25.66,121.24) 25.55,121.24 25.05,121.73 25.05,122.8 24.56,123.29 R4376.2
  BOTTOM w0.254: v1(39.4,117.02) 39.26,117.02 38,118.28 38,120.46 36.56,121.91 30.72,121.91 30.36,121.54 29.49,121.54 28.78,122.25 v2(27.05,122.25) 26.67,122.25 v1(25.66,121.24)
AC_PRESENT: length 58.4
  L3 w0.102: v1(113.27,81.79) 113.65,82.17 114.37,82.17 115.17,81.37 120.03,81.37 120.31,81.65 121.3,81.65 121.71,81.24 123.16,81.24 126.82,77.57 127.74,77.57 128.11,77.94 128.61,77.94 128.82,78.15 130.4,78.15 v1(130.58,78.33)
  BOTTOM w0.076: CPU1.BU35 112.28,85.19 112.41,84.85 112.41,84.82 112.42,84.8 112.44,84.75 112.44,84.52 112.42,84.47 112.42,84.46 112.42,84.16 112.44,84.1 112.44,83.81 112.58,83.67 112.58,82.67 113.27,81.98 v1(113.27,81.79)
  BOTTOM w0.102: Q1702.3 144.86,83.9 D1701.A 143.87,83.58 143.39,83.1 143.39,82.42 142.52,81.55 142.52,81.04 141.96,80.47 141.15,80.47 140.97,80.29 140.13,80.29 139.75,79.92 139.75,79.17 139.98,78.94 v2(139.98,78.92) 139.98,78.77 139.6,78.39 139.6,78.01 138.75,77.15 138.07,76.48 134.33,76.48 133.91,76.9 133.12,76.9 132.91,77.12 131.04,77.12 130.58,77.57 v1(130.58,78.33) 130.86,78.61 131.15,78.61 134.28,81.74 134.28,83.12 134.55,83.39 134.81,83.39 134.94,83.52 136.01,83.52 136.16,83.37 136.78,83.37 137.51,84.1 138.31,84.1 EC1707.1 139.14,83.64 139.77,84.27 139.77,84.27 139.9,84.4 RN1704.7
ACOK#: length 2.8
  TOP w0.102: v1(206.91,43.7) 206.91,43.69 206.81,43.59 PR4427.2
  BOTTOM w0.102: PQ4415.2 206.81,43.79 206.9,43.7 v1(206.91,43.7) 206.91,43.67 206.38,43.14 PQ4415.3
ACOK_IN_M: length 395.9
  TOP w0.102: D4309.K 36.67,132.24 D4305.K 36.26,133.4 v1(35.68,132.82) ; v1(180.77,69.22) 180.77,69.37 v2(180.44,69.7) ; v1(205.79,35.05) 205.79,35.61 206.7,36.51 206.7,38.5 206.41,38.78 206.41,39.32 206.07,39.66 206.07,41.09 206.07,41.1 206.07,41.18 205.25,41.99 205.25,42.42 v1(205.41,42.57)
  L4 w0.102: v1(35.68,132.82) 36.67,133.81 54.73,133.81 56.37,135.44 56.37,135.63 56.37,138.28 57.23,139.14 62.07,139.14 71.95,149.03 95.65,149.03 97.24,147.44 104.87,147.44 106.29,148.86 107.01,148.86 120.1,148.86 122.13,146.84 127.75,146.84 131.5,150.59 163.85,150.59 167.25,147.19 167.25,125.26 165.65,123.66 165.65,119.28 166.2,118.73 166.2,109.09 165.19,108.08 164.06,108.08 163.49,107.52 162.73,107.52 158.67,103.46 158.67,98.2 167.61,89.27 167.61,81.77 179.28,70.09 179.45,70.09 180.31,69.24 180.75,69.24 v1(180.77,69.22) 181.13,68.86 186.23,68.86 186.68,68.72 187.27,68.46 187.49,68.31 188.43,67.37 188.62,67.19 189.24,66.58 209.08,66.58 209.4,66.9 212.55,66.9 213.81,65.63 219,65.63 221.87,62.77 221.87,44.04 219.87,42.04 218.65,42.04 217.39,40.78 216,40.78 214.27,39.05 213.95,39.05 212.1,37.19 209.61,37.19 207.47,35.05 v1(205.79,35.05) ; v1(158.7,60.2) 158.14,60.2 154.82,63.53 154.82,65.85 154.81,65.86 154.81,65.93 154.18,66.56 154.18,67.34 148.31,73.21 148.31,75.26 147.55,76.02 147.55,78.25 147.12,78.69 147.12,79.74 146.36,80.49 146.36,80.74 144.8,82.3 v1(144.76,82.3)
  BOTTOM w0.102: v1(180.77,69.22) 180.77,68.35 180.5,68.07 178.45,68.07 178.17,68.35 177.79,68.35 176.27,69.88 176.16,69.88 173.37,72.67 170.84,72.67 166.17,67.99 166.17,65.84 163.22,62.89 163.22,62.5 161.17,60.45 158.96,60.45 v1(158.7,60.2) ; v1(205.41,42.57) 205.28,42.69 205.28,44 204.84,44.44 PQ4415.6 ; D1701.K 144.05,82.4 144.66,82.4 v1(144.76,82.3)
AD_IA: length 302.2
  TOP w0.089: v2(206.97,42.15) 206.95,42.15 v1(206.56,42.55) ; v1(35.89,77.9) 35.44,77.45 R2421.1
  L3 w0.089: v1(173.67,68.48) 173.68,68.49 174.6,68.49 174.94,68.15 174.94,68.15 175.26,67.84 175.32,67.84 175.47,67.69 175.48,67.68 177.35,67.68 178.23,66.81 180.56,66.81 184.56,62.81 187.3,62.81 190.12,65.62 209.16,65.62 209.6,65.18 216.79,65.18 219.85,62.12 220.21,62.12 221.07,61.26 221.07,53.86 220.74,53.53 219.51,53.53 217.2,51.23 217.2,50.27 214.04,47.11 212.58,47.11 211.14,45.66 211.14,43.88 210.51,43.25 210.51,43.24 210.16,42.88 210.15,42.88 210.12,42.86 209.04,42.86 208.8,43.1 207.57,43.1 207.01,42.55 v1(206.56,42.55) ; v1(14,63.63) 14.07,63.7 14.07,64.34 13.82,64.59 13.36,64.59 12.99,64.22 12.77,64.22 12.27,64.72 12.27,65.28 11.99,65.56 11.99,66.45 15.03,69.49 15.03,70.16 15.52,70.64 15.52,71.86 18.43,74.77 18.43,75.45 21.58,78.61 27.91,78.61 28.04,78.48 28.04,78.48 28.82,77.7 30.03,77.7 30.41,77.32 30.73,77.32 30.78,77.38 35.17,77.38 35.49,77.69 35.68,77.69 v1(35.89,77.9)
  BOTTOM w0.089: PR4412.1 202.57,43.61 PC4432.1 202.48,43.49 202.48,42.97 203.06,42.39 204.33,42.39 204.58,42.14 206.15,42.14 v1(206.56,42.55) ; v1(14,63.63) 15.15,62.48 19.01,62.48 19.35,62.81 21.39,62.81 22.32,61.88 22.32,61.88 22.37,61.83 23.17,61.83 23.75,62.42 24.73,62.42 24.86,62.55 25.49,62.55 26.39,61.64 26.39,56.33 26.81,55.91 26.81,55.91 27.08,55.64 27.08,55.64 27.18,55.54 27.18,53.49 27.57,53.1 36.81,53.1 37.63,53.93 42.66,53.93 42.99,54.26 55.71,54.26 57.66,56.22 108.82,56.22 110.24,57.63 146.01,57.63 146.57,57.07 148.49,57.07 148.82,56.74 155.67,56.74 155.92,56.99 156.41,57.47 161.24,57.47 165.54,61.78 165.54,62.54 167.85,64.86 167.85,66.06 169.84,68.05 173.23,68.05 173.42,68.23 173.42,68.23 v1(173.67,68.48)
AD_OFF_L: length 3.5
  TOP w0.254: Q4305.1 26.24,126.83 26.99,126.08 26.99,125.5 27.03,125.45 27.03,125.42 27.33,125.12 27.36,125.12 27.37,125.11 28.39,125.11 Q4304.C
AD_OFF_R: length 6.7
  TOP w0.254: C4301.2 27.38,128.21 R4307.2 28.26,129.08 R4308.1 28.49,128.97 PU4301.4 28.92,128.67 28.92,127.55 v2(28.65,127.28) 28.65,126.72 28.36,126.42 Q4305.3
ALERT#: length 5.6
  TOP w0.102: v1(130.53,123.7) 130.53,123.93 129.07,125.4 U2601.6 127.02,125.4 v2(126.71,125.08)
  BOTTOM w0.102: R2603.2 130.89,124.05 v1(130.53,123.7)
ALWON: length 59.7
  TOP w0.102: U2401.121 27.95,73.29 26.89,72.22 26.06,72.22 25.99,72.16 v1(25.97,72.16) ; R4009.2 28.14,29.01 v2(28.04,28.92) 27.86,28.73 v1(27.86,28.14)
  L3 w0.102: v1(25.97,72.16) 25.74,72.16 21.65,68.07 21.65,68.06 21.28,67.69 21.27,67.69 20.97,67.39 20.97,66.85 21.15,66.67 21.15,65.98 19.82,64.65 19.24,64.65 18.51,63.93 18.51,62.83 19.08,62.27 19.08,61.12 19.78,60.42 19.78,59.55 19.88,59.45 19.88,58.3 19.46,57.88 19.46,56.52 19.46,55.3 19.46,51.86 19.63,51.69 19.63,50.41 19.35,50.13 19.35,50.11 18.86,49.62 18.86,45.86 18.86,45.53 18.86,45.05 18.86,44.82 20.85,42.84 20.85,42.03 22.19,40.69 22.19,38.25 21.49,37.56 21.49,31.74 21.8,31.43 21.8,31.38 24.12,29.06 24.17,29.06 25.12,29.06 25.81,28.37 27.63,28.37 v1(27.86,28.14)
AMBER_LED_BAT: length 30.4
  TOP w0.127: v1(14.87,128.33) 14.87,127.74 v2(14.87,127.74) 14.82,127.7 14.82,126.18 15.33,125.68 15.94,125.68 16.77,124.84 16.77,124.53 17.69,123.61 17.69,122.91 v1(18.01,122.58)
  L4 w0.127: v1(18.01,122.58) 17.96,122.53 17.96,121.6 16.73,120.37 15.34,120.37 12.94,117.97 10.94,117.97 10.34,117.37 10.34,112.29 10.25,112.2 10.25,111.78 v1(10.69,111.35)
  BOTTOM w0.127: v1(14.87,128.33) 14.83,128.37 14.76,128.37 14.57,128.56 14.53,128.56 14.21,128.88 11.51,128.88 R6407.1 10.49,129.16 EC6402.1 ; v1(10.69,111.35) 9.71,110.37 Q6403.C
AUD_AGND: length 19.6
  TOP w0.203: v1(30.13,11.28) 30.13,11.43 29.59,11.97 HDA27.31 ; v1(23.32,12.26) 23.43,12.37 HDA27.19
  TOP w0.305: v1(23.32,12.26) 23.32,12.21 23.12,12.01 C2706.2 ; v1(19.08,16.97) 19.08,16.97 19.08,16.79 18.55,16.26 C2715.2
  TOP w0.381: v1(34.65,7.2) 34.63,7.22 R2704.1 34.62,7.85 R2705.1 34.62,9.78 C2711.2 34.7,10.47 v1(34.7,11.33) 33.71,11.33 C2710.1
  TOP w0.508: EC2704.1 v1(29.87,5.13) ; EC2705.1 22.92,5.89 22.85,5.96 v2(22.85,6) 22.85,6.37 23.02,6.53 v1(23.02,6.61) ; EC2703.1 v1(33.79,5.2)
  L2SGND w0.635: HPMIC1.MS 9.01,10.35 ; HPMIC1.MS 6.41,10.35 ; HPMIC1.MS 7.71,9.51
  L5SGND w0.635: HPMIC1.MS 9.01,10.35 ; HPMIC1.MS 7.71,9.51 ; HPMIC1.MS 6.41,10.35
  vias: v1(17.17,15.6) v1(17.96,12.83) v1(20.58,19.1) v1(21.44,10.52)
AUD_HP1_JACK_L: length 7.8
  TOP w0.203: 26.73,9.94 HDA27.25
  TOP w0.305: R2922.2 24.29,8.51 R2908.1 24.29,7.44 24.74,6.99 25.46,6.99 25.78,7.31 25.78,8.43 26.19,8.84 R2913.2 26.34,9.55 26.73,9.94
AUD_HP1_JACK_L1: length 7.8
  TOP w0.381: R2908.2 23.42,7.42 v1(23.7,7.14) ; R2907.1 19.89,9.5 v1(19.64,9.75) 19.64,9.88 19.94,10.19 EC2907.1
  L3 w0.381: v1(23.7,7.14) 23.17,7.67 21.97,7.67 19.89,9.75 v1(19.64,9.75)
AUD_HP1_JACK_R: length 6.8
  TOP w0.203: HDA27.26 27.13,10.41 27.18,10.36
  TOP w0.381: v2(29.04,5.37) 29.01,5.37 28.41,5.97 R2912.2 28.19,6.17 28.19,7.4 28.18,7.8 R2910.1 R2921.2 27.94,9.53 27.18,10.29 27.18,10.36
AUD_HP1_JACK_R1: length 10.5
  TOP w0.381: R2909.1 EC2908.1 18.98,11.02 19.36,10.65 v1(19.36,10.49)
  L3 w0.381: v1(26.89,7.48) 26.76,7.48 25.73,8.51 22.48,8.51 20.5,10.49 v1(19.36,10.49)
  vias: v2(27.66,7.24)
AUD_HPJD_N: length 5.2
  TOP w0.203: 23.9,15.37 24.1,15.17 HDA27.12
  TOP w0.254: R2710.2 21.57,17.86 R2711.2 22.08,17.83 22.09,17.82 22.19,17.82 23.74,16.26 23.74,16.23 v2(23.79,16.18) 23.79,16.17 23.9,16.06 23.9,15.37
AUD_PC_BEEP: length 3.3
  TOP w0.203: 24.44,16.1 HDA27.11
  TOP w0.254: C2735.2 22.62,18.11 22.84,17.89 22.84,17.88 23.22,17.5 v2(23.22,17.47) 23.25,17.47 24.44,16.29 24.44,16.1
AUD_PC_BEEP_C: length 3.6
  TOP w0.254: C2735.1 22.79,19.23 22.79,19.56 23.24,20.02 23.24,20.05 v2(23.32,20.13) 23.32,20.66 D2703.3 22.46,20.71 R2735.1
AUD_PORTA_L_HPMIC1: length 14.4
  TOP w0.381: v1(19.64,7.9) 19.89,7.65 21.93,7.65 22.26,7.98 ED2910.1 21.67,8.51 21.16,9.02 R2907.2
  L3 w0.381: HPMIC1.1 11.85,10.35 14.79,7.42 19.15,7.42 v1(19.64,7.9)
AUD_PORTA_R_HPMIC1: length 31.6
  TOP w0.381: ED2910.2 19.94,8.54 v1(19.61,8.87) 19.08,9.4 R2909.2
  L3 w0.381: v1(19.61,8.87) 16.89,8.87 15.37,10.39 15.37,11.23 15.97,11.82 15.97,14.22 16.07,14.32 16.07,17.13 18.55,19.61 18.55,20.35 18.21,20.68 15.04,20.68 14.25,21.46 7.75,21.46 6.31,20.02 HPMIC1.2
AUD_RING: length 0.8
  TOP w0.203: 23.68,14.89 23.79,14.77 HDA27.13
  vias: v2(22.6,16.41) v3(16.69,11.94) v3(23.14,15.65)
AUD_SENSE: length 3.9
  TOP w0.254: R2711.1 20.69,17.78 19.74,17.78 19.72,17.76 C2902.1 19.68,17.68 19.59,17.78 19.14,17.78 18.34,16.99 v2(18.34,16.89) 18.29,16.89 18.16,16.77 R2923.2
AUD_SLEEVE: length 6.3
  TOP w0.203: HDA27.14 23.44,14.37
  L3 w1.016: v3(22.05,15.6) 19.21,15.6 17.83,16.97 v3(17.83,17.53)
  vias: v2(23.29,14.51)
AUD_SPK_L+: length 13.9
  TOP w0.203: HDA27.35 30.23,13.57 30.56,13.23
  BOTTOM w1.016: v3(20.53,5.39) 23.5,8.36 23.5,9.36 25.64,11.51 29.1,11.51 29.73,12.15
  vias: v2(18.6,5.55) v3(31.4,13.26)
AUD_SPK_L+_C: length 7
  TOP w1.016: 15.73,5.92 14.15,5.92 14.15,5.95 AFTP2902.1 9.2,6.96 v3(9.17,6.94)
AUD_SPK_L-: length 17.2
  TOP w0.203: HDA27.36 30.67,13.97 v3(30.71,13.92)
  BOTTOM w1.016: 29.35,13.58 28.55,12.78 25.12,12.78 22.1,9.76 22.1,8.82 19.26,5.97 19.26,4.07 v3(19.41,3.91)
  vias: v2(20.23,3.87)
AUD_SPK_L-_C: length 8.2
  TOP w1.016: v3(7.9,6.95) 7.9,6.41 8.65,5.67 12.61,5.67 13.81,4.47 AFTP2901.1
AUD_SPK_R+: length 22.2
  TOP w0.203: v3(30.43,15.09) 30.13,15.09 29.81,14.77 HDA27.38
  BOTTOM w1.016: v3(19.46,1.73) 21.22,1.73 24.47,4.98 27.66,4.98 33.79,11.11 33.79,13.96
  vias: v2(20.11,1.62)
AUD_SPK_R+_C: length 5
  TOP w1.016: v3(11.18,3.1) AFTP2904.1 12.5,1.78 15.62,1.78
AUD_SPK_R-: length 18.9
  TOP w0.203: 30.47,14.5 30.2,14.5 30.07,14.37 HDA27.37
  BOTTOM w1.016: v3(20.48,3.1) 20.78,3.1 23.93,6.25 27.13,6.25 32.52,11.63 32.52,13.82
  vias: v2(18.14,3.1) v3(31.4,14.94)
AUD_SPK_R-_C: length 6
  TOP w1.016: 15.65,3.15 13.17,3.15 AFTP2903.1 10.24,4.37 v3(10.21,4.34)
AUD_VREF: length 2.7
  TOP w0.203: 25.16,10.58 25.53,10.95 HDA27.22
  TOP w0.254: 25.16,10.58 v2(24.43,10.58) 23.8,9.95 C2702.2
AUX_EN_WOWL: length 298.1
  TOP w0.089: R1718.2 53.74,108.76 53.87,108.89 53.87,109.53 v2(53.8,109.6) v1(53.04,109.6)
  L4 w0.089: v1(111.64,87.86) 111.23,87.46 111.23,86.59 113.69,84.13 114.26,84.13 114.71,83.68 114.71,83.23 115.48,82.46 119.67,82.46 119.9,82.23 121.01,82.23 121.02,82.23 121.52,81.72 121.52,80.55 145.76,56.31 150.48,56.31 157.02,49.77 157.02,47.9 156.49,47.37 156.49,44.89 155.31,43.71 133.17,43.71 133.01,43.87 125.84,43.87 123.34,46.37 107.88,46.37 107.06,45.55 104.32,45.55 103.36,46.51 99.27,46.51 96.81,44.06 95.14,44.06 94.88,43.8 93.32,43.8 93.23,43.71 92.71,43.71 92.44,43.94 81.57,43.94 81.17,43.54 79.29,43.54 79.25,43.51 63.59,43.51 63.58,43.51 36.29,43.51 36.04,43.26 30.99,43.26 30.11,44.14 30.11,45.55 29.81,45.85 28.83,45.85 28.2,46.48 28.2,46.65 28.19,46.66 28.15,46.89 28.15,48.11 29.54,49.5 29.54,51.02 31.77,53.24 31.77,54.85 32.02,55.1 32.08,55.1 33.9,56.92 34.35,56.92 34.6,57.17 34.6,57.8 37.08,60.28 37.82,60.28 38.93,61.4 38.93,61.81 40.12,62.99 41.15,62.99 43.03,64.88 43.03,65.29 44.21,66.47 45.48,66.47 50.2,71.2 50.2,72.08 53.26,75.14 v1(53.26,75.91) ; v1(53.04,109.6) 52.41,108.97 52.41,107.93 46.66,102.19 46.66,93.88 48.1,92.44 48.1,87.45 47.35,86.7 47.35,86.07 46.48,85.19 45.7,85.19 44.6,84.1 44.6,82.85 43.84,82.09 43.23,82.09 42.95,81.81 42.95,79.47 42.57,79.09 42.57,78.74 43.06,78.25 43.06,77.27 v1(42.8,77.01)
  BOTTOM w0.089: v1(111.64,87.86) 111.64,87.86 111.57,88.07 CPU1.BT30 ; v1(53.26,75.91) 53.24,75.92 53.24,76.05 52.38,76.91 49.94,76.91 49.59,76.56 43.26,76.56 v1(42.8,77.01)
AUX_EN_WOWL_R: length 87.3
  TOP w0.089: v1(51.56,109.06) 51.56,109.26 52.01,109.71 Q6102.S 52.4,109.41 R1718.1 ; v1(16.21,58.68) 16.58,59.05 17.1,59.05 17.89,58.26 17.89,57.71 18.18,57.42 R2409.2
  L2SGND w0.089: v1(41.63,80.47) 37.87,76.71 35.36,76.71 34.92,76.27 28.1,76.27 27.31,77.06 23.13,77.06 22.73,77.47 21.75,77.47 19.42,75.15 19.42,74.11 18.01,72.7 18.01,68.5 17.04,67.53 16.66,67.53 15.31,66.17 15.31,65.82 15.77,65.36 16.36,65.36 17.24,64.48 17.24,59.74 16.21,58.71 v1(16.21,58.68)
  L4 w0.089: v1(41.63,80.47) 42.1,80.93 42.1,90.7 42.62,91.22 46.55,91.22 46.99,91.66 46.99,93.28 46.49,93.78 46.49,102.46 51.56,107.54 v1(51.56,109.06)
  BOTTOM w0.089: v2(42.19,80.71) 41.95,80.47 v1(41.63,80.47)
AUX_ON: length 96.5
  TOP w0.102: U2401.3 22.99,71.69 22.74,71.94 v1(22.72,71.94) 21.95,71.94 v2(21.9,71.88)
  L3 w0.102: v1(22.72,71.94) 23.82,71.94 25.83,73.94 37.1,73.94 40.55,77.4 40.55,91.84 42.08,93.37 44.36,93.37 45.85,91.87 v1(45.93,91.87) ; v1(44.91,118.67) 44.91,120.14 45.85,121.08 45.85,123.47 49.18,126.8 53.54,126.8 55.76,124.59 60.67,124.59 61.19,125.11 v1(61.27,125.11)
  L4 w0.102: v1(45.93,91.87) 45.89,91.87 44.63,93.14 44.63,96.88 44.05,97.46 44.05,101.07 45.03,102.05 45.03,106.54 45.61,107.12 45.61,110.88 46.75,112.03 46.75,116.83 v1(44.91,118.67)
  BOTTOM w0.102: R2466.2 60.84,125.54 v1(61.27,125.11)
BAT1_LED#: length 23.5
  TOP w0.089: 22.38,74.3 22.3,74.22 21.89,74.22 21.76,74.09 21.76,73.29 21.89,73.16 RN2405.1
  TOP w0.102: v1(21.54,76.13) 21.36,75.95 v2(21.36,75.29) 21.52,75.13 22.13,75.13 22.43,74.83 22.43,74.35 22.38,74.3 ; U2401.106 33.95,72.82 v1(33.81,72.67) ; v1(22.05,72.48) 22.22,72.64 RN2405.1
  L2SGND w0.102: v1(33.81,72.67) 33.41,72.67 32.77,72.04 31.71,72.04 31.39,72.36 31.39,72.98 31.03,73.34 22.91,73.34 22.04,72.48 v1(22.05,72.48)
  BOTTOM w0.102: R2452.1 22.57,77.87 Q2416.4 21.95,77.49 21.54,77.08 v1(21.54,76.13)
BAT2_LED#: length 7.2
  TOP w0.102: RN2405.2 22.68,73.81 22.81,73.94 22.81,74.46 v1(22.92,74.57) 23.29,74.2 23.29,73.55 23.73,73.11 U2401.1
  BOTTOM w0.102: v1(22.92,74.57) 23.21,74.28 R2453.2 23.57,74.33 23.57,75.04 23.88,75.34 Q2416.1 24.22,75.84 v2(24.7,75.36)
BAT_AMBER: length 11.3
  L4 w0.203: v1(10.4,130.67) 10.06,130.67 9.34,131.39 3.96,131.39 3.46,131.89 2.48,131.89 2.35,132.03 v1(2.28,132.03)
  BOTTOM w0.203: LED1.1 2.7,132.42 2.38,132.09 2.35,132.09 v1(2.28,132.03) ; R6407.2 11.23,130.11 10.67,130.67 v1(10.4,130.67)
BAT_WHITE: length 15.6
  L4 w0.203: v1(11.33,130.75) 10.76,130.18 10.08,130.18 9.17,131.09 3.79,131.09 3.33,131.55 2.48,131.55 2.33,131.4 v1(2.33,131.33)
  BOTTOM w0.203: v1(2.33,131.33) 3.68,132.69 3.68,134.17 3.35,134.5 LED1.2 ; v1(11.33,130.75) 11.97,130.11 R6406.2
BATT_WHITE_LED#: length 54
  L3 w0.102: v1(25.13,74.96) 23.46,73.29 21.98,73.29 21.43,72.75 21.43,72.12 21.43,72.12 21.43,71.39 19.62,69.58 19.62,66.19 19.6,66.18 19.03,65.61 18.84,65.61 17.58,64.34 17.58,64.33 17.49,64.25 17.49,62.34 17.31,62.16 17.31,60.83 17.71,60.42 17.71,59.64 17.68,59.61 17.68,58.12 18.11,57.68 18.11,57.08 18.11,56.93 18.11,52.09 17.98,51.96 17.98,51.84 17.52,51.37 17.52,46.42 17.52,46.09 17.52,44.15 17.52,44.15 17.52,44.03 18.35,43.2 18.35,41.16 19.19,40.31 19.19,40.03 19.64,39.58 19.99,39.58 20.06,39.65 20.47,39.65 20.78,39.34 20.78,38.41 20.05,37.68 v1(20.05,37.16)
  BOTTOM w0.102: 25.68,76.26 R6409.2 25.36,76.65 Q6406.4 ; 25.68,76.26 25.17,75.74 24.71,75.74 24.49,75.96 24.49,76.29 23.88,76.91 Q2416.6 ; 25.68,76.26 25.68,75.63 25.13,75.07 v1(25.13,74.96) 25.11,74.94 25.09,74.94 24.43,74.28 R2453.1 ; Q6401.D 21.09,37.12 v2(20.85,37.35) 20.24,37.35 v1(20.05,37.16)
BATT_WHITE_LED#_Q: length 71
  L3 w0.102: v1(16.05,111.46) 16.6,112.02 19.05,112.02 19.84,111.23 22.06,111.23 25.75,107.54 25.75,103.56 27.68,101.63 27.68,97.35 27.65,97.33 27.65,95.24 28.16,94.73 28.72,94.73 29.58,93.87 35.42,93.87 35.75,94.2 37.98,94.2 39.94,92.23 39.94,77.63 38.09,75.78 36.26,75.78 35.96,75.48 31.57,75.48 31.51,75.42 29.53,75.42 29.19,75.77 28.22,75.77 28.18,75.8 27.71,75.8 v1(27.16,76.35)
  BOTTOM w0.102: v1(16.05,111.46) 15.78,111.19 Q6404.B ; v2(27.77,76.56) 27.56,76.35 v1(27.16,76.35) 27.08,76.35 27.05,76.33 R6409.1 26.55,76.88 Q6406.3
BEEP: length 37.6
  TOP w0.203: U2401.45 29.96,57.49 29.91,57.45 29.91,56.18 29.94,56.15 29.94,55.5 29.92,55.47 29.92,55.3 28.87,54.25 28.87,54.14 28.84,54.11 28.84,53.97 28.64,53.77 v1(27.96,53.77)
  TOP w0.254: R2739.1 21.82,26.54 21.82,27.37 v2(22.02,27.58) 22.98,28.53 23.56,28.53 v1(25.86,30.84)
  L3 w0.254: v1(25.86,30.84) 25.92,30.9 25.92,36.97 24.8,38.09 24.8,39.52 24.83,39.55 24.83,42.07 24.56,42.34 24.56,43.86 24.59,43.89 24.59,48.26 25.87,49.54 25.87,49.57 26.27,49.97 26.27,52.08 v1(27.96,53.77)
BKLT_CTRL: length 122.8
  TOP w0.102: v1(220.01,60.83) 220.04,60.83 220.7,60.17 220.7,58.6 221.85,57.46 221.85,54.76 225.78,50.83 225.78,46.61 226.01,46.38 226.01,43.28 226.06,43.23 226.06,39.88 v2(225,38.81) v1(224.44,38.81) ; v1(220.04,37.57) 220.24,37.76 221.25,37.76 221.36,37.65 221.36,36.91 221.52,36.75 RN5502.3 222.4,36.75 222.54,36.89 RN5503.2
  L4 w0.102: v1(220.04,37.57) 221.41,37.57 222.71,38.86 224.39,38.86 v1(224.44,38.81) ; v1(164.06,71.71) 164.66,71.71 165.26,71.11 165.26,70.71 170.94,65.03 171.48,65.03 174.67,61.83 174.86,61.83 175.08,61.62 176.23,61.62 180.24,57.61 188.19,57.61 190,59.42 204.45,59.42 206.13,61.09 210.78,61.09 211.38,61.7 214.3,61.7 214.84,61.16 214.84,60.65 214.79,60.6 v1(214.79,60.49)
  BOTTOM w0.102: v1(220.01,60.83) 219.84,61.01 217.4,61.01 216.89,61.52 215.71,61.52 214.79,60.6 v1(214.79,60.49) ; D5503.3 181.7,69.8 180.11,69.8 179.89,70.03 178.59,70.03 177.68,70.94 176.61,70.94 173.84,73.71 164.21,73.71 163.15,72.65 163.15,71.83 163.48,71.5 163.86,71.5 v1(164.06,71.71)
BKLT_IN_EC: length 3
  TOP w0.102: R2435.1 40.54,62.06 40.54,61.22 40.22,60.89 U2401.67
BLON_OUT_C: length 13.2
  TOP w0.102: RN5503.6 224.66,36.39 v1(224.76,36.49) ; v1(219.76,42.55) 219.76,43.04 219.45,43.36 218.07,43.36 AFTP5518.1
  L3 w0.102: v1(219.76,42.55) 220.13,42.55 223.5,39.18 223.5,38.66 224.76,37.4 v1(224.76,36.49)
  BOTTOM w0.102: LCD1.30 219.63,42.55 219.64,42.55 v1(219.76,42.55)
BLUETOOTH_EN: length 200.8
  TOP w0.089: v1(41.58,81.1) 41.87,81.1 42.93,80.04 43.82,80.04 44.38,79.48 44.38,78.01 46.74,75.65 46.74,74.5 46.94,74.3 49.54,74.3 v1(50.14,73.69) ; v1(43.16,102.24) 41.97,103.42 AFTP6112.1 41.97,104 R6108.2
  L3 w0.089: v1(41.58,81.1) 41.86,81.1 42.06,81.3 42.06,81.88 41.33,82.6 41.33,91.34 42.32,92.33 42.67,92.33 v1(43.11,91.89)
  L4 w0.089: v1(155.31,72.2) 155.12,72.01 154.28,72.01 149.31,76.98 149.31,78.91 148.73,79.49 148.73,81.83 146.38,84.18 146.38,84.6 146.38,84.6 146.38,85.47 145.02,86.83 144.84,86.83 144.47,87.2 144.46,87.2 144.11,87.55 143.93,87.55 138.91,92.57 138.91,92.92 138.91,93.21 134.58,97.55 133.59,97.55 132.84,98.31 132.06,98.31 131.17,99.2 131.17,100.09 130.63,100.63 129.28,100.63 127.38,98.73 127.1,98.73 v1(126.72,98.35) ; v1(43.11,91.89) 43.11,92.48 42.77,92.82 42.77,94.99 43.16,95.38 v1(43.16,102.24)
  BOTTOM w0.076: 122.94,98.5 122.87,98.58 122.87,98.58 122.72,98.73 122.42,98.73 122.39,98.7 122.34,98.67 122.14,98.57 CPU1.CP14
  BOTTOM w0.089: v1(126.72,98.35) 126.52,98.55 125.84,98.55 125.56,98.83 125.33,98.83 125.31,98.81 125.18,98.81 125.17,98.8 124.84,98.8 124.83,98.81 124.77,98.81 124.77,98.81 124.7,98.81 124.67,98.84 123.77,98.84 123.43,98.5 122.94,98.5 ; v1(50.14,73.69) 50.13,73.68 50.13,73.53 50.64,73.03 55.3,73.03 56.32,74.05 75.61,74.05 77.37,72.29 123.29,72.29 125.4,70.18 152.24,70.18 152.58,69.83 152.94,69.83 v1(155.31,72.2)
BLUETOOTH_EN_R: length 3.3
  TOP w0.102: v1(44.2,103.54) 44.12,103.62 R6115.2 44.12,104.44 R6108.1
  BOTTOM w0.102: v1(44.2,103.54) WLAN1.54
BMON22: length 263.7
  TOP w0.089: R2483.1 32.29,77.45 v1(32.67,77.83) ; v1(205.16,44.79) 205.22,44.86 206.45,44.86 206.66,44.65 PR4493.2 ; v1(28.61,30.9) 28.61,30.84 v2(28.11,30.35)
  L2SGND w0.089: v1(28.61,30.9) 27.97,30.26 26.97,30.26 26.59,30.64 26.59,31.7 25.22,33.07 25.22,35.33 25.68,35.79 25.68,36.7 25.37,37.01 24.77,37.01 24.44,37.34 22.51,37.34 21.38,38.47 21.38,39.15 21.1,39.43 21.09,39.43 20.84,39.68 20.84,39.69 20.55,39.98 20.55,41.77 19.98,42.34 19.98,43.47 17.99,45.46 17.99,50.28 17.4,50.88 17.4,57.22 16.42,58.2 16.03,58.2 15.78,58.45 15.78,58.83 15.55,59.06 15.55,59.99 16.21,60.66 16.21,62.24 15.54,62.91 15.54,64.73 15.14,65.13 15.14,67.64 15.75,68.25 16.29,68.25 v1(16.37,68.33)
  L3 w0.089: v1(205.16,44.79) 204.85,44.48 199.98,44.48 199.12,43.62 198.11,43.62 197.47,42.98 196.22,42.98 195.69,42.45 192.29,42.45 191.4,41.57 190.91,41.57 190.66,41.82 190.66,42.17 190.47,42.36 189.77,42.36 188.46,41.05 188.3,40.89 184.28,40.89 182.29,38.9 173.03,38.9 171.74,40.19 168.85,40.19 168.19,39.53 154.27,39.53 153.95,39.21 128.08,39.21 126.67,40.63 126.67,41.26 125.84,42.08 123.38,42.08 121.21,44.25 108.94,44.25 107.64,42.96 106.38,42.96 105.76,42.34 102.55,42.34 102.2,41.98 100.09,41.98 97.63,39.52 85.09,39.52 84.84,39.26 75.38,39.26 71.32,35.21 71.28,35.21 71.26,35.19 62.73,35.19 61.34,33.8 58.41,33.8 56.96,32.35 32.61,32.35 32.15,31.89 29.45,31.89 28.61,31.05 v1(28.61,30.9)
  L4 w0.089: v1(16.37,68.33) 16.44,68.33 16.84,68.73 16.84,69.86 17.03,70.06 17.03,70.08 17.36,70.4 17.36,73.09 22.36,78.09 22.66,78.09 28,78.09 28.05,78.09 28.83,77.3 32.14,77.3 v1(32.67,77.83)
BOARD_ID: length 4.7
  TOP w0.102: U2401.111 31.96,73.92 31.96,74.61 32.16,74.8 32.16,74.86 32.16,74.87 32.16,75.22 32.16,75.23 v2(32.16,75.52) 32.37,75.73 32.58,75.73 33.07,76.21 C2408.2 33.84,76.38 R2444.1 34.62,76.35 R2443.2
BOARD_ID1: length 15.1
  L4 w0.102: v1(117.73,99.06) 118.21,98.58 118.52,98.58 118.56,98.54 118.63,98.54 118.64,98.53 118.77,98.53 118.82,98.48 119.32,98.48 119.33,98.49 120,98.49 120.04,98.53 121.23,98.53 121.24,98.54 123.02,98.54 123.99,97.58 124.42,97.58 125.2,96.8 128.42,96.8 129.04,97.42 v1(129.04,97.72)
  BOTTOM w0.102: CPU1.CG12 118.01,99.65 117.95,99.49 117.79,99.11 117.78,99.08 v1(117.73,99.06) ; R2010.2 128.65,98.4 R2009.1 128.58,98.17 v1(129.04,97.72)
BOT_MUX_N: length 33.5
  TOP w0.127: EL7106.2 36.56,115.65 36.36,115.44 36.36,114.35 36.57,114.14 36.57,113.69 ; v2(36.73,113.69) 36.57,113.69 ; 36.57,113.69 36.57,113.68 36.33,113.44 36.33,113.22 v1(36.55,113.01)
  L3 w0.114: v1(16.62,119.46) 16.29,119.13 16.29,118.95 16.72,118.51 17.45,118.51 17.92,118.99 22.29,118.99 22.42,118.86 24.76,116.52 24.76,115.94 25.19,115.52 27.03,115.52 27.67,116.15 27.67,116.83 v1(27.57,116.93)
  BOTTOM w0.127: v1(16.62,119.46) 16.43,119.65 16.43,119.68 16.42,119.69 16.42,119.97 16.04,120.35 15.2,120.35 14.97,120.58 14.56,120.58 R7334.2 ; v1(36.55,113.01) 36.34,113.22 36.34,113.94 35.97,114.31 32.62,114.31 29.27,117.67 28.27,117.67 27.57,116.96 v1(27.57,116.93)
BOT_MUX_N_L: length 3.7
  TOP w0.127: 36.46,118.48 36.62,118.33 36.62,117.72 36.56,117.66 EL7106.1 ; 36.46,118.48 v2(36.6,118.62) ; 36.46,118.48 36.35,118.59 35.18,118.59 34.8,118.79 U7102.9
BOT_MUX_N_R: length 11.9
  TOP w0.127: R7333.1 10.61,122.11 v1(10.4,121.91)
  L3 w0.114: v1(10.4,121.91) 10.57,121.74 10.78,121.74 10.96,121.91 10.96,122.54 10.29,123.21 9.25,123.21 8.59,123.87 7.37,123.87 7.24,123.74 7.24,123.43 7.11,123.3 JUSB1.B7
  BOTTOM w0.127: R7334.1 13.14,120.55 12.96,120.55 12.55,120.96 11.41,120.96 11.28,121.08 ED7313.2 10.8,121.51 v1(10.4,121.91) v2(9.86,121.62)
BOT_MUX_P: length 32.8
  TOP w0.127: v2(35.99,114.89) 36.12,114.89 ; 36.12,114.89 36.12,114.25 36.33,114.04 36.33,113.78 36.09,113.54 36.09,113.19 v1(35.91,113.01) ; 36.12,114.89 36.12,115.44 35.88,115.68 EL7106.3
  L3 w0.114: v1(28.21,116.9) 27.89,116.59 27.89,116.06 27.12,115.29 25.09,115.29 24.53,115.85 24.53,116.43 22.19,118.76 18.02,118.76 17.54,118.29 16.63,118.29 16.07,118.85 v1(15.98,119.5)
  BOTTOM w0.127: v1(28.21,116.9) 28.21,117.26 28.37,117.43 29.17,117.43 32.52,114.07 35.87,114.07 36.1,113.84 36.1,113.19 v1(35.91,113.01) ; R7335.2 14.56,120.34 14.87,120.34 15.1,120.11 15.94,120.11 16.18,119.87 16.18,119.69 v1(15.98,119.5)
BOT_MUX_P_L: length 3.5
  TOP w0.127: 35.44,118.35 35.08,118.35 35.04,118.39 U7102.8 ; 35.44,118.35 v2(35.44,118.21) ; 35.44,118.35 36.25,118.35 36.37,118.23 36.37,117.82 36.24,117.69 36.09,117.69 35.88,117.48 EL7106.4
BOT_MUX_P_R: length 12.5
  TOP w0.127: v1(10.35,121.22) 10.39,121.22 10.5,121.33 R7332.1
  L3 w0.114: v1(10.35,121.22) 10.39,121.22 10.68,121.51 10.88,121.51 11.19,121.82 11.19,122.64 10.38,123.44 9.34,123.44 8.69,124.1 JUSB1.B6
  BOTTOM w0.127: v2(10.29,120.47) v1(10.35,121.22) 10.41,121.22 10.47,121.15 ED7314.2 11.8,120.71 12.45,120.71 12.86,120.3 13.21,120.3 R7335.1
BREATH_LED#: length 11.9
  TOP w0.102: U2401.70 39.67,62.09 39.8,62.23 39.8,64.81 40.94,65.94 41.41,65.94 41.94,66.47 41.94,66.9 42.42,67.38 43.08,67.38 43.98,66.47 44.58,66.47 R2467.1 45.57,66.5 U2402.1
BT+: length 35.9
  TOP w0.305: AFTP4312.1 144.4,36.5 v1(143.64,36.5)
  L4 w0.305: v1(200.71,43.21) 200.79,43.13 200.79,42.62 199.65,41.48 197.92,41.48 197.51,41.07 195.33,41.07 194.87,41.53 194.21,41.53 193.7,41.02 192.93,41.02 192.78,40.87 192.01,40.87 191.57,40.42 191.57,40.1 188.32,36.86 188.32,35.49 186.03,33.2 182.83,33.2 181.82,32.18 v1(173.38,32.18)
  BOTTOM w0.508: v1(200.71,43.21) 200.65,43.27 200.65,44.18 200.6,44.23 PR4478.2
  vias: v1(151.49,33.63) v3(143.01,31.9) v3(143.92,31.9) v3(171.07,31.57) v3(171.99,31.57)
BT_PCMFRM_RSTN: length 6.2
  TOP w0.102: R6122.1 35.24,105.12 35.5,105.39 v2(35.5,105.8) 35.69,105.99 R1913.1 35.37,107.06 v1(34.34,107.06)
  BOTTOM w0.102: WLAN1.10 33.2,105.92 v1(34.34,107.06)
BT_PCMOUT_CLKREQ0: length 9.7
  TOP w0.102: R1912.1 35.27,107.56 34.56,108.27 33.57,108.27 32.81,107.51 32.81,105.13 v2(32.98,104.97) 33.86,104.97 R6121.1 34.34,105.52 v1(34.34,106.25)
  BOTTOM w0.102: v1(34.34,106.25) 34.2,106.11 WLAN1.14
BT_PWR_IN+: length 203.9
  TOP w0.102: v2(158.03,146.11) 158.14,146.23 v1(158.14,146.71) ; v1(191.11,36.22) 190.99,36.35 190.96,36.35 190.58,36.72 189.64,36.72 189.39,36.48 187.78,36.48 R4402.1
  L4 w0.089: v1(158.14,146.71) 158.89,147.46 162.89,147.46 163.79,146.56 163.79,141.49 162.21,139.9 162.21,130.52 164.42,128.31 164.42,119.15 165.25,118.32 165.25,110.4 164.69,109.84 164.69,109.5 163.99,108.8 163.03,108.8 158.11,103.88 158.11,97.97 167.04,89.03 167.04,81.64 167.04,81.53 179.05,69.53 179.06,69.53 179.71,68.87 179.71,67.89 184.63,62.97 186.98,62.97 189.58,65.57 209.69,65.57 210.02,65.25 217.85,65.25 221.48,61.61 221.48,44.93 220.73,44.18 219.83,44.18 216.84,41.19 215.81,41.19 214.05,39.43 213.79,39.43 211.94,37.58 209.45,37.58 207.72,35.85 199.24,35.85 198.08,34.68 192.27,34.68 191.11,35.84 v1(191.11,36.22)
  BOTTOM w0.102: PMBD1.20 158.17,146.69 v1(158.14,146.71)
BT_PWR_IN-: length 201.8
  TOP w0.102: R4401.1 187.66,37.23 187.66,36.93 187.91,36.68 189.31,36.68 189.61,36.98 v2(190.99,36.98) 191.14,36.98 191.43,37.28 191.79,37.28 191.8,37.27 191.81,37.27 192.19,36.88 192.26,36.88 v1(192.28,36.86)
  L4 w0.102: v1(158.79,146.68) 159.37,147.27 162.81,147.27 163.6,146.48 163.6,141.61 161.99,140.01 161.99,130.46 164.21,128.24 164.21,119.08 165.05,118.24 165.05,110.48 164.49,109.92 164.49,109.58 163.91,109 162.94,109 157.91,103.96 157.91,97.89 166.84,88.95 166.84,81.56 166.84,81.56 166.84,81.45 178.97,69.33 178.98,69.33 179.52,68.79 179.52,67.81 184.55,62.78 187.09,62.78 189.68,65.37 209.61,65.37 209.93,65.05 217.77,65.05 221.29,61.53 221.29,45.02 220.65,44.38 219.75,44.38 217.48,42.11 216.4,42.11 213.92,39.63 213.71,39.63 211.86,37.78 209.37,37.78 207.79,36.2 199.17,36.2 198.89,35.92 195.96,35.92 195.81,36.07 192.76,36.07 192.28,36.55 v1(192.28,36.86)
  BOTTOM w0.102: PMBD1.18 158.57,146.46 v1(158.79,146.68)
BT_USB20_CON_N: length 8.4
  TOP w0.102: 29.86,97.63 AFTP6111.1
  TOP w0.127: R6105.1 30.27,98.03 29.73,97.5 29.73,95.56 30.05,95.25 30.63,95.25 v1(30.77,95.1)
  BOTTOM w0.127: v1(30.77,95.1) 31.4,95.1 31.95,95.65 WLAN1.5
BT_USB20_CON_P: length 8.1
  TOP w0.127: v1(30.77,95.73) 30.53,95.49 30.15,95.49 29.97,95.66 29.97,95.86 29.98,95.86 ; R6104.1 31.23,97.13 30.79,97.13 30.66,97.26 30.66,97.64 30.53,97.76 30.34,97.76 29.97,97.4 29.97,95.86 29.98,95.86 ; 29.98,95.86 AFTP6114.1
  BOTTOM w0.127: v1(30.77,95.73) 31.17,95.34 31.3,95.34 31.71,95.75 31.71,96.34 31.45,96.6 WLAN1.3
