# Allegro board 17938-1.1228WZS1107.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_ALERT_N: length 59.4
  TOP w0.089: v2(58.51,44.39) 59.03,44.39 v1(59.08,44.35)
  L4 w0.089: v1(86.79,80.75) 85.55,80.75 85.02,80.21 85.02,76.35 84.05,75.38 83.85,75.38 81.78,73.32 78.05,73.32
  L4 w0.203: 78.05,73.32 72.92,68.19 69.74,68.19 58.44,56.88 58.44,44.98 v1(59.08,44.35)
  BOTTOM w0.076: v1(86.79,80.75) 87.06,80.75 87.19,80.87 87.19,80.94 88.19,81.94 88.19,83.85 CPU1.W37
  BOTTOM w0.216: DM1.116 v1(59.08,44.35)
M_A_BA0: length 58.7
  L4 w0.089: v1(88.06,86.6) 88.06,85.71 91.95,81.82 91.95,80.36 92.14,80.18 92.14,79.54 92.14,79.53 92.14,78.17 92.45,77.86 92.45,74.12 90.18,71.85
  L4 w0.203: v1(69.08,45.08) 69.01,45.15 68.2,45.97 68.2,50.59 75.42,57.81 78.99,57.81 90.18,69 90.18,71.85
  BOTTOM w0.076: v1(88.06,86.6) 88.07,86.62 88.1,86.62 CPU1.W32
  BOTTOM w0.216: DM1.150 69.58,44.59 v1(69.08,45.08)
M_A_BA1: length 60.6
  L4 w0.089: v1(89.76,88.02) 89.21,87.46 89.21,86.35 90.95,84.6 91.86,83.81 93.07,82.61 93.09,82.54 93.15,78.03 93.22,77.42 93.22,73.64 91.09,71.51
  L4 w0.203: v1(69.16,47.07) 69.07,47.17 69.07,50.24 72.12,53.29 72.19,53.29 75.8,56.9 79.37,56.9 91.09,68.62 91.09,71.51
  BOTTOM w0.089: CPU1.AB31 89.84,88.02 v1(89.76,88.02)
  BOTTOM w0.216: DM1.145 68.33,47.08 68.47,46.94 69.03,46.94 v1(69.16,47.07)
M_A_BG0: length 61.7
  TOP w0.216: v1(57.85,47.73) v2(57.84,47.17)
  L4 w0.076: 84.53,78.44 84.53,80.6 85.93,81.99 v1(87.18,81.99)
  L4 w0.089: 79.89,73.95 81.58,73.95 83.71,76.08 83.92,76.08 84.53,76.7 84.53,78.44
  L4 w0.203: v1(57.85,47.73) 57.51,47.73 57.17,48.07 57.17,48.42 56.53,49.06 56.53,56.41 69.23,69.11 72.53,69.11 77.37,73.95 79.89,73.95
  BOTTOM w0.076: v1(87.18,81.99) 87.36,81.99 87.86,82.48 87.86,84.01 87.92,84.19 87.92,84.43 87.9,84.49 87.9,84.78 87.92,84.84 87.92,85.36 CPU1.V34
  BOTTOM w0.216: v1(57.85,47.73) 58.37,47.73 58.51,47.88 58.51,48.18 58.83,48.5 DM1.115
M_A_BG1: length 62.5
  TOP w0.216: v1(57.83,49) v2(58.39,48.92)
  L4 w0.089: v1(86.95,81.38) 86.74,81.59 85.94,81.59 84.84,80.49 84.84,76.51 84.83,76.51 84.01,75.69 83.73,75.69 81.65,73.61
  L4 w0.203: v1(57.83,49) 57.39,49 57.03,49.36 57.03,50.55 57.24,50.76 57.74,50.76 57.95,50.96 57.95,51.37 57.74,51.57 57.24,51.57 57.03,51.77 57.03,52.18 57.24,52.38 57.74,52.38 57.95,52.59 57.95,52.99 57.74,53.2 57.24,53.2 57.03,53.4 57.03,53.81 57.24,54.01 57.74,54.01 57.95,54.21 57.95,54.62 57.74,54.82 57.24,54.82 57.03,55.02 57.03,56.19 69.49,68.66 72.72,68.66 77.67,73.61 81.65,73.61
  BOTTOM w0.076: v1(86.95,81.38) 87.4,81.38 88.02,82.01 88.02,83.98 88.09,84.16 88.09,84.46 88.06,84.52 88.06,84.75 88.1,84.84 88.1,84.85 88.22,85.19 CPU1.W35
  BOTTOM w0.216: v1(57.83,49) 58.2,49 58.33,49.13 DM1.113
M_A_CKE0: length 64.1
  TOP w0.216: v1(56.26,47) v2(56.22,47.57)
  L4 w0.089: v1(83.97,77.42) 81.11,74.56 76.68,74.56
  L4 w0.203: v1(56.26,47) 55.39,47.88 55.39,51.56 55.18,51.76 54.9,51.76 54.7,51.97 54.7,52.37 54.9,52.57 55.18,52.57 55.39,52.78 55.39,53.18 55.18,53.39 54.9,53.39 54.7,53.59 54.7,54 54.9,54.2 55.18,54.2 55.39,54.4 55.39,54.81 55.18,55.01 54.9,55.01 54.7,55.22 54.7,55.62 54.9,55.83 55.18,55.83 55.39,56.03 55.39,56.72 68.7,70.03 72.15,70.03 76.68,74.56
  BOTTOM w0.076: CPU1.U36 87.02,84.41 87.24,84.19 87.27,84.1 87.27,83.46 86.67,82.86 86.67,82.29 86.19,81.82 86.19,81.45
  BOTTOM w0.14: 86.19,81.45 86.19,81.44 85.48,80.74 85.48,78.93 v1(83.97,77.42)
  BOTTOM w0.216: v1(56.26,47) 56.82,47 57.33,47.5 DM1.109
M_A_CKE1: length 62.7
  TOP w0.216: v1(57.58,44.35) v2(57.18,43.95)
  L4 w0.089: v1(84.13,78.68) 84.03,78.68 83.24,77.89 83.24,77.38 80.66,74.8 76.28,74.8
  L4 w0.203: 76.28,74.8 71.96,70.48 68.51,70.48 54.16,56.14 54.16,47.28 54.4,47.05 54.4,46.76 54.12,46.49 54.12,46.2 54.41,45.91 54.7,45.91 54.97,46.19 55.55,46.19 57.39,44.35 v1(57.58,44.35)
  BOTTOM w0.076: 85.17,80.7 85.17,81.03 86.5,82.36 86.5,82.93 86.79,83.22 86.79,83.22 87.02,83.45 87.02,83.98 CPU1.U37
  BOTTOM w0.216: v1(57.58,44.35) DM1.110 ; v1(84.13,78.68) 85.17,79.73 85.17,80.7
M_A_CLK0: length 60
  L4 w0.089: 89.33,71.63 89.33,71.74 89.27,71.8 89.27,72.26 92.18,75.17 92.18,77.8 91.96,78.01 91.96,79.46 91.96,79.47 91.96,79.9 91.71,80.15 91.71,81.81 87.66,85.86 87.66,86.96 87.47,87.15 87.27,87.15 v1(87.06,87.36)
  L4 w0.165: 89.33,71.63 89.33,69.35 78.64,58.66 75.07,58.66 67.78,51.37 67.78,48.4 v1(67.01,47.62)
  BOTTOM w0.076: CPU1.V31 87.09,87.38 87.07,87.36 v1(87.06,87.36)
  BOTTOM w0.216: DM1.137 64.33,50.09 64.76,49.66 64.76,49.21 66.34,47.62 v1(67.01,47.62)
M_A_CLK1: length 59.6
  L4 w0.089: v1(86.12,87.86) 85.81,87.54 85.73,87.46 85.73,87.38 85.72,87.37 85.72,87.04 85.73,87.04 85.73,86.94 86.07,86.6 86.07,86.26 85.82,86.01 85.82,85.25 89.33,81.74 89.33,74.89 86.11,71.67 86.11,71.14 86.06,71.09 86.06,70.98
  L4 w0.165: v1(64.95,45.63) 65.61,46.29 65.61,52.96 74.09,61.44 77.59,61.44 86.06,69.9 86.06,70.6 86.06,70.98
  BOTTOM w0.076: v1(86.12,87.86) 86.14,87.86 CPU1.T31
  BOTTOM w0.216: DM1.138 64.58,45.25 v1(64.95,45.63)
M_A_CLK#0: length 60.1
  L4 w0.089: 89.08,71.63 89.08,72.34 91.98,75.24 91.98,77.72 91.77,77.93 91.77,79.38 91.77,79.39 91.77,79.82 91.52,80.07 91.52,81.73 87.47,85.78 87.47,86.88 87.39,86.96 87.23,86.96 87.02,86.96 86.88,86.82 86.88,86.7 v1(87.04,86.54)
  L4 w0.165: v1(66.93,48.5) 67.11,48.31 67.34,48.31 67.53,48.51 67.53,51.48 74.96,58.91 78.53,58.91 89.08,69.46 89.08,71.63
  BOTTOM w0.102: v1(87.04,86.54) 87.04,86.52 87.2,86.37 87.35,86.37 87.65,86.67 87.65,86.82 CPU1.V32
  BOTTOM w0.216: DM1.139 64.83,50.07 65.1,49.8 65.1,49.35 66.48,47.97 66.63,47.97 66.93,48.27 v1(66.93,48.5)
M_A_CLK#1: length 59.6
  L4 w0.089: v1(86.12,87.21) 86.12,86.82 86.26,86.68 86.26,86.18 86.01,85.93 86.01,85.33 89.52,81.82 89.52,74.97 89.52,74.81 86.3,71.59 86.3,71.01 86.31,70.99 86.31,70.98
  L4 w0.165: 86.31,70.98 86.31,70.71 86.31,69.8 77.7,61.18 74.2,61.18 65.87,52.85 65.87,46.18 65.49,45.81 65.49,45.35 v1(65.13,44.99)
  BOTTOM w0.089: v1(86.12,87.21) 86.12,86.69 86.22,86.59 86.49,86.59 86.58,86.68 CPU1.T32
  BOTTOM w0.216: DM1.140 65.08,43.8 64.92,43.96 64.92,44.78 v1(65.13,44.99)
M_A_CS#0: length 63.5
  L4 w0.089: 94.2,70.96 94.2,71.31 94.2,71.31 94.2,71.44 95.43,72.67 95.43,76.48 95.73,76.78 95.73,83.01 92.51,86.24 v1(92.51,86.75)
  L4 w0.203: v1(71.13,47.66) 71.21,47.66 71.89,48.34 71.89,49.5 73.14,50.76 73.91,50.76 77.1,53.94 82.99,53.94 84.99,55.94 85.28,55.94 85.65,55.58 85.93,55.58 86.22,55.86 86.22,56.15 85.85,56.52 85.85,56.81 86.14,57.09 86.43,57.09 86.79,56.73 87.08,56.73 87.37,57.01 87.37,57.3 87,57.67 87,57.95 87.29,58.24 87.58,58.24 87.94,57.88 88.23,57.88 88.52,58.16 88.52,58.45 88.15,58.82 88.15,59.1 94.2,65.15 94.2,70.96
  BOTTOM w0.089: CPU1.AE32 v1(92.51,86.75)
  BOTTOM w0.216: DM1.149 69.33,49.23 70.31,48.24 70.49,48.24 71.07,47.66 v1(71.13,47.66)
M_A_CS#1: length 64.4
  L4 w0.089: 95.11,71.6 95.99,72.49 95.99,76.18 96.35,76.53 96.35,82.32 96.19,82.48 96.19,83.08 95.98,83.29 95.98,84.2 93.43,86.75 v1(93.42,86.75)
  L4 w0.203: 95.11,71.6 95.11,63.41 83.82,52.11 83.36,52.11 83.16,52.32 83.16,52.81 82.96,53.01 82.55,53.01 82.35,52.81 82.35,52.32 82.14,52.11 81.74,52.11 81.53,52.32 81.53,52.81 81.33,53.01 80.92,53.01 80.72,52.81 80.72,52.32 80.52,52.11 80.11,52.11 79.91,52.32 79.91,52.81 79.7,53.01 79.3,53.01 79.09,52.81 79.09,52.32 78.89,52.11 76.69,52.11 73.79,49.22 73.79,48.67 73.54,48.42 73.54,47.23 73.4,47.09 v1(72.96,47.09)
  BOTTOM w0.089: CPU1.AF32 v1(93.42,86.75)
  BOTTOM w0.216: DM1.157 71.33,49.74 71.35,49.71 71.35,48.99 71.39,48.95 71.39,48.82 71.65,48.56 71.65,48.23 71.66,48.23 71.66,48.06 72.63,47.09 v1(72.96,47.09)
M_A_DIMA_ODT0: length 64.6
  L4 w0.089: v1(92.51,87.4) 92.11,87 92.11,86.39 94.84,83.58 94.84,81.31 94.86,79.14 94.91,77.38 94.91,77.19 95.13,76.97 95.13,72.72 93.73,71.33 93.73,71.29 93.69,71.25
  L4 w0.203: v1(71.12,48.37) 71.12,48.6 71.41,48.88 71.41,49.59 72.97,51.16 73.58,51.16 76.84,54.43 82.64,54.43 84.72,56.51 84.72,56.8 84.42,57.1 84.42,57.39 84.71,57.68 85,57.68 85.3,57.37 85.59,57.37 85.87,57.66 85.87,57.95 85.57,58.25 85.57,58.54 85.86,58.83 86.15,58.83 86.45,58.52 86.74,58.52 87.02,58.81 87.02,59.1 86.72,59.4 86.72,59.69 87.01,59.98 87.3,59.98 87.6,59.67 87.89,59.67 88.17,59.96 88.17,60.25 87.87,60.55 87.87,60.84 88.16,61.12 88.45,61.12 88.75,60.82 89.04,60.82 89.32,61.11 89.32,61.4 89.02,61.7 89.02,61.99 89.31,62.27 89.6,62.27 89.9,61.97 90.18,61.97 90.47,62.26 90.47,62.55 90.17,62.85 90.17,63.14 90.46,63.42 90.74,63.42 91.05,63.12 91.33,63.12 93.69,65.48 93.69,71.25
  BOTTOM w0.089: CPU1.AE31 v1(92.51,87.4)
  BOTTOM w0.216: DM1.155 70.83,49.68 70.93,49.58 70.93,48.56 v1(71.12,48.37)
M_A_DIMA_ODT1: length 63.7
  L4 w0.089: v1(93.42,87.4) 93.02,87 93.02,86 95.99,83.02 95.99,76.58 95.69,76.28 95.69,72.54 94.65,71.5
  L4 w0.203: v1(72.9,48.36) 73.31,48.76 73.31,49.57 77.21,53.47 84.53,53.47 89.63,58.58 89.63,58.86 89.24,59.26 89.24,59.54 89.53,59.83 89.81,59.83 90.21,59.44 90.5,59.44 90.78,59.73 90.78,60.01 90.39,60.41 90.39,60.69 90.68,60.98 90.96,60.98 91.36,60.59 91.65,60.59 91.93,60.87 91.93,61.16 91.54,61.56 91.54,61.84 91.83,62.13 92.11,62.13 92.51,61.74 92.8,61.74 93.08,62.02 93.08,62.31 92.69,62.71 92.69,62.99 92.98,63.28 93.26,63.28 93.66,62.89 93.94,62.89 94.65,63.6 94.65,71.5
  BOTTOM w0.089: CPU1.AF31 v1(93.42,87.4)
  BOTTOM w0.216: DM1.161 72.33,49.84 72.25,49.77 72.25,49.36 72.59,49.02 72.6,49.02 72.6,49.02 72.61,49.02 72.9,48.72 v1(72.9,48.36)
M_A_DQ0: length 69.5
  TOP w0.127: v1(46.99,46.88) v2(47.48,46.51)
  L2SGND w0.114: v1(46.99,46.88) 48.28,46.88 49.21,47.81 49.21,49.06 62.76,62.61 62.76,86.22 67.5,90.96 71.6,90.96 v1(72.03,91.38)
  BOTTOM w0.076: CPU1.A26 77.65,91.19 75.74,91.19 75.34,90.79 72.62,90.79 v1(72.03,91.38)
  BOTTOM w0.216: v1(46.99,46.88) 47.36,46.88 47.58,46.66 DM1.70
M_A_DQ1: length 70.5
  TOP w0.127: v2(72.21,88.72) v1(71.88,88.27)
  L2SGND w0.114: v1(51.19,48.43) 51.92,48.43 58.08,54.58 58.08,54.58 60.42,56.92 60.58,56.92 61.17,56.33 61.33,56.33 61.49,56.49 61.49,56.65 60.9,57.24 60.9,57.4 61.07,57.56 61.23,57.56 61.8,56.99 61.96,56.99 62.13,57.15 62.13,57.31 61.55,57.89 61.55,58.05 61.71,58.21 61.87,58.21 62.54,57.55 62.7,57.55 62.86,57.71 62.86,57.87 62.2,58.53 62.2,58.7 64.59,61.09 64.59,85.46 67.33,88.2 71.81,88.2 v1(71.88,88.27)
  BOTTOM w0.076: 76.16,90.35 76.68,90.35 76.97,90.05 77.99,90.05 78.15,90 78.38,90 78.44,90.02 78.75,90.02 78.88,89.97 79.45,89.97 79.76,89.97 79.89,90.1 CPU1.D26
  BOTTOM w0.089: v1(71.88,88.27) 72.5,88.27 74.28,90.04 75.55,90.04 75.85,90.35 76.16,90.35
  BOTTOM w0.216: v1(51.19,48.43) 50.78,48.83 50.78,49.35 50.83,49.39 DM1.83
M_A_DQ2: length 70.2
  TOP w0.127: v2(76.68,88.5) v1(76.43,89.01)
  L2SGND w0.089: 71.49,86.76 72.97,88.24 75.67,88.24 v1(76.43,89.01)
  L2SGND w0.114: 71.49,86.76 67.35,86.76 65.62,85.03 65.62,59.01 58.22,51.61 58.06,51.61 57.84,51.84 57.67,51.84 57.51,51.67 57.51,51.51 57.73,51.29 57.73,51.13 57.57,50.97 57.41,50.97 56.96,51.42 56.8,51.42 56.64,51.25 56.64,51.09 57.09,50.64 57.09,50.48 56.93,50.32 56.76,50.32 56.31,50.77 56.15,50.77 55.99,50.61 55.99,50.45 56.44,50 56.44,49.83 56.28,49.67 56.12,49.67 55.67,50.12 55.51,50.12 55.34,49.96 55.34,49.8 55.79,49.35 55.79,49.19 v1(51.17,44.57)
  BOTTOM w0.076: CPU1.D28 79.28,89.31 78.34,89.31 78.11,89.18 77.71,89.18 77.52,89.37 76.8,89.37 v1(76.43,89.01)
  BOTTOM w0.216: v1(51.17,44.57) 51.08,44.47 DM1.84
M_A_DQ3: length 69.9
  TOP w0.127: v2(46.49,45.29) v1(46.95,45.61)
  L2SGND w0.114: v1(46.95,45.61) 47.99,46.1 49.55,47.66 49.55,48.91 63.1,62.47 63.1,86.07 67.31,90.28 73.15,90.28 73.79,89.63 v1(73.89,89.06)
  BOTTOM w0.076: 75.91,89.94 76.85,89.94 76.9,89.89 77.96,89.89 78.12,89.83 78.43,89.83 78.44,89.84 78.47,89.85 78.72,89.85 79.14,89.7 CPU1.C28
  BOTTOM w0.089: 75.91,89.94 75.69,89.94 75.62,89.87 74.69,89.87 v1(73.89,89.06)
  BOTTOM w0.216: DM1.66 46.58,44.05 46.58,44.05 46.58,45.07 46.67,45.16 46.67,45.36 46.92,45.61 v1(46.95,45.61)
M_A_DQ4: length 68.5
  TOP w0.127: v1(48.19,48.05) v2(47.72,47.74)
  L2SGND w0.114: v1(48.19,48.05) 48.42,47.81 48.73,47.81 48.87,47.95 48.87,49.2 62.39,62.72 62.39,86.33 67.36,91.3 68.9,91.3 69.25,91.65 70.02,91.8 70.55,91.8 70.66,91.68 70.66,91.38 70.78,91.26 71,91.26 71.12,91.38 71.12,91.68 71.23,91.8 73.03,91.8 v1(73.43,91.4)
  BOTTOM w0.076: v1(73.43,91.4) 73.87,90.96 75.27,90.96 75.67,91.35 77.7,91.35 78.03,91.17 78.38,90.99 CPU1.B26
  BOTTOM w0.216: v1(48.19,48.05) 47.77,48.46 47.77,48.99 47.83,49.04 DM1.71
M_A_DQ5: length 69.5
  TOP w0.127: v2(75.31,91.09) v1(74.81,91.35)
  L2SGND w0.114: v1(74.81,91.35) 74.16,92 70,92 68.09,91.64 67.21,91.64 62.04,86.47 62.04,63.1 47.17,48.22 v1(45.85,48.22)
  BOTTOM w0.076: CPU1.C26 78.75,91.22 78.3,91.22 77.75,91.52 74.98,91.52 v1(74.81,91.35)
  BOTTOM w0.216: v1(45.85,48.22) 45.9,48.22 46.83,49.15 DM1.67
M_A_DQ6: length 69
  TOP w0.127: v2(76.06,89.63) v1(75.81,89.12)
  L2SGND w0.089: 71.4,87.16 71.63,87.16 72.9,88.42 75.11,88.42 v1(75.81,89.12)
  L2SGND w0.114: v1(51.17,45.89) 52.78,47.5 52.78,47.67 52.58,47.87 52.58,48.12 52.78,48.31 52.94,48.31 53.61,47.65 53.77,47.65 53.98,47.85 53.98,48.02 53.31,48.68 53.31,48.84 56.65,52.19 56.81,52.19 57.05,51.95 57.21,51.95 57.37,52.11 57.37,52.28 57.18,52.47 57.18,52.63 57.42,52.87 57.58,52.87 58.2,52.25 58.37,52.25 65.27,59.15 65.27,85.17 67.26,87.16 71.4,87.16
  BOTTOM w0.076: CPU1.B28 78.54,89.6 78.25,89.45 78.07,89.34 77.78,89.34 77.59,89.54 76.35,89.54 76.32,89.51
  BOTTOM w0.089: 76.32,89.51 76.19,89.51 v1(75.81,89.12)
  BOTTOM w0.216: v1(51.17,45.89) 50.99,45.89 50.08,44.97 DM1.80
M_A_DQ7: length 68.9
  TOP w0.127: v2(74.81,89.55) v1(75.16,89.11)
  L2SGND w0.089: 71.76,87.58 72.84,88.66 74.72,88.66 v1(75.16,89.11)
  L2SGND w0.114: 71.76,87.58 67.2,87.58 64.93,85.31 64.93,59.3 59.86,54.22 59.69,54.22 59.32,54.59 59.16,54.59 59,54.43 59,54.27 59.37,53.9 59.37,53.73 59.21,53.57 59.05,53.57 58.38,54.24 58.22,54.24 58.06,54.08 58.06,53.92 58.72,53.25 58.72,53.09 58.56,52.93 58.4,52.93 57.73,53.59 57.57,53.59 52.24,48.26 52.24,47.9 51.5,47.16 v1(51.19,47.16)
  BOTTOM w0.076: 76.08,89.76 76.8,89.76 76.84,89.72 77.81,89.72 CPU1.A28
  BOTTOM w0.089: 76.08,89.76 76.03,89.71 75.77,89.71 v1(75.16,89.11)
  BOTTOM w0.216: v1(51.19,47.16) 51.07,47.16 49.83,48.4 DM1.79
M_A_DQ8: length 70.9
  L4 w0.089: v1(74.48,87.75) 74.03,87.3 73.11,87.3
  L4 w0.203: 73.11,87.3 72.43,86.62 72.21,86.62 72.01,86.42 72.01,86.16 71.8,85.96 71.4,85.96 71.19,86.16 71.19,86.42 70.99,86.62 70.58,86.62 70.38,86.42 70.38,86.28 70.18,86.08 69.77,86.08 69.57,86.28 69.57,86.42 69.36,86.62 66.89,86.62 65.36,85.09 65.36,83.33 43.1,61.07 43.1,60.78 43.25,60.63 43.25,60.34 42.96,60.05 42.68,60.05 42.52,60.21 42.24,60.21 41.95,59.92 41.95,59.63 42.1,59.48 42.1,59.19 41.81,58.9 41.53,58.9 41.37,59.06 41.09,59.06 40.8,58.77 40.8,58.48 40.95,58.33 40.95,58.04 40.66,57.76 40.38,57.76 40.22,57.91 39.94,57.91 39.11,57.08 37.34,57.08 30.8,50.54 v1(30.8,49.67)
  BOTTOM w0.076: 76.07,88.29 76.2,88.42 77.25,88.42 77.25,88.42 77.3,88.42 77.52,88.64 78.05,88.64 78.18,88.58 78.21,88.57 78.21,88.57 78.53,88.44 CPU1.B30
  BOTTOM w0.089: 76.07,88.29 74.78,88.29 74.48,87.99 v1(74.48,87.75)
  BOTTOM w0.216: v1(30.8,49.67) 30.83,49.69 DM1.3
M_A_DQ9: length 72.5
  L4 w0.089: 73.51,86.26 73.51,86.32 74.03,86.84 74.8,86.84 75.25,87.1 75.56,87.1 v1(76.13,86.76)
  L4 w0.203: 73.51,86.26 73.03,85.78 72.33,84.73 71.65,83.43 69.22,81.01 64.57,81.01 45.32,61.75 45.05,60.85 40.92,56.71 39.43,56.16 37.72,56.16 35.27,53.71 35.27,53.71 34.44,52.88 32.83,51.27 31.95,49.53 31.95,46.42 31.54,45.28 31.26,44.67 v1(31.05,44.34)
  BOTTOM w0.076: CPU1.D30 79.89,87.63 79.7,87.44 79.68,87.44 79.44,87.44 78.9,87.44 78.87,87.45 78.86,87.46 78.72,87.51 78.46,87.51 78.34,87.47 78.17,87.47 78.13,87.49 78.04,87.53 78.03,87.53 78.02,87.53 76.99,87.53 76.56,87.1 76.46,87.1 v1(76.13,86.76)
  BOTTOM w0.216: v1(31.05,44.34) 31.08,44.02 DM1.4
M_A_DQ10: length 71.6
  L4 w0.089: 71.46,79.41 76.51,84.46 v1(76.51,84.81)
  L4 w0.203: 71.46,79.41 68.96,76.91 68.51,76.91 68.31,77.12 68.31,77.55 68.11,77.75 67.7,77.75 67.5,77.55 67.5,77.12 67.29,76.91 66.2,76.91 65.99,76.71 65.7,76.71 65.49,76.92 65.2,76.92 64.91,76.63 64.91,76.34 65.13,76.13 65.13,75.84 64.84,75.56 64.55,75.56 64.34,75.77 64.05,75.77 63.76,75.48 63.76,75.19 63.98,74.98 63.98,74.69 63.69,74.41 63.4,74.41 63.19,74.62 62.9,74.62 62.61,74.33 62.61,74.04 62.83,73.83 62.83,73.54 62.54,73.26 62.25,73.26 62.04,73.47 61.75,73.47 61.46,73.18 61.46,72.89 61.68,72.68 61.68,72.39 61.39,72.11 61.1,72.11 60.89,72.32 60.6,72.32 60.31,72.03 60.31,71.75 60.53,71.53 60.53,71.24 42.22,52.93 39.27,52.93 37.98,51.64 37.31,51.64 36.17,50.5 36.17,50.49 35.91,50.23 35.91,48.17 35.9,48.05 35.77,47.93 35.44,47.93 35.31,48.06 v1(35.31,48.19)
  BOTTOM w0.089: CPU1.B33 78.19,86.4 77.83,86.04 77.45,86.04 76.51,85.09 v1(76.51,84.81)
  BOTTOM w0.216: v1(35.31,48.19) 35.31,47.68 35.18,47.55 34.51,47.55 34.35,47.72 34.35,49.07 34.33,49.1 DM1.17
M_A_DQ11: length 70.9
  L4 w0.089: v1(75.87,84.79) 75.87,84.38 69.69,78.2
  L4 w0.203: 69.69,78.2 67.17,78.2 67.03,78.06 67.03,77.6 66.87,77.43 66.46,77.43 66.3,77.6 66.3,77.88 66.12,78.05 65.69,78.05 59.33,71.7 59.33,71.41 59.54,71.2 59.54,70.91 59.26,70.62 58.97,70.62 58.76,70.83 58.47,70.83 58.18,70.55 58.18,70.26 58.4,70.05 58.4,69.76 56.96,68.32 56.67,68.32 56.46,68.54 56.17,68.54 55.88,68.25 55.88,67.96 56.1,67.75 56.1,67.46 55.81,67.17 55.52,67.17 55.31,67.39 55.02,67.39 54.73,67.1 54.73,66.81 54.95,66.6 54.95,66.31 54.66,66.02 54.37,66.02 54.16,66.24 53.87,66.24 53.58,65.95 53.58,65.66 53.8,65.45 53.8,65.16 53.51,64.87 53.22,64.87 53.01,65.09 52.72,65.09 52.43,64.8 52.43,64.51 52.65,64.3 52.65,64.01 52.36,63.72 52.07,63.72 51.86,63.94 51.57,63.94 51.28,63.65 51.28,63.36 51.5,63.15 51.5,62.86 51.21,62.57 50.92,62.57 50.71,62.79 50.42,62.79 50.13,62.5 50.13,62.21 50.35,62 50.35,61.71 41.98,53.34 39.1,53.34 39.06,53.3 39.06,53.3 37.8,52.05 37.07,52.05 35.32,50.3 v1(35.32,49.46)
  BOTTOM w0.076: 76.78,85.89 76.98,86.09 77.08,86.09 77.95,86.49 78.07,86.62 78.07,86.62 78.11,86.66 78.35,86.77 78.35,86.77 79.74,86.77 79.85,86.86 CPU1.D32
  BOTTOM w0.216: v1(35.32,49.46) 35.32,51.1 DM1.21 ; v1(75.87,84.79) 75.87,84.99 76.78,85.89
M_A_DQ12: length 71
  L4 w0.089: v1(75.13,87.71) 74.65,87.23 73.97,87.02 73.69,87.02
  L4 w0.203: 73.69,87.02 71.69,85.03 71.23,84.11 70.95,83.33 69.1,81.48 64.4,81.48 44.91,61.99 44.65,61.09 40.73,57.17 39.24,56.62 37.53,56.62 34.2,53.29 33.8,52.88 33.8,52.88 31.54,50.63 31.54,46.6 31.29,46.3 v1(30.94,46)
  BOTTOM w0.076: CPU1.A30 77.5,88.38 77.37,88.25 77.32,88.25 77.32,88.25 76.47,88.25 76.41,88.19 76.26,88.04
  BOTTOM w0.089: v1(75.13,87.71) 75.46,88.04 76.26,88.04
  BOTTOM w0.216: DM1.8 32.08,44.87 v1(30.94,46)
M_A_DQ13: length 71.5
  L4 w0.203: v1(30.75,48.4) 30.51,48.44 30.22,48.8 30.22,50.58 31.08,51.44 31.08,51.46 37.18,57.56 38.94,57.56 64.19,82.81 64.8,85.45 66.6,87.25 70.63,87.74 v1(73.21,87.8)
  BOTTOM w0.076: 75.96,88.47 76.07,88.58 77.18,88.58 77.18,88.58 77.23,88.58 77.45,88.8 78.09,88.8 78.19,88.76 78.24,88.74 78.63,88.74 78.78,88.7 CPU1.C30
  BOTTOM w0.089: v1(73.21,87.8) 73.56,88.15 74.41,88.47 75.96,88.47
  BOTTOM w0.216: DM1.7 31.83,49.13 31.09,48.4 v1(30.75,48.4)
M_A_DQ14: length 70.3
  L4 w0.203: v1(34.08,44.56) 34.51,44.56 35,45.06 35,47.7 34.75,47.95 34.75,50.37 36.85,52.48 37.65,52.48 38.93,53.76 41.75,53.76 49.63,61.65 49.63,62.65 65.67,78.68 69.64,78.68 74.5,83.54 v1(74.5,84.79)
  BOTTOM w0.076: 76.86,86.36 77.12,86.36 77.98,86.75 78.02,86.8 78.12,86.84 78.32,87.04 78.4,87.08 CPU1.B32 ; 76.84,86.36 76.67,86.2
  BOTTOM w0.089: 76.86,86.36 76.84,86.36
  BOTTOM w0.216: 76.67,86.2 76.65,86.2 76.37,85.91 73.96,85.91 73.83,85.79 73.83,84.91 73.96,84.79 v1(74.5,84.79) ; DM1.16 v1(34.08,44.56)
M_A_DQ15: length 69.9
  L4 w0.089: 74.04,83.97 74.04,84.89 74.36,85.21 74.83,85.21 76.28,86.24 v1(76.8,86.76)
  L4 w0.203: v1(34.09,46.21) 34.3,46.21 34.55,46.46 34.55,47.07 34.34,47.27 34.34,50.61 35.03,51.3 35.03,51.31 36.62,52.9 37.26,52.9 38.58,54.22 41.56,54.22 49.01,61.67 49.01,62.67 65.48,79.14 69.21,79.14 74.04,83.97
  BOTTOM w0.076: v1(76.8,86.76) 76.8,86.97 77.19,87.36 77.99,87.36 78,87.36 78,87.36 78.06,87.34 78.1,87.32 78.1,87.32 78.13,87.3 78.38,87.3 78.39,87.31 78.4,87.31 78.4,87.32 78.49,87.35 78.69,87.35 78.77,87.32 78.78,87.31 78.96,87.24 CPU1.C32
  BOTTOM w0.216: v1(34.09,46.21) 35.08,45.23 DM1.20
M_A_DQ16: length 76.5
  L4 w0.089: v1(82.82,92.83) 82.06,93.58 80.56,93.58 77.83,90.85 77.83,85 77.14,84.32 76.95,84.32 72.75,80.11
  L4 w0.203: v1(36.07,45.7) 36.12,45.75 36.29,47.78 36.3,47.79 36.3,47.93 36.3,47.99 36.32,48 36.32,48.03 36.32,50.06 36.91,50.65 37.62,50.65 39.5,52.53 42.69,52.53 66.58,76.42 69.05,76.42 72.75,80.11
  BOTTOM w0.089: CPU1.J22 82.69,93.04 82.69,92.95 v1(82.82,92.83)
  BOTTOM w0.216: v1(36.07,45.7) 36.2,45.7 37.08,44.83 DM1.28
M_A_DQ17: length 78.6
  L4 w0.089: 82.3,85.89 82.3,86.82 82.02,87.1 82.02,90.68 v1(82.07,90.74)
  L4 w0.203: v1(39.55,45.89) 39.96,45.89 40.08,45.76 40.08,45.01 40.41,44.68 42.75,44.68 42.88,44.81 42.88,45.87 44.07,47.07 44.75,47.07 45.21,47.53 45.21,49.72 45.55,50.06 46.26,50.06 47.08,49.24 48.5,49.24 48.96,48.77 49.69,48.77 50.97,50.06 52.24,50.06 52.95,50.76 52.95,56.64 68.09,71.78 68.47,71.78 71.4,71.78 76.43,76.81 77.43,76.81 77.9,77.28 77.9,79.9 82.3,84.31 82.3,85.89
  BOTTOM w0.089: v1(82.07,90.74) 82.07,90.97 CPU1.H25
  BOTTOM w0.216: v1(39.55,45.89) 40.58,44.86 DM1.42
M_A_DQ18: length 74.8
  L4 w0.089: 74.17,80.54 78.4,84.78 78.4,90.92 80.7,93.23 81.38,93.23 81.52,93.08 v1(81.52,92.83)
  L4 w0.203: v1(37.3,49.67) 37.41,49.56 37.98,49.56 40.13,51.72 43.17,51.72 45.26,53.81 45.55,53.81 46.19,53.16 46.43,53.16 46.76,53.49 46.76,53.75 46.12,54.38 46.12,54.67 46.41,54.96 46.69,54.96 47.25,54.4 47.57,54.4 47.85,54.69 47.85,54.95 47.27,55.53 47.27,55.82 47.56,56.11 47.84,56.11 48.45,55.5 48.74,55.5 49.03,55.78 49.03,56.07 48.42,56.68 48.42,56.97 66.95,75.5 69.49,75.5 74.17,80.19 74.17,80.54
  BOTTOM w0.089: v1(81.52,92.83) 81.52,93.15 81.43,93.24 CPU1.G22
  BOTTOM w0.216: DM1.29 37.33,50.71 37.3,50.69 v1(37.3,49.67)
M_A_DQ19: length 75.1
  L4 w0.089: v1(82.17,92.83) 81.59,93.4 80.63,93.4 78.22,91 78.22,85 73.4,80.18
  L4 w0.203: 73.4,80.18 69.18,75.96 66.76,75.96 42.93,52.12 39.7,52.12 37.81,50.23 37.07,50.23 36.73,49.89 36.73,44.94 36.23,44.43 v1(36.07,44.43)
  BOTTOM w0.089: CPU1.H22 82.04,93.04 82.04,92.95 v1(82.17,92.83)
  BOTTOM w0.216: DM1.24 36.08,44.43 v1(36.07,44.43)
M_A_DQ20: length 79.2
  L4 w0.089: 79.61,88.41 80.03,88.82 80.03,90.09 v1(80.65,90.71)
  L4 w0.203: v1(39.85,48.49) 40.01,48.49 40.37,48.13 40.89,48.13 41.02,48.26 41.02,48.67 40.91,48.78 40.91,49.26 41.3,49.66 42.14,49.66 42.71,50.22 43.19,50.22 43.57,49.84 44.17,49.84 45.23,50.9 48.77,50.9 49.86,52 50.15,52 50.96,51.19 51.24,51.19 51.53,51.48 51.53,51.77 50.73,52.57 50.73,52.86 51.57,53.7 51.57,56.56 68.11,73.1 70.91,73.1 71.03,73.23 71.03,74.03 71.36,74.35 71.7,74.35 72.03,74.02 72.32,74.02 72.61,74.31 72.61,74.59 72.27,74.93 72.27,75.22 72.56,75.5 72.85,75.5 73.18,75.17 73.47,75.17 73.76,75.46 73.76,75.74 73.42,76.08 73.42,76.37 73.71,76.65 74,76.65 74.33,76.32 74.62,76.32 74.91,76.61 74.91,76.89 74.57,77.23 74.57,77.51 74.86,77.8 75.15,77.8 75.48,77.47 75.77,77.47 76.05,77.75 76.05,78.04 75.72,78.38 75.72,78.66 76.15,79.1 76.15,80.67 77.28,81.8 77.57,81.8 77.79,81.58 78.08,81.58 78.37,81.87 78.37,82.16 78.14,82.38 78.14,82.66 78.43,82.95 78.72,82.95 78.94,82.73 79.23,82.73 79.51,83.02 79.51,83.31 79.29,83.53 79.29,83.81 79.61,84.13 79.61,88.41
  BOTTOM w0.076: CPU1.F25 80.79,91.08 80.79,90.9 80.7,90.74 80.67,90.73 v1(80.65,90.71)
  BOTTOM w0.216: v1(39.85,48.49) 39.69,48.49 39.33,48.86 DM1.37
M_A_DQ21: length 78
  TOP w0.216: v1(39.53,44.48) 39.71,44.48 39.95,44.73 v2(40.05,44.73)
  L4 w0.089: v1(82.77,90.74) 82.77,90.22 82.88,90.1 82.88,86.87 82.67,86.66 82.67,85.87
  L4 w0.203: 82.67,85.87 82.96,85.59 82.96,82.62 79.92,79.57 79.39,79.57 79.38,79.58 78.83,79.58 78.33,79.08 78.33,77.03 77.58,76.28 76.56,76.28 71.61,71.33 68.28,71.33 53.41,56.46 53.41,50 52.93,49.52 51.37,49.52 50.63,48.78 50.63,47.68 50.19,47.25 49.12,47.25 48.67,46.79 47.87,46.79 47.23,47.44 46.6,47.44 46.44,47.27 46.44,46.5 45.73,45.8 45.73,44.38 45.6,44.25 39.76,44.25 v1(39.53,44.48)
  BOTTOM w0.089: CPU1.J25 82.77,90.93 v1(82.77,90.74)
  BOTTOM w0.216: DM1.38 39.58,44.44 v1(39.53,44.48)
M_A_DQ22: length 76.3
  L4 w0.089: 80.26,88.4 80.26,88.98 81.1,89.82 81.1,90.4 v1(81.38,90.69)
  L4 w0.203: v1(39.93,47.22) 40.43,47.22 40.62,47.04 40.62,46.59 40.74,46.46 41.33,46.46 41.46,46.59 41.46,46.9 41.66,47.11 43.53,47.11 44.53,48.11 44.53,49.63 45.4,50.5 46.76,50.5 47.53,49.73 49.86,49.73 50.63,50.5 51.69,50.5 52.49,51.3 52.49,56.83 68.3,72.65 71.61,72.65 76.63,77.67 76.63,80.58 77.05,81 78.21,81 80.83,83.62 80.83,84.71 79.95,85.59 79.95,88.08 80.26,88.4
  BOTTOM w0.089: v1(81.38,90.69) 81.39,90.7 81.39,91 CPU1.G25
  BOTTOM w0.216: v1(39.93,47.22) 40.02,47.22 40.36,47.56 40.36,49.92 40.33,49.95 DM1.41
M_A_DQ23: length 75.1
  L4 w0.089: 74.68,80.67 78.58,84.57 78.58,90.54 v1(80.87,92.83)
  L4 w0.203: 74.68,80.67 74.68,79.96 69.76,75.05 67.14,75.05 49.63,57.53 49.63,55.67 48.87,54.92 48.87,54.63 49.33,54.17 49.33,53.88 49.05,53.59 48.76,53.59 48.3,54.05 48.01,54.05 47.72,53.77 47.72,53.48 48.18,53.02 48.18,52.73 47.9,52.44 47.61,52.44 47.15,52.9 46.86,52.9 46.61,52.66 44.75,52.66 43.41,51.31 40.37,51.31 38.1,49.04 38.1,48.57 37.86,48.32 v1(37.3,48.32)
  BOTTOM w0.216: CPU1.F22 v1(80.87,92.83) ; v1(37.3,48.32) 37.09,48.11 36.48,48.11 36.31,48.27 36.31,51.09 DM1.25
M_A_DQ24: length 77.4
  TOP w0.127: v2(41.42,47.22) 41.61,47.41 v1(41.61,47.75)
  L2SGND w0.114: v1(41.61,47.75) 41.59,47.75 41.03,48.31 41.03,50.85 56.32,66.14 57.69,69.31 57.69,87.61 65.66,95.58 75.63,95.58 v1(76.82,94.4)
  BOTTOM w0.076: 77.12,94.1 77.37,93.84 78.1,93.84 78.3,93.74 79.23,93.74 CPU1.D22
  BOTTOM w0.089: 77.12,94.1 v1(76.82,94.4)
  BOTTOM w0.216: v1(41.61,47.75) 41.63,47.75 42.44,48.56 42.44,49.42 42.33,49.53 DM1.49
M_A_DQ25: length 77.3
  TOP w0.127: v2(41.43,45.79) v1(41.67,45.27)
  L2SGND w0.114: v1(41.67,45.27) 41.71,45.27 41.71,45.28 41.82,45.28 42.27,45.28 42.59,45.6 42.59,47.44 42.52,47.51 42.52,50.34 42.95,50.78 42.95,50.94 42.84,51.04 42.84,51.2 43,51.37 43.16,51.37 43.27,51.26 43.43,51.26 43.59,51.42 43.59,51.58 43.56,51.62 43.56,51.78 43.72,51.95 43.88,51.95 43.92,51.91 44.08,51.91 58.72,66.54 58.72,87.19 66.03,94.5 74.03,94.5 v1(74.17,94.36)
  BOTTOM w0.076: CPU1.C22 78.71,93.17 78.66,93.16 78.53,93.16 78.35,93.19 78.19,93.19 78,93.16 77.02,93.16 76.55,93.63 76.49,93.63
  BOTTOM w0.089: 76.49,93.63 75.7,93.63 75.4,93.93 74.6,93.93 v1(74.17,94.36)
  BOTTOM w0.216: DM1.46 41.58,45.03 41.67,45.12 v1(41.67,45.27)
M_A_DQ26: length 76.5
  TOP w0.127: v2(45.06,44.81) v1(44.68,45.26)
  L2SGND w0.114: v1(70.94,93.07) 70.52,92.65 70.13,92.65 70.11,92.67 66.79,92.67 60.54,86.43 60.54,64.45 53.47,57.38 53.31,57.38 52.85,57.83 52.69,57.83 52.53,57.67 52.53,57.51 52.98,57.06 52.98,56.89 52.82,56.73 52.66,56.73 52.2,57.19 52.04,57.19 51.88,57.03 51.88,56.86 52.34,56.41 52.34,56.25 46.37,50.28 45.46,50.28 45.01,49.82 45.01,45.52 44.75,45.26 v1(44.68,45.26)
  BOTTOM w0.076: 74.47,92.2 74.9,91.77 77.64,91.77 77.72,91.7 78.11,91.7 78.22,91.76 78.33,91.82 78.79,91.82 CPU1.C24
  BOTTOM w0.089: 74.47,92.2 71.81,92.2 v1(70.94,93.07)
  BOTTOM w0.216: v1(44.68,45.26) 44.74,45.21 44.74,44.41 44.58,44.25 DM1.58
M_A_DQ27: length 77.8
  TOP w0.127: v1(44.33,46.5) v2(44.24,47.19)
  L2SGND w0.114: v1(70.3,93.07) 68,93.07 67.94,93.02 66.65,93.02 60.2,86.57 60.2,65.83 51.29,56.92 51.29,56.92 51.13,56.76 51.13,56.6 51.57,56.15 51.57,55.99 51.41,55.83 51.25,55.83 50.8,56.27 50.64,56.27 50.48,56.11 50.48,55.95 50.93,55.5 50.93,55.34 46.21,50.62 45.32,50.62 44.66,49.97 44.66,46.83 v1(44.33,46.5)
  BOTTOM w0.076: CPU1.D24 79.89,92.84 79.84,92.88 79.68,93.05 79.45,93.05 79.43,93.03 78.8,93.03 78.7,93 78.52,93 78.32,93.02 78.2,93.02 78.02,93 76.95,93 76.52,93.43 76.49,93.43
  BOTTOM w0.089: v1(70.3,93.07) 70.71,93.47 75.44,93.47 75.47,93.44 76.48,93.44 76.49,93.43
  BOTTOM w0.216: DM1.62 45.58,43.97 45.64,44.03 45.64,44.85 45.65,44.86 45.65,45.89 45.05,46.5 v1(44.33,46.5)
M_A_DQ28: length 75.6
  TOP w0.127: v1(75.51,94.36) 75.49,94.35 v2(75.49,93.74)
  L2SGND w0.114: v1(42.15,46.54) 42.15,51 53.43,62.28 53.97,62.28 58.37,66.69 58.37,87.33 65.89,94.85 75.03,94.85 v1(75.51,94.36)
  BOTTOM w0.076: v1(75.51,94.36) 76.05,93.82 76.59,93.82 77,93.42 CPU1.A22
  BOTTOM w0.216: DM1.50 42.58,44.77 42.64,44.83 42.64,46.05 v1(42.15,46.54)
M_A_DQ29: length 76.2
  TOP w0.127: v2(76.71,93.8) v1(76.15,94.37)
  L2SGND w0.114: v1(76.15,94.37) 75.27,95.24 65.8,95.24 58.03,87.47 58.03,67.36 57.76,67.1 57.76,66.93 57.87,66.83 57.87,66.67 57.71,66.5 57.54,66.5 57.44,66.61 57.28,66.61 57.11,66.45 57.11,66.29 57.22,66.18 57.22,66.02 57.06,65.86 56.9,65.86 56.79,65.96 56.63,65.96 56.47,65.8 56.47,65.64 56.57,65.53 56.57,65.37 56.41,65.21 56.25,65.21 56.14,65.32 55.98,65.32 55.82,65.16 55.82,64.99 55.93,64.89 55.93,64.73 55.77,64.56 55.6,64.56 55.5,64.67 55.34,64.67 55.17,64.51 55.17,64.35 55.28,64.24 55.28,64.08 55.12,63.92 54.96,63.92 54.85,64.02 54.69,64.02 54.53,63.86 54.53,63.7 54.63,63.59 54.63,63.43 54.47,63.27 54.31,63.27 54.2,63.38 54.04,63.38 53.88,63.22 53.88,63.05 53.99,62.95 53.99,62.79 53.83,62.62 53.66,62.62 53.56,62.73 53.4,62.73 41.47,50.8 v1(41.47,49.01)
  BOTTOM w0.076: 76.76,93.93 77.02,93.68 78.06,93.68 78.31,93.54 CPU1.B22
  BOTTOM w0.089: 76.76,93.93 76.67,94.02 76.49,94.02 v1(76.15,94.37)
  BOTTOM w0.216: v1(41.47,49.01) 41.33,49.16 DM1.45
M_A_DQ30: length 76
  TOP w0.127: v2(73.74,92.41) v1(73.65,92.98)
  L2SGND w0.114: v1(45.79,49.5) 47.26,49.5 47.5,49.74 47.5,49.9 47.31,50.09 47.31,50.25 47.48,50.41 47.64,50.41 47.82,50.23 47.99,50.23 48.15,50.39 48.15,50.55 47.96,50.74 47.96,50.9 48.12,51.06 48.28,51.06 48.47,50.87 48.63,50.87 48.79,51.04 48.79,51.2 48.61,51.38 48.61,51.55 48.77,51.71 48.93,51.71 49.12,51.52 49.28,51.52 49.44,51.68 49.44,51.84 49.25,52.03 49.25,52.19 49.42,52.35 49.58,52.35 49.76,52.17 49.93,52.17 50.09,52.33 50.09,52.49 49.9,52.68 49.9,52.84 50.06,53 50.22,53 50.41,52.81 50.57,52.81 50.73,52.98 50.73,53.14 50.55,53.33 50.55,53.49 50.71,53.65 50.87,53.65 51.06,53.46 51.22,53.46 51.38,53.62 51.38,53.78 51.19,53.97 51.19,54.13 51.36,54.3 51.52,54.3 51.7,54.11 51.87,54.11 52.03,54.27 52.03,54.43 51.84,54.62 51.84,54.78 52,54.94 52.16,54.94 52.35,54.75 52.51,54.75 52.67,54.92 52.67,55.08 52.49,55.27 52.49,55.43 52.65,55.59 52.81,55.59 53,55.4 53.16,55.4 53.32,55.56 53.32,55.72 53.13,55.91 53.13,56.07 53.3,56.24 53.46,56.24 53.64,56.05 53.81,56.05 53.97,56.21 53.97,56.37 53.78,56.56 53.78,56.72 53.94,56.88 54.1,56.88 54.29,56.69 54.45,56.69 54.61,56.86 54.61,57.02 54.43,57.21 54.43,57.37 54.59,57.53 54.75,57.53 54.94,57.34 55.1,57.34 55.26,57.5 55.26,57.66 55.07,57.85 55.07,58.01 55.24,58.18 55.4,58.18 55.58,57.99 55.75,57.99 55.91,58.15 55.91,58.31 55.72,58.5 55.72,58.66 55.88,58.82 56.04,58.82 56.23,58.63 56.39,58.63 61.23,63.47 61.23,86.14 67.07,91.99 68.08,91.99 68.32,92.23 72.9,92.23 v1(73.65,92.98)
  BOTTOM w0.076: CPU1.A24 75.13,92.12
  BOTTOM w0.089: 75.13,92.12 74.69,92.56 74.07,92.56 v1(73.65,92.98)
  BOTTOM w0.216: v1(45.79,49.5) 45.83,49.54 DM1.63
M_A_DQ31: length 77.1
  TOP w0.127: v1(45.82,46.9) v2(45.63,46.36)
  L2SGND w0.114: v1(72.22,93.01) 71.64,92.43 68,92.43 67.9,92.33 66.93,92.33 60.89,86.29 60.89,64.31 60.54,63.96 60.54,63.8 60.72,63.61 60.72,63.45 60.56,63.29 60.4,63.29 60.21,63.48 60.05,63.48 59.89,63.32 59.89,63.15 60.08,62.97 60.08,62.81 59.92,62.64 59.75,62.64 59.57,62.83 59.41,62.83 59.24,62.67 59.24,62.51 59.43,62.32 59.43,62.16 59.27,62 59.11,62 58.92,62.18 58.76,62.18 58.6,62.02 58.6,61.86 58.78,61.67 58.78,61.51 58.62,61.35 58.46,61.35 58.27,61.54 58.11,61.54 57.95,61.38 57.95,61.21 58.14,61.03 58.14,60.87 57.98,60.7 57.81,60.7 57.63,60.89 57.47,60.89 57.3,60.73 57.3,60.57 57.49,60.38 57.49,60.22 57.33,60.06 57.17,60.06 56.98,60.24 56.82,60.24 46.51,49.94 45.6,49.94 45.35,49.68 45.35,47.37 v1(45.82,46.9)
  BOTTOM w0.076: 74.97,91.96 74.99,91.94 77.71,91.94 77.79,91.86 78.06,91.86 78.12,91.89 78.36,92.02 CPU1.B24
  BOTTOM w0.089: 74.97,91.96 74.55,92.38 72.84,92.38 v1(72.22,93.01)
  BOTTOM w0.216: DM1.59 44.83,49.89 44.81,49.88 44.81,47.85 45.77,46.9 v1(45.82,46.9)
M_A_DQ32: length 48.3
  L2SGND w0.114: v1(77.22,78.54) 76.81,78.12 76.81,75.84 76.91,75.74 76.91,74.92 77.38,74.45 77.38,63.34 85.77,54.95 85.77,47.19 v1(84.97,46.39)
  BOTTOM w0.076: 80.82,82.67 81.03,82.88 81.53,83.41 81.91,83.91 CPU1.H37
  BOTTOM w0.089: 80.82,82.67 80.44,82.29 79.42,82.29 78.17,81.04 78.17,79.49 v1(77.22,78.54)
  BOTTOM w0.216: v1(84.97,46.39) 85.02,46.39 85.92,45.49 85.92,44.78 86.07,44.63 86.07,43.97 86.08,43.96 DM1.216
M_A_DQ33: length 49.9
  L2SGND w0.114: v1(77.19,80.49) 76.22,79.52 76.22,74.31 76.69,73.84 76.69,63.06 84.52,55.23 84.52,48.26 v1(85.3,47.49)
  BOTTOM w0.076: 80.63,83.19 81.52,84.08 81.7,84.41 81.7,85.36 CPU1.H34
  BOTTOM w0.089: v1(77.19,80.49) 77.19,82.14 77.72,82.67 79.6,82.67 79.6,82.68 80.12,82.68 80.63,83.19
  BOTTOM w0.216: v1(85.3,47.49) 85.56,47.49 85.83,47.76 DM1.215
M_A_DQ34: length 51.7
  L2SGND w0.114: v1(79.02,79.12) 79.4,78.74 79.4,78.14 80.11,77.42 80.11,75.59 80.23,75.47 80.23,64.53 90.66,54.1 90.66,48.41 90.24,48 90.24,47.98 89.98,47.73 89.97,47.73 v1(89.78,47.53)
  BOTTOM w0.076: CPU1.K34 82.56,85.94 82.52,85.89 82.32,85.69 82.32,85.02 82.41,84.75 82.41,84.52 82.38,84.43 82.38,84.19 82.41,84.1 82.41,83.68 81.97,83.24
  BOTTOM w0.089: 81.97,83.24 80.61,81.87 79.84,81.87 78.92,80.95 78.79,80.95 78.57,80.72 78.57,79.91 78.53,79.88 78.53,79.61 v1(79.02,79.12)
  BOTTOM w0.216: v1(89.78,47.53) 89.08,46.83 DM1.228
M_A_DQ35: length 51.3
  TOP w0.216: v1(87.76,47.1) v2(87.2,47.1)
  L2SGND w0.114: v1(87.76,47.1) 87.96,46.9 88.75,46.9 88.99,47.14 88.99,54.31 79.21,64.1 79.21,73.85 78.79,74.27 78.79,74.8 78.95,74.96 v1(78.95,75.26)
  BOTTOM w0.076: CPU1.K35 83.58,84.99 83.58,84.38 83.7,84.15 83.7,82.81 80.33,79.44 80.27,79.44 79.78,78.95 79.78,77.92
  BOTTOM w0.089: 79.78,77.92 79.85,77.85 79.85,75.81 79.3,75.26 v1(78.95,75.26)
  BOTTOM w0.216: v1(87.76,47.1) 88.11,47.1 88.33,47.32 88.33,48.82 88.33,48.82 88.33,49.22 88.33,49.23 DM1.225
M_A_DQ36: length 48.6
  L2SGND w0.114: v1(85.28,48.8) 84.86,49.21 84.86,49.97 84.98,50.09 85.31,50.09 85.42,50.2 85.42,50.43 85.31,50.54 84.98,50.54 84.86,50.66 84.86,50.89 84.98,51 85.31,51 85.42,51.12 85.42,51.35 85.31,51.46 84.98,51.46 84.86,51.57 84.86,51.8 84.98,51.92 85.31,51.92 85.42,52.03 85.42,52.26 85.31,52.37 84.98,52.37 84.86,52.49 84.86,52.72 84.98,52.83 85.31,52.83 85.42,52.95 85.42,53.17 85.31,53.29 85.21,53.29 85.09,53.4 85.09,53.63 85.21,53.75 85.31,53.75 85.42,53.86 85.42,54.81 77.03,63.2 77.03,74.04 76.56,74.52 76.56,78.52 v1(77.22,79.17)
  BOTTOM w0.076: CPU1.H36 81.98,84.58 81.5,83.69 80.88,83.06
  BOTTOM w0.089: v1(77.22,79.17) 77.47,79.17 77.82,79.52 v2(77.82,80.85) 77.82,81.25 79.07,82.49 79.67,82.49 79.68,82.5 80.32,82.5 80.88,83.06
  BOTTOM w0.216: v1(85.28,48.8) 85.13,48.95 85.12,48.95 84.84,49.23 84.84,49.24 84.83,49.25 DM1.211
M_A_DQ37: length 49.6
  L2SGND w0.114: v1(84.97,44.98) 86.16,46.18 86.29,46.49 86.29,54.92 77.72,63.48 77.72,74.63 77.24,75.11 v1(77.24,77.27)
  BOTTOM w0.076: CPU1.H35 82.08,85.19 82.15,84.99 82.15,84.99 82.24,84.75 82.24,84.52 82.21,84.46 82.21,84.16 82.24,84.1 82.24,83.78 81.05,82.6
  BOTTOM w0.089: 81.05,82.6 80.51,82.06 79.77,82.06 78.84,81.13 78.64,81.13 78.39,80.87 78.39,79.99 78.35,79.95 78.35,79.29 v2(78.46,79.17) 78.46,78.23 77.5,77.27 v1(77.24,77.27)
  BOTTOM w0.216: v1(84.97,44.98) 84.97,44.37 85.08,44.26 DM1.212
M_A_DQ38: length 50
  L2SGND w0.114: v1(87.56,45.32) 87.57,45.32 87.65,45.25 88.91,45.25 89.33,45.68 89.33,54.45 79.55,64.24 79.55,75.07 79.4,75.21 79.4,76.07 v1(78.94,76.53)
  BOTTOM w0.076: 80.1,79.51 82.52,81.93 82.58,81.93 83.54,82.89 83.54,84.1 83.28,84.57 CPU1.K36
  BOTTOM w0.089: v1(78.94,76.53) 79.56,77.15 79.56,78.03 79.61,78.08 79.61,79.02 80.1,79.51
  BOTTOM w0.216: v1(87.56,45.32) 87.57,45.32 87.65,45.25 87.78,45.25 88.1,44.94 88.1,44.9 88.1,44.89 88.1,44.49 88.08,44.46 DM1.224
M_A_DQ39: length 48.8
  L2SGND w0.114: v1(78.95,77.83) 79.73,77.04 79.73,75.39 79.89,75.23 79.89,64.38 90.31,53.96 90.31,53.34 90.2,53.22 89.79,53.22 89.68,53.11 89.68,52.88 89.79,52.77 90.2,52.77 90.31,52.65 90.31,52.42 90.2,52.31 89.79,52.31 89.68,52.2 89.68,51.97 89.79,51.85 90.2,51.85 90.31,51.74 90.31,51.51 90.2,51.4 89.79,51.4 89.68,51.28 89.68,51.05 89.79,50.94 90.2,50.94 90.31,50.82 90.31,50.6 90.2,50.48 89.79,50.48 89.68,50.37 89.68,50.14 89.79,50.02 90.2,50.02 90.31,49.91 90.31,48.92 90.2,48.8 v1(89.8,48.8)
  BOTTOM w0.076: CPU1.K37 83.28,82.88 82.51,82.11 82.45,82.11 82.35,82.01
  BOTTOM w0.089: 82.35,82.01 80.03,79.69 80.02,79.69 79.43,79.09 79.43,78.16 79.1,77.83 v1(78.95,77.83)
  BOTTOM w0.216: DM1.229 89.33,49.28 89.34,49.27 89.34,49.26 89.62,48.98 89.63,48.98 v1(89.8,48.8)
M_A_DQ40: length 51.8
  L2SGND w0.089: v1(80.4,78.33) 80.43,78.33 80.98,77.78 80.98,77.04 81.43,76.59 81.43,74.86
  L2SGND w0.114: 81.43,74.86 81.43,71.34 81.41,71.32 81.41,65.32 84.67,62.06 84.67,61.9 84.59,61.81 84.59,61.65 84.75,61.49 84.91,61.49 85,61.57 85.16,61.57 85.32,61.41 85.32,61.25 85.24,61.16 85.24,61 85.4,60.84 85.56,60.84 85.64,60.93 85.81,60.93 85.97,60.77 85.97,60.6 85.88,60.52 85.88,60.36 86.04,60.19 86.21,60.19 86.29,60.28 86.45,60.28 86.61,60.12 86.61,59.96 86.53,59.87 86.53,59.71 86.69,59.55 86.85,59.55 86.94,59.63 87.1,59.63 87.26,59.47 87.26,59.31 87.18,59.22 87.18,59.06 87.34,58.9 87.5,58.9 87.58,58.99 87.75,58.99 87.91,58.83 87.91,58.66 87.82,58.58 87.82,58.42 87.98,58.25 88.15,58.25 88.23,58.34 88.39,58.34 88.55,58.18 88.55,58.02 88.47,57.93 88.47,57.77 88.63,57.61 88.79,57.61 88.88,57.69 89.04,57.69 89.2,57.53 89.2,57.37 89.12,57.28 89.12,57.12 89.28,56.96 89.44,56.96 89.52,57.05 89.69,57.05 89.85,56.89 89.85,56.72 89.76,56.64 89.76,56.48 89.92,56.31 90.09,56.31 90.17,56.4 90.33,56.4 90.49,56.24 90.49,56.08 90.41,55.99 90.41,55.83 90.57,55.67 90.73,55.67 90.82,55.75 90.98,55.75 91.14,55.59 91.14,55.43 91.06,55.34 91.06,55.18 91.22,55.02 91.38,55.02 91.46,55.11 91.63,55.11 92.4,54.34 92.4,48.09 92.28,47.97 92.05,47.97 v1(91.86,48.17)
  BOTTOM w0.076: 82.82,81.31 84.17,82.66 84.17,83.97 84.5,84.58 CPU1.N36
  BOTTOM w0.089: 82.82,81.31 80.78,79.27 80.78,78.71 v1(80.4,78.33)
  BOTTOM w0.216: DM1.237 91.33,49.65 91.32,49.64 91.32,48.62 91.62,48.31 91.71,48.31 v1(91.86,48.17)
M_A_DQ41: length 52
  L2SGND w0.089: v1(80.37,78.96) 81.16,78.17 81.16,77.11 81.75,76.52 81.75,76.4
  L2SGND w0.114: 81.75,76.4 81.75,65.47 92.74,54.48 92.74,46.98 92.62,46.86 v1(91.84,46.86)
  BOTTOM w0.076: 82.89,81.74 84,82.86 84,84.02 84.18,84.34 84.18,85.28 CPU1.N34
  BOTTOM w0.089: v1(80.37,78.96) 80.32,79.01 80.32,79.17 82.89,81.74
  BOTTOM w0.216: v1(91.84,46.86) 91.02,46.86 90.33,47.55 90.33,49.68 90.33,49.68 DM1.233
M_A_DQ42: length 51.6
  L2SGND w0.089: v1(84.04,80.58) 83.21,79.74 83.21,75.95 83.32,75.85
  L2SGND w0.114: v1(94.9,47.28) 95.18,47.28 95.48,47.58 95.48,52.52 95.34,52.66 94.68,52.66 94.57,52.78 94.57,53.01 94.68,53.12 95.39,53.12 95.52,53.25 95.52,53.46 95.4,53.58 94.68,53.58 94.57,53.69 94.57,53.92 94.68,54.03 95.39,54.03 95.52,54.16 95.52,54.43 95.39,54.56 94.79,54.56 94.59,54.75 94.59,55.45 83.58,66.46 83.58,75.58 83.32,75.85
  BOTTOM w0.089: v1(84.04,80.58) 84.04,80.79 85.89,82.65 85.89,83.89 CPU1.R37
  BOTTOM w0.216: DM1.245 93.33,48.52 94.57,47.28 v1(94.9,47.28)
M_A_DQ43: length 51.7
  L2SGND w0.089: 83.03,75.47 83.03,78.15 v1(81.91,79.26)
  L2SGND w0.114: 83.03,75.47 83.24,75.26 83.24,66.08 94.22,55.1 94.22,52.31 94.34,52.19 94.85,52.19 94.97,52.08 94.97,51.85 94.85,51.73 94.34,51.73 94.22,51.62 94.22,51.39 94.34,51.28 94.85,51.28 94.97,51.16 94.97,50.93 94.85,50.82 94.34,50.82 94.22,50.71 94.22,50.48 94.34,50.36 94.85,50.36 94.97,50.25 94.97,50.02 94.85,49.91 94.35,49.91 94.22,49.78 94.22,48.62 94.35,48.49 94.69,48.49 v1(94.85,48.65)
  BOTTOM w0.076: 84.43,82.09 84.67,82.33 84.67,83.52 84.92,83.77 84.92,84.13 84.9,84.19 84.9,84.43 84.92,84.49 84.92,84.78 84.81,85.07 84.81,85.67 84.87,85.73 85.03,85.89 85.04,85.89 85.08,85.94 CPU1.R34
  BOTTOM w0.089: v1(81.91,79.26) 81.91,79.58 84.43,82.09
  BOTTOM w0.216: v1(94.85,48.65) 94.72,48.65 94.33,49.04 DM1.249
M_A_DQ44: length 51.9
  L2SGND w0.089: 81.12,74.99 81.25,75.12 81.25,76.4 v1(80.58,77.07)
  L2SGND w0.114: 81.12,74.99 81.07,74.94 81.07,64.66 91.34,54.39 91.34,53.41 91.46,53.29 91.74,53.29 91.85,53.18 91.85,52.95 91.74,52.83 91.46,52.83 91.34,52.72 91.34,52.49 91.46,52.38 91.74,52.38 91.85,52.26 91.85,52.03 91.74,51.92 91.46,51.92 91.34,51.8 91.34,51.58 91.46,51.46 91.74,51.46 91.85,51.35 91.85,51.12 91.74,51 91.46,51 91.34,50.89 91.34,50.66 91.46,50.55 91.74,50.55 91.85,50.43 91.85,50.2 91.74,50.09 91.46,50.09 91.34,49.98 91.34,45.65 91.14,45.45 v1(89.79,45.45)
  BOTTOM w0.076: CPU1.N37 84.34,83.82 84.34,82.59 83.93,82.18
  BOTTOM w0.089: v1(80.58,77.07) 81.03,77.52 v2(81.03,78.46) 81.03,79.27 83.93,82.17 83.93,82.18
  BOTTOM w0.216: v1(89.79,45.45) 90.08,45.17 DM1.232
M_A_DQ45: length 51.9
  L2SGND w0.089: 80.72,75.07 81.07,75.41 81.07,75.9 v1(80.62,76.35)
  L2SGND w0.114: v1(89.79,46.72) 90.2,46.31 90.88,46.31 91,46.43 91,54.25 80.72,64.52 80.72,75.07
  BOTTOM w0.076: CPU1.N35 84.59,85.19 84.75,84.74 84.75,84.52 84.73,84.46 84.73,84.16 84.74,84.15 84.75,84.1 84.75,83.84 84.5,83.58 84.5,82.43 84.09,82.01
  BOTTOM w0.089: v1(80.62,76.35) 81.28,76.35 81.38,76.46 81.38,76.91 81.21,77.09 81.21,78.15 81.38,78.32 81.38,78.61 81.21,78.78 81.21,79.13 84.09,82.01
  BOTTOM w0.216: DM1.236 91.08,45.82 90.17,46.72 v1(89.79,46.72)
M_A_DQ46: length 52.3
  L2SGND w0.089: v1(83.97,79.95) 83.38,79.36 83.38,76.31 83.59,76.1
  L2SGND w0.114: v1(94.62,45.7) 95.02,45.3 95.76,45.3 95.88,45.43 95.88,45.93 95.77,46.04 95.23,46.04 95.11,46.15 95.11,46.38 95.23,46.5 95.77,46.5 95.88,46.61 95.88,54.7 83.92,66.66 83.92,75.77 83.59,76.1
  BOTTOM w0.076: 84.44,80.93 86.07,82.56 86.07,84.1 86.06,84.1 85.88,84.44 85.88,84.55 CPU1.R36
  BOTTOM w0.089: v1(83.97,79.95) 84.41,80.38 84.41,80.38 84.44,80.41 84.44,80.93
  BOTTOM w0.216: DM1.246 93.58,42.91 93.58,45.67 93.85,45.94 94.38,45.94 v1(94.62,45.7)
M_A_DQ47: length 51.3
  L2SGND w0.089: 83.68,76.42 83.56,76.54 83.56,78.83 v1(84.04,79.31)
  L2SGND w0.114: 83.68,76.42 84.27,75.83 84.27,66.81 96.23,54.85 96.23,51.82 96.34,51.7 96.51,51.7 96.62,51.59 96.62,51.36 96.51,51.25 96.34,51.25 96.23,51.13 96.23,50.9 96.34,50.79 96.51,50.79 96.62,50.67 96.62,50.45 96.51,50.33 96.34,50.33 96.23,50.22 96.23,44.88 96.1,44.76 94.94,44.76 v1(94.62,44.43)
  BOTTOM w0.076: CPU1.R35 85.81,85.29 86.12,84.98 86.12,84.34 86.21,84.18 86.22,84.16 86.23,84.15 86.23,82.34 84.74,80.86
  BOTTOM w0.216: 84.74,80.86 84.74,80.01 v1(84.04,79.31) ; v1(94.62,44.43) 94.6,44.41 94.6,42.92 DM1.250
M_A_DQ48: length 60.3
  L2SGND w0.089: 80.09,87.22 80.12,87.26 81.1,87.26 81.15,87.31 v1(81.58,87.31)
  L2SGND w0.114: 80.09,87.22 79.53,86.67 79.53,86.13 77.26,83.86 74.9,83.86 69.49,78.46 69.49,70.66 70.28,69.86 70.28,60.73 70.17,60.62 69.75,60.62 69.64,60.51 69.64,60.28 69.75,60.16 70.17,60.16 70.28,60.05 70.28,59.82 70.17,59.71 69.75,59.71 69.64,59.59 69.64,59.36 69.75,59.25 70.17,59.25 70.28,59.13 70.28,58.91 70.17,58.79 69.75,58.79 69.64,58.68 69.64,58.45 69.75,58.33 70.17,58.33 70.28,58.22 70.28,57.99 70.17,57.88 69.75,57.88 69.64,57.76 69.64,57.53 69.75,57.42 70.17,57.42 70.28,57.31 70.28,56.93 77.09,50.13 77.09,47.99 v1(76.2,47.11)
  BOTTOM w0.089: CPU1.G31 81.44,87.31 v1(81.58,87.31)
  BOTTOM w0.216: v1(76.2,47.11) 76.63,47.54 76.63,47.67 77.73,48.77 77.73,49.82 77.83,49.92 DM1.183
M_A_DQ49: length 62.6
  L2SGND w0.114: v1(80.72,86.66) 80.71,86.66 77.45,83.41 75.41,83.41 70.85,78.85 70.85,77.69 70.74,77.58 70.35,77.58 70.19,77.42 70.19,77.24 70.31,77.12 70.81,77.12 70.92,77.01 70.92,76.78 70.81,76.66 70.31,76.66 70.19,76.55 70.19,76.32 70.31,76.21 70.81,76.21 70.92,76.09 70.92,75.86 70.81,75.75 70.31,75.75 70.19,75.63 70.19,75.41 70.31,75.29 70.81,75.29 70.92,75.18 70.92,74.95 70.81,74.83 70.31,74.83 70.19,74.72 70.19,74.49 70.31,74.38 70.81,74.38 70.92,74.26 70.92,74.03 70.81,73.92 70.31,73.92 70.19,73.81 70.19,73.58 70.31,73.46 70.87,73.46 70.97,73.36 70.97,58.2 74.21,54.97 74.21,54.8 73.88,54.47 73.88,54.31 74.04,54.15 74.2,54.15 74.53,54.48 74.69,54.48 74.85,54.32 74.85,54.16 74.52,53.82 74.52,53.66 74.68,53.5 74.85,53.5 75.09,53.75 75.28,53.75 75.43,53.6 75.43,53.44 75.17,53.18 75.17,53.02 75.33,52.85 77.77,50.41 77.77,50.23 77.89,50.12 77.99,50.12 78.1,50.01 78.1,49.78 77.99,49.66 77.89,49.66 77.77,49.55 77.77,49.32 77.89,49.21 77.99,49.21 78.1,49.09 78.1,48.86 77.99,48.75 77.89,48.75 77.77,48.63 77.77,46.77 77.97,46.56 77.97,45.76 78.48,45.25 79.03,45.25 v1(79.08,45.2)
  BOTTOM w0.089: v1(80.72,86.66) 80.75,86.68 80.75,86.7 80.87,86.83 CPU1.G32
  BOTTOM w0.216: DM1.186 78.58,44.85 78.93,45.2 v1(79.08,45.2)
M_A_DQ50: length 60.8
  L2SGND w0.089: 75.8,85.67 76.28,86.15 77.61,86.15 80.26,88.8 80.26,88.84 80.49,89.08 81.13,89.08 v1(81.57,88.64)
  L2SGND w0.114: 75.8,85.67 74.07,85.67 67.58,79.19 67.58,55.44 70.38,52.64 70.54,52.64 70.93,53.04 71.09,53.04 71.26,52.87 71.26,52.71 70.86,52.32 70.86,52.16 71.02,52 71.19,52 71.58,52.39 71.74,52.39 71.9,52.23 71.9,52.07 71.51,51.67 71.51,51.51 71.67,51.35 71.83,51.35 72.23,51.74 72.39,51.74 72.55,51.58 72.55,51.42 72.16,51.03 72.16,50.86 72.32,50.7 72.48,50.7 72.87,51.1 73.03,51.1 73.2,50.93 73.2,50.77 72.8,50.38 72.8,50.22 73.91,49.11 73.91,48.85 v1(74.39,48.37)
  BOTTOM w0.089: CPU1.H29 v1(81.57,88.64)
  BOTTOM w0.216: DM1.169 74.33,50.09 73.89,49.66 73.89,49.22 73.89,49.22 73.89,48.81 74.33,48.37 v1(74.39,48.37)
M_A_DQ51: length 61.6
  L2SGND w0.089: v1(81.57,89.29) 80.45,89.29 80.08,88.92 80.08,88.88 77.53,86.33 76,86.33 75.59,85.91 73.99,85.91
  L2SGND w0.114: v1(74.48,47.11) 73.66,47.11 73.37,47.39 73.37,48.51 72.77,49.11 72.49,49.11 71.36,50.24 71.36,50.41 71.48,50.53 71.48,50.69 71.32,50.85 71.16,50.85 71.03,50.73 70.87,50.73 70.71,50.89 70.71,51.05 70.84,51.18 70.84,51.34 70.67,51.5 70.51,51.5 70.39,51.38 70.23,51.38 70.06,51.54 70.06,51.7 70.19,51.82 70.19,51.99 70.03,52.15 69.87,52.15 69.74,52.02 69.58,52.02 69.42,52.18 69.42,52.35 69.54,52.47 69.54,52.63 69.38,52.79 69.22,52.79 69.09,52.67 68.93,52.67 67.03,54.57 67.03,79.11 73.83,85.91 73.99,85.91
  BOTTOM w0.089: CPU1.H28 v1(81.57,89.29)
  BOTTOM w0.216: v1(74.48,47.11) 74.96,47.59 74.96,49.33 75.28,49.65 75.28,49.76 75.33,49.8 DM1.173
M_A_DQ52: length 59.9
  L2SGND w0.089: 80.32,89.49 81.15,89.49 v1(81.58,89.92)
  L2SGND w0.114: v1(74.49,45.86) 72.77,46.65 72.6,46.82 71.52,48.66 70.79,49.56 70.68,49.66 66.69,54.31 66.69,79.28 70.19,82.78 73.64,86.77 76.57,87.33 79.52,89.49 80.32,89.49
  BOTTOM w0.089: CPU1.G28 81.46,89.92 v1(81.58,89.92)
  BOTTOM w0.216: v1(74.49,45.86) 74.66,45.86 75.57,44.94 75.57,42.91 DM1.174
M_A_DQ53: length 61.7
  L2SGND w0.114: v1(74.49,44.59) 74.92,45.02 74.92,47.66 74.84,47.75 74.84,49.78 70.94,53.67 70.78,53.67 70.39,53.28 70.23,53.28 70.06,53.44 70.06,53.6 70.46,54 70.46,54.16 70.3,54.32 70.14,54.32 69.74,53.93 69.58,53.93 69.42,54.09 69.42,54.25 69.81,54.64 69.81,54.8 69.65,54.97 69.49,54.97 69.09,54.57 68.93,54.57 68.77,54.73 68.77,54.9 69.17,55.29 69.17,55.45 69,55.61 68.84,55.61 68.45,55.22 68.29,55.22 68.12,55.38 68.12,55.54 68.52,55.94 68.52,56.1 67.93,56.69 67.93,79.02 74.12,85.21 75.99,85.21 76.55,85.77 77.19,85.77 77.38,85.96 78,85.96 78.87,86.83 78.87,86.89 v1(80.66,88.68)
  BOTTOM w0.089: v1(80.66,88.68) 80.72,88.68 CPU1.G29
  BOTTOM w0.216: v1(74.49,44.59) 74.58,44.5 DM1.170
M_A_DQ54: length 61.3
  L2SGND w0.089: 79.73,86.11 79.81,86.19 79.81,86.31 80.55,87.06 80.93,87.06 81.09,86.91 81.77,86.91 82.42,87.56 v1(82.42,87.96)
  L2SGND w0.114: v1(77.06,45.03) 77.53,45.51 77.53,46.52 77.49,46.56 77.49,46.57 77.43,46.63 77.43,50.27 73.3,54.4 73.3,54.57 73.63,54.9 73.63,55.06 73.47,55.22 73.3,55.22 72.97,54.89 72.81,54.89 72.65,55.05 72.65,55.21 72.98,55.54 72.98,55.71 72.82,55.87 72.66,55.87 72.33,55.54 72.16,55.54 72,55.7 72,55.86 72.33,56.19 72.33,56.35 72.17,56.51 72.01,56.51 71.68,56.18 71.52,56.18 71.36,56.34 71.36,56.51 71.69,56.84 71.69,57 71.53,57.16 71.36,57.16 71.03,56.83 70.87,56.83 70.63,57.07 70.63,70.02 69.83,70.82 69.83,78.31 75.15,83.64 77.36,83.64 79.73,86.01 79.73,86.11
  BOTTOM w0.089: CPU1.H31 82.35,87.96 v1(82.42,87.96)
  BOTTOM w0.216: v1(77.06,45.03) 77.36,45.03 77.58,44.82 DM1.182
M_A_DQ55: length 62.8
  L2SGND w0.114: v1(81.9,86.46) 81.9,85.63 80.96,84.69 79.17,84.69 77.67,83.19 75.68,83.19 71.31,78.83 71.31,58.34 71.56,58.1 71.72,58.1 72.11,58.49 72.27,58.49 72.43,58.33 72.43,58.17 72.04,57.78 72.04,57.62 72.2,57.45 72.36,57.45 72.76,57.85 72.92,57.85 73.08,57.69 73.08,57.52 72.69,57.13 72.69,56.97 72.85,56.81 73.01,56.81 73.4,57.2 73.57,57.2 73.73,57.04 73.73,56.88 73.33,56.48 73.33,56.32 73.5,56.16 73.66,56.16 74.05,56.55 74.21,56.55 74.37,56.39 74.37,56.23 73.98,55.84 73.98,55.68 74.14,55.51 74.3,55.51 74.7,55.91 74.86,55.91 75.02,55.75 75.02,55.58 74.63,55.19 74.63,55.03 74.79,54.87 74.95,54.87 75.34,55.26 75.51,55.26 75.67,55.1 75.67,54.94 75.27,54.54 75.27,54.38 76.42,53.23 76.42,53.07 76.09,52.74 76.09,52.58 76.25,52.42 76.42,52.42 76.75,52.75 76.91,52.75 77.07,52.59 77.07,52.43 76.74,52.09 76.74,51.93 76.9,51.77 77.06,51.77 77.39,52.1 77.56,52.1 77.72,51.94 77.72,51.78 77.39,51.45 77.39,51.28 77.55,51.12 77.71,51.12 78.04,51.46 78.2,51.46 78.45,51.21 v1(78.45,48.11)
  BOTTOM w0.089: v1(81.9,86.46) 82.02,86.59 CPU1.H32
  BOTTOM w0.216: v1(78.45,48.11) 78.63,48.29 78.63,49.39 78.83,49.59 DM1.187
M_A_DQ56: length 60.9
  L2SGND w0.089: 82.6,85.14 82.69,85.23 82.69,86.62 83.38,87.31 v1(83.44,87.31)
  L2SGND w0.114: v1(81.06,45.03) 79.93,46.17 79.93,46.43 79.57,46.79 79.57,53.59 76.36,56.8 76.36,56.96 76.67,57.27 76.67,57.43 76.51,57.59 76.35,57.59 76.04,57.28 75.87,57.28 75.71,57.45 75.71,57.61 76.02,57.92 76.02,58.08 75.86,58.24 75.7,58.24 75.39,57.93 75.23,57.93 75.07,58.09 75.07,58.25 75.38,58.56 75.38,58.73 75.21,58.89 75.05,58.89 74.74,58.58 74.58,58.58 74.42,58.74 74.42,58.9 74.73,59.21 74.73,59.37 74.57,59.53 74.4,59.53 74.1,59.22 73.93,59.22 73.77,59.39 73.77,59.55 74.08,59.86 74.08,60.02 73.92,60.18 73.76,60.18 73.45,59.87 73.29,59.87 72.44,60.71 72.44,78.33 73.32,79.2 73.32,79.48 76.28,82.44 78.73,82.44 79.16,82.87 80.33,82.87 82.6,85.14
  BOTTOM w0.089: v1(83.44,87.31) 83.52,87.31 CPU1.L31
  BOTTOM w0.216: v1(81.06,45.03) 80.87,45.03 80.57,44.73 80.57,42.91 DM1.194
