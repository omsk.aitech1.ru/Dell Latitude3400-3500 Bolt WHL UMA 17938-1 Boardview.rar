# Allegro board 17938-1.1228WZS1107.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EDP_VDD_EN: length 37
  TOP w0.102: v1(136.55,101.18) 136.82,101.45 137.1,101.45 138.13,100.42 138.13,100.21 138.55,99.79 138.55,97.41 143.37,92.59 v2(143.37,91.71) D5502.1
  L3 w0.102: v1(136.55,101.18) 136.55,102.43 134.86,104.12 127.49,104.12 125.68,102.31 124.95,102.31 124.26,101.63 123.77,101.63 121.89,99.75 118.63,99.75 v1(118.19,100.18)
  BOTTOM w0.102: CPU1.CG11 118.02,100.35 v1(118.19,100.18)
EMMC_CLK: length 38.3
  TOP w0.14: R6367.1 145.34,112.42 144.94,112.82 144.8,112.82 144.55,112.57 144.55,112.37 145.37,111.56 145.75,111.56 v1(145.98,111.78)
  BOTTOM w0.076: 132.74,96.42 132.51,96.42 132.41,96.31 126.3,96.31 125.77,96.84 125.15,96.84 125.1,96.89 123.93,96.89 123.79,97.03 123.28,97.03 123.16,96.92 122.44,96.92 122.34,96.97 122.34,96.97 122.16,97.07 122.15,97.07 CPU1.CP16
  BOTTOM w0.14: 132.74,96.42 134.27,96.42 134.85,97 135.57,97 142.76,104.19 v2(142.76,107.42) 142.76,108 142.88,108.13 143.46,108.13 144.53,109.19 144.53,109.73 144.81,110.01 145.29,110.01 145.75,110.46 145.75,111.56 v1(145.98,111.78) 145.98,111.79 145.82,111.95 R6336.1
EMMC_CLK_R: length 17.3
  TOP w0.14: R6367.2 146.68,111.92 147.04,111.56 v2(147.04,111.55) 149.5,111.55 149.51,111.55 149.86,111.55 149.87,111.55 150.09,111.55 150.73,110.9 155.65,110.9 155.78,111.03 155.78,111.79 155.65,111.91 v1(154.96,111.91) ; U6301.M6 156.72,114.95 156.49,115.17 v1(156.49,115.21)
  BOTTOM w0.14: v1(156.49,115.21) 155.81,114.52 155.81,114.24 155.67,114.1 155.29,114.1 155.15,113.96 155.15,113.68 155.29,113.54 155.67,113.54 155.81,113.4 155.81,112.76 v1(154.96,111.91)
EMMC_CMD: length 38.4
  TOP w0.14: v1(145.19,113.36) 145.32,113.23 R6366.1
  BOTTOM w0.076: 133.18,97.36 133.12,97.36 132.86,97.09 132.86,97.09 132.31,96.54 126.4,96.54 125.88,97.06 124.07,97.06 123.93,97.2 123.21,97.2 123.18,97.17 CPU1.CR16
  BOTTOM w0.14: R6334.2 145.78,113.36 v1(145.19,113.36) 144.72,113.36 144.6,113.23 144.6,112.6 144.72,112.47 145.06,112.47 145.19,112.35 145.19,111.92 145.06,111.79 144.39,111.79 144.25,111.65 144.25,111.37 144.39,111.23 145.08,111.23 145.19,111.12 145.19,110.69 145.06,110.57 144.1,110.57 143.97,110.44 143.97,109.43 v2(143.23,108.69) 142.55,108.69 142.2,108.34 142.2,104.42 135.13,97.36 133.18,97.36
EMMC_CMD_R: length 14.3
  TOP w0.14: v1(154.23,111.94) 154.23,111.62 154.08,111.46 150.97,111.46 150.29,112.14 148.03,112.14 147.78,112.39 147.78,112.96 147.52,113.22 147.52,113.22 147.51,113.23 R6366.2 ; U6301.M5 156.58,114.45 156.45,114.32 v1(156.45,114.04)
  BOTTOM w0.14: v1(156.45,114.04) 156.72,113.77 156.72,113.23 156.51,113.02 156.51,113.02 ; 156.51,113.02 v2(156.51,113.02) ; 156.51,113.02 156.51,112.67 155.3,111.46 154.71,111.46 v1(154.23,111.94)
EMMC_D0: length 47.5
  TOP w0.14: R6358.1 145.14,115.69 v1(145.14,115.7)
  L3 w0.127: v1(145.14,115.7) 145.47,116.03 146.38,116.03 149.79,112.62 149.79,111.23 v1(149.69,111.13)
  BOTTOM w0.076: 131.91,93.91 131.5,93.91 131.2,94.2 124.21,94.2 124.07,94.33 123.96,94.45 123.96,94.45 123.66,94.75 123.6,94.76 123.5,94.76 122.68,94.76 CPU1.CR20
  BOTTOM w0.14: v1(149.69,111.13) 150.11,110.7 150.11,109.94 150.01,109.83 150.01,109.83 149.66,109.48 149.66,108.79 146.72,105.85 v2(146.68,105.81) 146.68,102.74 146.67,102.73 146.67,102.56 138.31,94.2 136.49,94.2 136.2,93.91 131.91,93.91 ; v1(145.14,115.7) R6325.2
EMMC_D0_R: length 5.7
  TOP w0.14: U6301.A3 150.23,113.45 149.86,113.81 149.51,113.81 149.48,113.78 148.91,113.78 v2(147.65,115.04) 147,115.69 R6358.2
EMMC_D1: length 52.4
  TOP w0.14: R6359.1 145.47,117.32 144.66,116.51 v1(144.66,115.25)
  L3 w0.127: v1(144.66,115.25) 146.62,115.25 149.19,112.68 149.19,110.83 v1(149.66,110.36)
  BOTTOM w0.076: 131.78,94.18 131.46,94.18 131.22,94.43 124.3,94.43 123.84,94.89 123.61,94.93 123.57,94.93 122.48,94.93 122.4,94.88 122.1,94.88 122.02,94.9 122.02,94.91 121.91,94.94 121.84,94.97 121.56,94.99 121.05,94.99 CPU1.CM20
  BOTTOM w0.14: 131.78,94.18 135.97,94.18 136.25,94.46 137.98,94.46 146.25,102.74 v2(146.25,103.07) 146.25,105.97 146.26,105.98 149.24,108.97 149.24,109.65 149.59,110 149.59,110.01 149.66,110.08 v1(149.66,110.36) ; R6359.1 145.47,117.32 144.66,116.51 v1(144.66,115.25)
EMMC_D1_R: length 6.2
  TOP w0.14: R6359.2 146.76,117.26 147.78,116.25 v2(147.78,116.25) 148.97,115.06 149.55,115.06 150.67,113.95 U6301.A4
EMMC_D2: length 49.9
  TOP w0.14: v1(145.32,118.82) 145.52,119.03 R6360.1
  L3 w0.127: v1(145.32,118.82) 144.87,118.38 144.87,117.7 145.15,117.43 146.42,117.43 148.53,115.32 148.62,115.32 149.69,114.25 v1(149.69,113.39)
  BOTTOM w0.076: 131.88,94.46 131.6,94.46 131.41,94.66 124.68,94.66 124.56,94.77 124.24,94.77 123.97,95.04 123.62,95.09 122.44,95.09 122.36,95.05 122.13,95.05 121.97,95.09 CPU1.CN19
  BOTTOM w0.14: v1(149.69,113.39) 149.69,111.94 149.21,111.46 149.21,110.22 149.17,110.18 149.17,110.18 148.82,109.83 v2(148.82,109.14) 145.83,106.15 145.83,102.92 137.66,94.74 135.97,94.74 135.69,94.46 131.88,94.46 ; v1(145.32,118.82) 145.52,119.03 R6360.1
EMMC_D2_R: length 7.3
  TOP w0.14: U6301.A5 151.04,114.45 150.19,115.29 150.19,116.66 148.98,117.87 147.75,118.72 v2(147.68,118.72) 147.68,118.72 147.68,118.76 147.41,119.03 R6360.2
EMMC_D3: length 46.4
  TOP w0.14: R6361.1 145.15,114.03 145.14,114.04 v1(145.11,114.04)
  L3 w0.127: v1(145.11,114.04) 145.35,114.04 147.37,112.02 147.55,112.02 148,112.46 148.18,112.46 148.36,112.28 148.36,112.1 147.56,111.3 147.56,111.12 148.31,110.36 v1(148.72,110.36)
  BOTTOM w0.076: 132.01,94.74 131.65,94.74 131.49,94.91 125.05,94.91 124.91,95.05 124.91,95.38 124.66,95.63 124.16,95.63 123.95,95.42 122.96,95.42 122.76,95.44 122.73,95.44 122.68,95.45 122.57,95.49 122.55,95.5 122.55,95.5 122.49,95.53 122.32,95.55 122.12,95.55 122.07,95.53 121.78,95.53 121.71,95.55 121.33,95.6 121.08,95.6 120.94,95.47 CPU1.CM19
  BOTTOM w0.14: v1(148.72,110.36) 148.68,110.36 148.4,110.09 148.4,109.31 v2(145.41,106.32) 145.41,103.09 137.37,95.05 135.77,95.05 135.46,94.74 132.01,94.74 ; v1(145.11,114.04) R6329.2
EMMC_D3_R: length 6.2
  TOP w0.089: 150.9,112.57 151.22,112.57 151.34,112.7 151.75,112.7 U6301.B2
  TOP w0.14: 150.9,112.57 148.44,112.57 148.24,112.78 148.24,113.13 v2(147.78,113.59) 147.34,114.03 R6361.2
EMMC_D4: length 46.7
  TOP w0.14: v1(145.09,114.73) 145.22,114.87 R6362.1
  L3 w0.127: v1(145.09,114.73) 145.52,114.73 145.82,114.43 146.05,114.43 146.36,114.73 146.6,114.73 146.85,114.48 146.85,114.3 146.34,113.79 146.34,113.61 146.52,113.43 146.7,113.43 147.21,113.94 147.39,113.94 148.75,112.59 v1(148.75,111)
  BOTTOM w0.076: 132.03,95.02 131.85,95.02 131.74,95.13 125.4,95.13 124.72,95.81 124.1,95.81 123.88,95.59 122.97,95.59 122.77,95.6 122.76,95.6 122.71,95.62 122.53,95.69 122.4,95.71 122.33,95.72 122.07,95.72 122.03,95.7 121.85,95.7 121.68,95.72 121.54,95.87 CPU1.CN18
  BOTTOM w0.14: 132.03,95.02 135.26,95.02 135.61,95.38 137.1,95.38 144.99,103.27 v2(144.99,103.51) 144.99,106.49 147.98,109.49 147.98,110.27 148.72,111 v1(148.75,111) ; v1(145.09,114.73) 145.22,114.87 R6330.2
EMMC_D4_R: length 6.3
  TOP w0.089: U6301.B3 152,113.42 151.78,113.19 151.24,113.19 150.98,112.93 150.75,112.93
  TOP w0.14: R6362.2 147.22,114.87 149.15,112.93 150.75,112.93
EMMC_D5: length 46
  TOP w0.14: v1(145.14,116.33) 145.34,116.54 R6363.1
  L3 w0.127: v1(145.14,116.33) 145.14,116.92 145.27,117.04 146.26,117.04 v1(149.11,114.2)
  BOTTOM w0.076: 132.24,95.3 131.98,95.3 131.9,95.39 125.48,95.39 124.78,96.09 124.15,96.09 123.81,95.75 123.04,95.75 122.79,95.77 122.73,95.79 CPU1.CR18
  BOTTOM w0.14: R6363.1 145.34,116.54 v1(145.14,116.33) ; v1(149.11,114.2) 149.11,114.2 149.11,112.02 147.56,110.48 v2(147.56,109.66) 144.57,106.67 144.57,103.44 136.84,95.71 135.46,95.71 135.05,95.3 132.24,95.3
EMMC_D5_R: length 6.5
  TOP w0.089: 150.96,113.69 151.75,113.69 U6301.B4
  TOP w0.14: R6363.2 146.85,116.54 148.75,114.63 149.48,114.63 150.42,113.69 150.96,113.69
EMMC_D6: length 47.3
  TOP w0.14: v1(145.32,117.89) 145.62,118.19 R6364.1
  L3 w0.127: v1(145.32,117.89) 146.53,117.89 148.55,115.86 149.44,115.86 v1(149.53,115.95)
  BOTTOM w0.076: CPU1.CP18 122.3,96.14 122.31,96.14 122.45,96.2 122.82,96.2 123.11,95.92 123.74,95.92 124.15,96.32 124.88,96.32 125.58,95.62 131.77,95.62 131.8,95.58 132.21,95.58
  BOTTOM w0.14: R6364.1 145.62,118.19 v1(145.32,117.89) ; v1(149.53,115.95) 148.62,115.04 148.62,112.13 147.15,110.65 147.15,109.83 v2(144.15,106.84) 144.15,103.61 136.58,96.04 135.26,96.04 134.8,95.58 132.21,95.58
EMMC_D6_R: length 7.2
  TOP w0.089: U6301.B5 151.75,114.2 150.83,114.2 150.63,114.4
  TOP w0.14: R6364.2 147.07,118.19 147.73,117.53 147.73,117.53 147.79,117.47 v2(147.79,117.47) 147.79,117.46 148.06,117.12 148.59,116.05 149.18,115.47 149.56,115.47 150.63,114.4
EMMC_D7: length 48.1
  TOP w0.14: v1(145.29,119.51) R6365.1
  L3 w0.127: v1(145.29,119.51) 146.41,118.9 v1(149,116.31)
  BOTTOM w0.076: 132.74,95.86 132.31,95.86 132.3,95.85 125.63,95.85 124.98,96.5 124.1,96.5 123.67,96.08 123.18,96.08 122.89,96.37 122.41,96.37 122.28,96.31 122.26,96.31 122.21,96.28 121.31,96.28 120.83,96.07 CPU1.CM18
  BOTTOM w0.14: R6333.2 145.81,119.83 145.49,119.51 v1(145.29,119.51) ; v1(149,116.31) 148.2,115.24 148.2,112.3 146.73,110.82 146.73,110.01 143.74,107.02 v2(143.74,104.45) 143.74,103.79 136.34,96.39 135.18,96.39 134.65,95.86 132.74,95.86
EMMC_D7_R: length 8.6
  TOP w0.089: 151.14,114.79 151.23,114.7 151.75,114.7 U6301.B6
  TOP w0.14: 151.14,114.79 150.48,115.45 150.48,117.19 v2(147.73,119.94) 147.62,119.83 R6365.2
EMMC_RCLK: length 42.9
  TOP w0.14: R6368.1 145.01,120.02 144.73,119.74 v2(144.73,119.69) 144.73,118.47 v1(144.34,117.67)
  BOTTOM w0.076: 132.79,97.46 132.63,97.3 132.63,97.17 132.24,96.78 126.52,96.78 125.96,97.33 124.23,97.33 124.03,97.43 122.45,97.43 122.39,97.4 122.09,97.4 121.85,97.49 121.84,97.5 121.8,97.51 121.13,97.51 120.88,97.41 CPU1.CM16
  BOTTOM w0.14: 132.79,97.46 132.92,97.59 134.57,97.59 141.64,104.66 R6335.1 141.83,109.83 141.83,110.36 142.67,111.2 142.67,111.91 143,112.24 143.83,112.24 144.04,112.45 144.04,113.35 144.03,113.36 144.03,115.88 144.02,115.89 143.99,116.84 143.99,117.31 v1(144.34,117.67)
EMMC_RCLK_R: length 13
  TOP w0.127: 150.93,117.53 150.93,117.5 v1(150.96,117.48)
  TOP w0.14: R6368.2 147.82,120.64 150.93,117.53 ; U6301.H5 155,115.28 155.27,115.54 v1(155.27,115.62)
  BOTTOM w0.14: v1(155.27,115.62) 155.29,115.62 155.74,116.06 155.74,116.44 155.39,116.79 v2(151.74,116.79) 151.06,117.48 v1(150.96,117.48)
EMMC_RCOMP: length 6.2
  TOP w0.203: v1(120.17,97.03) 120.88,97.03 122.72,98.87 122.72,99.26 123.13,99.67 v2(123.24,99.67) 123.37,99.67 R2108.1
  BOTTOM w0.203: CPU1.CK15 120.12,97.06 120.17,97.03 v1(120.17,97.03)
EMMC_RESET#: length 19.7
  TOP w0.14: Q6302.D 151.08,106.81 151.5,107.23 v2(155.86,107.23) 156.54,107.91 v1(156.54,108.61) ; U6301.K5 155.5,113.95 v1(153.7,113.95)
  BOTTOM w0.14: v1(153.7,113.95) 153.04,113.95 152.33,114.66 R6343.2 152.18,114.65 R2125.2 R6337.1 152.85,113 153.29,112.55 153.29,111.65 154.42,110.52 155.13,110.52 156.54,109.1 v1(156.54,108.61)
EMMC_RST_N: length 46.4
  BOTTOM w0.076: CPU1.CN16 121.62,96.91 121.69,96.87 122.18,96.87 122.26,96.83 122.4,96.75 123.23,96.75 123.35,96.87 123.67,96.87 123.85,96.69 125.02,96.69 125.64,96.07 132.47,96.07 132.54,96.14 132.74,96.14
  BOTTOM w0.14: 132.74,96.14 134.45,96.14 135,96.7 135.49,96.7 135.56,96.78 136.13,96.78 143.32,103.96 143.32,107.19 146.31,110.18 146.31,111 147.78,112.47 147.78,116.13 148.68,117.03 149.85,117.03 v2(150.56,116.33) 150.56,114.15 150.87,113.83 R2125.1
EQ0: length 2.4
  TOP w0.102: U7101.38 v1(19.31,104.39)
  BOTTOM w0.102: R7143.1 19.44,104.52 v1(19.31,104.39) 19.25,104.45 R7142.2
EQ1: length 2.5
  TOP w0.102: U7101.35 v1(19.31,105.59)
  BOTTOM w0.102: R7141.1 19.59,105.31 v1(19.31,105.59) 18.96,105.59 R7140.2
ESPI_ALERT#: length 7
  TOP w0.14: v1(113.47,89.3) 113.93,89.76 113.93,90.09 114.4,90.56 114.55,90.6 117.64,90.6 v2(117.84,90.8) 118.3,90.33 R1821.2
  BOTTOM w0.089: v1(113.47,89.3) CPU1.BV28
ESPI_CLK: length 161.5
  TOP w0.14: U2401.57 34.75,57.46 v2(34.86,57.36) 34.77,57.27 34.25,57.27 v1(34.17,57.35)
  L3 w0.127: v1(114.08,80.47) 114.12,80.52 115.52,80.52 115.84,80.2 122.62,80.2 122.66,80.16 122.67,80.16 126.37,76.46 128.81,76.46 v1(128.96,76.3)
  L4 w0.127: v1(147.71,61.08) 147.69,61.08 147.68,61.07 147.01,61.07 144.47,63.61 143.68,65.76 143.29,66.15 130.56,74.75 129.74,75.57 129.73,75.57 129.1,76.19 129.08,76.19 v1(128.96,76.3)
  BOTTOM w0.14: EC1801.1 116.28,78.67 114.78,80.17 R1805.2 114.19,80.36 v1(114.08,80.47) ; v1(147.71,61.08) 147.25,60.63 140.88,60.63 111.97,62.69 108.93,63.75 94.86,63.75 75.54,59.92 75.51,59.92 60.93,58.84 58.68,58.84 58.55,58.83 56.53,58.83 44.17,57.89 40.88,57.28 35.76,57.28 35.46,57.58 34.49,57.58 34.25,57.35 v1(34.17,57.35)
ESPI_CLK_CON: length 2.3
  BOTTOM w0.089: DBG1.2 58.13,72.01 TP6801.1
ESPI_CS#: length 162.5
  TOP w0.14: U2401.58 35.15,59.31 35.54,59.7 35.54,60.78 35.08,61.24 v1(35.08,61.39)
  L4 w0.089: 116.06,86.23 115.8,86.49 115.8,87.74 115.83,87.77 115.83,88.23 115.83,88.23 115.83,88.47 115.79,88.5 115.79,88.8 v1(115.29,89.3)
  L4 w0.127: 116.06,86.23 116.9,86.03 118.05,85.98 118.94,86.02 119.01,86.03 119.28,85.93 120.3,85.89 123.17,85.7 123.59,85.44 127.64,80.23 128.06,79.72 130.93,76.85 131.2,76.85 132.53,75.52 132.82,75.31 135.82,73.04 135.82,73.04 135.89,72.99 138.95,70.93 142.4,68.59 144.3,67.31 144.45,67.23 145.67,66.01 145.67,65.95 146.78,63.32 146.78,62.05 v1(146.78,62.04)
  BOTTOM w0.089: CPU1.CA28 v1(115.29,89.3)
  BOTTOM w0.14: v1(35.08,61.39) 35.58,61.39 38.85,58.12 40.54,58.12 43.57,58.84 43.85,58.86 44.16,58.93 52.94,59.47 72.22,60.76 75.46,60.76 75.54,60.77 93.27,64.29 94.74,64.58 94.84,64.6 94.86,64.6 95.05,64.64 109.38,64.64 111.6,63.87 141.48,61.65 146.38,61.65 v1(146.78,62.04)
ESPI_CS#_CON: length 2.5
  BOTTOM w0.089: TP6803.1 61.13,71.5 DBG1.5
ESPI_IO0: length 142.2
  TOP w0.14: v1(128.65,76.91) 128.65,76.91 128.65,76.74 RN1806.8 ; U2401.59 35.55,57.52 36.25,56.83 36.25,56.69 v2(36.55,56.39) 36.99,55.95 39.02,55.95 40.31,57.25 40.31,59.61 v1(41.12,60.41)
  L4 w0.127: v1(128.65,76.91) 129.37,77.48 129.93,77.48 130.5,76.91 130.51,76.91 130.82,76.6 131.1,76.6 132.37,75.33 135.74,72.78 144.34,66.98 145.42,65.9 146.31,63.78 v1(146.31,62.51)
  BOTTOM w0.14: v1(146.31,62.51) 145.91,62.1 141.64,62.1 111.74,64.2 109.49,64.92 95.03,64.92 94.93,64.9 94.9,64.9 94.69,64.86 75.95,61.14 75.92,61.14 75.74,61.1 75.73,61.1 75.5,61.05 75.42,61.05 75.41,61.04 65.69,61.04 61.79,60.99 v1(41.12,60.41)
ESPI_IO0_CON: length 2.1
  BOTTOM w0.089: TP6807.1 65.13,72.53 DBG1.9
ESPI_IO1: length 139.4
  TOP w0.14: v2(130.36,76.61) v1(129.72,76.29) 129.4,76.03 129.37,76.03 129.22,75.89 128.91,75.64 127.58,75.64 127.46,75.76 RN1806.7 ; U2401.60 35.95,57.52 37.24,56.23 38.9,56.23 40.03,57.36 40.03,58.95 v1(39.77,59.22)
  L4 w0.127: v1(129.72,76.29) 129.75,76.28 129.75,76.27 130.88,75.14 143.62,66.54 144.22,65.94 144.89,64.11 144.89,63.93 v1(144.89,63.93)
  BOTTOM w0.14: v1(39.77,59.22) 39.77,60 39.76,60 39.76,60.38 39.77,60.38 39.77,60.55 40.81,61.59 50.08,61.7 65.34,61.87 65.34,61.88 75.06,61.88 75.07,61.89 94.51,65.74 94.53,65.76 109.96,65.76 111.88,65.21 138.38,63.81 140.83,63.64 142.74,63.5 143.1,63.48 144.45,63.48 v1(144.89,63.93)
ESPI_IO1_CON: length 2.2
  BOTTOM w0.089: DBG1.8 64.13,72.31 TP6806.1
ESPI_IO2: length 140.9
  TOP w0.14: v1(131.1,75.96) 129.8,75.84 v2(129.52,75.66) 129.07,75.36 127.36,75.36 127.04,75.68 127.04,75.73 126.97,75.79 RN1806.6 ; U2401.61 36.35,57.51 37.36,56.51 38.79,56.51 39.75,57.47 39.75,58.27 v1(39.27,58.75)
  L4 w0.127: v1(131.1,75.96) 135.51,72.64 135.51,72.63 144.1,66.83 145.13,65.8 145.84,64.15 145.84,62.99 v1(145.84,62.98)
  BOTTOM w0.14: v1(39.27,58.75) 39.96,58.75 40.67,59.46 40.67,60.23 40.66,60.23 40.66,60.6 41.02,60.96 51.65,61.15 65.57,61.32 65.57,61.32 75.29,61.32 75.31,61.33 75.47,61.33 75.6,61.35 75.6,61.36 75.89,61.42 75.92,61.42 94.63,65.13 94.92,65.2 94.96,65.2 109.61,65.2 111.74,64.53 141.81,62.56 145.42,62.56 v1(145.84,62.98)
ESPI_IO2_CON: length 2.3
  BOTTOM w0.089: DBG1.7 63.13,72.04 TP6805.1
ESPI_IO3: length 143.7
  TOP w0.14: U2401.62 36.75,57.51 37.43,56.84 38.72,56.84 39.35,57.46 v2(39.35,57.61) 39.35,58.03 38.82,58.56 38.82,58.93 39.68,59.79 39.82,59.79 v1(40.22,60.19) ; v1(129.54,77.04) 129.01,78.44 128.51,78.93 126.85,79.16 126.32,79.16 125.94,78.78 125.94,76.45 126.25,76.14 RN1806.5
  L4 w0.127: v1(129.54,77.04) 129.6,77.04 129.9,76.73 129.9,76.73 130.17,76.47 130.17,76.47 130.46,76.17 130.66,75.77 130.92,75.51 132.05,74.66 143.94,66.64 144.72,65.85 145.34,64.18 v1(145.34,63.47)
  BOTTOM w0.14: v1(145.34,63.47) 145.3,63.47 144.85,63.02 142.11,63.02 111.77,64.87 109.72,65.48 94.65,65.48 75.21,61.63 75.18,61.6 65.46,61.6 65.45,61.59 50.96,61.43 50.2,61.42 40.92,61.25 40.22,60.55 v1(40.22,60.19)
ESPI_IO3_CON: length 2.4
  BOTTOM w0.089: TP6804.1 62.13,71.77 DBG1.6
ESPI_RESET#: length 163.6
  TOP w0.14: v1(33.44,59.75) 33.15,59.46 U2401.53
  L4 w0.127: v1(115.29,89.94) 116.37,89.73 116.68,89.42 116.68,88.45 116.69,88.45 116.69,86.55 116.96,86.28 117.77,86.24 119.13,86.27 119.41,86.16 123.26,85.96 123.85,85.59 124.53,84.72 128.57,79.57 131.03,77.11 131.31,77.11 132.7,75.71 136.06,73.18 144.43,67.53 144.65,67.41 145.95,66.11 147.22,63.05 v1(147.22,61.59)
  BOTTOM w0.089: CPU1.CA27 v1(115.29,89.94)
  BOTTOM w0.14: v1(147.22,61.59) 146.82,61.19 141.41,61.19 111.54,63.57 109.26,64.36 95.45,64.36 95.17,64.31 94.8,64.31 94.8,64.31 94.41,64.23 75.68,60.52 75.49,60.48 73.99,60.48 44.2,58.65 40.65,57.84 36.09,57.84 34.18,59.75 v1(33.44,59.75)
ESPI_RST#_CON: length 2.6
  BOTTOM w0.089: TP6802.1 60.13,71.23 DBG1.4
EXT_PWR_GATE#: length 4
  BOTTOM w0.076: 115.89,83.87 CPU1.CC37
  BOTTOM w0.102: R1731.2 116.39,80.41 116.39,82.18 115.88,82.69 115.88,83.86 115.89,83.87
FALL_INT2: length 4.6
  TOP w0.102: 143.31,83.16 143.31,83.16 Q7001.2 ; 143.31,83.16 142.91,83.16 142.66,83.41 Q7001.3 ; 143.31,83.16 144.16,83.16 144.62,83.62 v2(144.83,83.62) R7010.2
FAN1_PWM: length 175.4
  TOP w0.102: RN2601.2 30.96,54.62 30.33,55.25 EC2601.1 30.58,55.56 30.58,56.08 30.32,56.35 30.32,57.45 30.76,57.89 U2401.47 30.76,59.51 31.24,59.99 31.24,64.53 30.63,65.14 28.47,65.14 25.72,67.89 25.72,69.82 v1(26.08,70.19)
  BOTTOM w0.102: v1(26.08,70.19) 26.22,70.05 26.94,70.05 27.61,69.38 28.15,69.38 28.48,69.7 28.48,69.8 28.87,70.2 29.14,70.2 29.25,70.09 29.25,70.08 29.71,69.63 29.71,69.63 29.95,69.39 31.43,69.39 31.6,69.22 31.86,69.22 41.12,69.22 41.89,68.45 43.08,68.45 43.53,68.01 45.51,68.01 49.17,64.35 73.61,64.35 78.22,68.96 122.2,68.96 124.1,67.06 146.63,67.06 149.5,64.19 153.29,64.19 153.85,64.75 153.85,68.18 155.27,69.6 156.55,69.6 157.56,70.61 157.56,72.88 153.95,76.48 v2(153.95,78.21) 153.95,80.95
FAN1_TACH: length 4.9
  TOP w0.102: U2401.40 27.95,57.77 27.83,57.65 26.99,57.65 26.77,57.43 R2430.1 25.89,56.98 v2(25.82,56.91) 25.82,56.4 26.31,55.92
FAN_PWM1_C: length 13.4
  TOP w0.102: v1(161.94,87.34) 161.29,86.69 AFTP2602.1
  BOTTOM w0.102: R2614.2 153.95,82.41 154.73,83.19 154.95,83.19 155.61,83.85 157.34,83.85 v2(157.59,84.1) 158.82,85.33 FAN1.4 160.23,85.7 161.8,87.28 161.88,87.28 v1(161.94,87.34)
FAN_TACH1: length 181.9
  TOP w0.102: EC2602.1 32.19,54.77 v1(32.19,54.67) 32.19,54.29 v2(31.96,54.05) 31.7,53.79 RN2601.1 30.53,53.34 27.79,53.34 27.79,53.34 27.78,53.34 27.34,53.77 25.89,53.77 25.3,54.36 D2403.K
  L4 w0.102: v1(25.06,64.28) 24.63,64.28 24.35,64.56 24.35,65.6 25.95,67.21 26.38,67.21 28.46,69.29 28.46,69.8 28.79,70.13 28.81,70.13 28.83,70.15 30.29,70.15 v1(30.31,70.13)
  BOTTOM w0.102: R2613.1 153.6,79.17 153.6,76.41 157.25,72.75 157.25,70.73 156.42,69.9 155.14,69.9 153.55,68.31 153.55,64.88 153.17,64.5 149.63,64.5 146.76,67.36 124.23,67.36 122.33,69.27 78.09,69.27 73.48,64.65 49.3,64.65 44.74,69.21 44.59,69.21 44,69.8 41.95,69.8 41.89,69.74 31.8,69.74 31.41,70.13 v1(30.31,70.13) ; v1(32.19,54.67) 32.18,54.66 31.26,54.66 29.64,56.29 28.02,56.29 27.72,56.59 27.72,56.76 27.72,56.76 27.72,62.42 25.87,64.28 v1(25.06,64.28)
FAN_TACH1_C: length 14.4
  TOP w0.102: v1(161.44,87.77) 160.81,87.14 AFTP2601.1
  BOTTOM w0.102: v1(161.44,87.77) 161.38,87.77 160.31,86.7 FAN1.3 158.18,86.7 157.87,86.4 157.87,85.21 157.89,85.2 157.89,85.08 156.95,84.15 155.48,84.15 154.82,83.49 154.6,83.49 153.42,82.31 153.42,80.21 R2613.2
FFS_INT1: length 35.6
  TOP w0.102: v1(118.17,92.92) 118.17,92.71 118.5,92.37 v2(118.54,92.37) ; U7001.12 142.12,80.82 141.5,81.44 v1(141.5,81.5)
  L3 w0.102: v1(141.5,81.5) 141.5,81.52 139.68,83.34 137.77,83.34 v1(137.34,82.91)
  L4 w0.102: v1(137.34,82.91) 136.7,83.55 134.41,83.55 133.98,83.98 133.98,85.08 132.61,86.45 132.1,86.45 131.95,86.3 131.35,86.3 129.17,88.48 124.98,88.48 124.31,89.15 124.31,89.55 123.51,90.35 121.42,90.35 120.5,91.26 117.64,91.26 117.15,91.75 117.15,92.27 117.8,92.92 v1(118.17,92.92)
  BOTTOM w0.102: v1(118.17,92.92) 118.19,92.97 CPU1.CG22
FFS_INT2: length 44.4
  TOP w0.102: U7001.11 142.62,79.51 143.29,80.18 143.49,80.18 v2(143.64,80.34) 143.64,81.05 R7011.1 143.31,81.38 Q7001.5 143.31,82.64 143.59,82.93 v1(144.64,82.93) 145.35,82.93 R2044.2
  L4 w0.102: v1(118.39,99.05) 118.72,98.72 118.85,98.72 118.9,98.67 119.24,98.67 119.25,98.68 119.92,98.68 119.96,98.72 121.15,98.72 121.91,99.47 123.6,99.47 126.07,97 128.1,97 128.6,97.51 128.6,97.89 129.06,98.35 131.35,98.35 131.94,97.75 132.39,97.75 132.64,97.5 132.64,96.9 137.14,92.4 138.1,92.4 138.35,92.15 138.35,91.45 142.52,87.27 142.52,86.07 143.01,85.59 143.01,84.89 144.64,83.25 v1(144.64,82.93)
  BOTTOM w0.102: v1(118.39,99.05) 118.4,99.04 118.4,99.03 118.44,99.11 118.66,99.65 CPU1.CH12
FFS_INT2_Q: length 67.7
  TOP w0.102: v1(160.77,36.93) 160.94,36.77 v2(160.94,36.35) 160.48,36.35 160.32,36.51 R7014.2 ; v1(146.15,79.93) 146.15,80.35 145.02,81.47 144.18,81.47 143.96,81.69 Q7001.6
  L4 w0.102: v1(146.15,79.93) 146.91,79.16 146.91,78.6 147.35,78.17 147.35,73.84 153.98,67.21 153.98,66.48 154.61,65.85 154.61,63.45 159.29,58.77 160.13,58.77 168.96,49.93 168.96,46.59 168.84,46.46 168.84,43.21 169.29,42.76 169.29,41.4 169.6,41.1 169.6,40.1 167.93,38.43 163.47,38.43 161.97,36.93 v1(160.77,36.93)
  BOTTOM w0.102: HDD1.9 160.15,37.55 v1(160.77,36.93)
FLT_NXP3290: length 2.3
  TOP w0.102: U7403.A4 43.13,121.94 42.05,120.87 R7414.2
FP1_USB20_CON_N: length 21.7
  BOTTOM w0.127: FP1.3 220.95,62.13 220.78,61.96 218.64,61.96 217.92,62.68 212.5,62.68 211.22,61.39 209.32,61.39 208.91,60.98 208.91,57.85 208.4,57.34 208.4,56.43 208.12,56.15 207.83,56.15 207.83,56.15 206.81,56.15 ED9202.6 206.57,56.37 206.34,56.15 205.78,56.15 205.49,56.44
FP1_USB20_CON_P: length 22.5
  BOTTOM w0.127: FP1.4 221.45,62.28 220.88,61.72 218.54,61.72 217.82,62.43 212.6,62.43 211.32,61.15 209.42,61.15 209.15,60.88 209.15,57.75 208.65,57.24 208.65,56.73 ED9202.1 208.83,56.2 208.51,56.2 208.22,55.91 207.93,55.91 207.93,55.91 205.77,55.91 205.49,55.63
FP1_USB20_N: length 137.6
  TOP w0.127: v2(204.48,56.3) v1(203.94,56.47)
  L4 w0.114: v1(118.34,104.28) 118.21,104.15 118.03,104.15 117.81,104.36 117.81,104.88 118.28,105.35 118.28,108.51 118.08,108.71 118.08,114.17 118.92,115.02 122.17,115.02 123.71,113.47 135.32,113.47 136.38,112.41 136.38,107.37 140.97,102.78 140.97,99.04 154.74,85.27 154.74,83.71 154.26,83.23 154.26,79.78 159.99,74.05 159.99,72.22 163.05,69.15 163.45,69.15 168.67,63.93 168.67,63.5 169.11,63.06 169.11,62.02 172.97,58.15 176.26,58.15 179.08,55.33 189.14,55.33 190.92,57.12 195.04,57.12 195.76,56.4 201.7,56.4 202.07,56.04 203.81,56.04 203.94,56.16 v1(203.94,56.47)
  BOTTOM w0.127: v1(118.34,104.28) 117.91,104.36 117.53,104.36 117.4,104.23 117.4,104.12 117.6,103.92 CPU1.CG5 ; R9209.2 204.18,55.99 204.1,55.99 203.94,56.16 v1(203.94,56.47)
FP1_USB20_P: length 136.9
  TOP w0.127: v1(203.28,56.49) v2(202.72,56.47)
  L4 w0.114: v1(203.28,56.49) 203.07,56.29 203.05,56.26 202.16,56.26 201.8,56.63 195.85,56.63 195.13,57.35 190.83,57.35 189.04,55.56 179.18,55.56 176.36,58.38 173.07,58.38 169.33,62.12 169.33,63.16 168.9,63.59 168.9,64.02 163.54,69.38 163.15,69.38 160.21,72.31 160.21,74.15 154.49,79.88 154.49,83.14 154.97,83.62 154.97,85.37 141.2,99.13 141.2,102.87 136.6,107.47 136.6,112.51 135.41,113.7 123.81,113.7 122.26,115.25 118.83,115.25 117.85,114.27 117.85,108.62 118.05,108.42 118.05,105.45 117.58,104.97 117.58,104.27 v1(118.29,103.56)
  BOTTOM w0.127: CPU1.CG6 v1(118.29,103.56) ; v1(203.28,56.49) 203.34,56.43 203.34,56.41 204,55.75 204.5,55.75 R9210.2
FP_3D3V: length 313.3
  TOP w0.254: v1(19.89,56.85) 20.1,56.85 20.54,57.29 R2458.1 ; R9211.1 213.14,63.57 213.32,63.39 213.79,63.39 C9201.1 214.34,63.4 C9202.1 ; v1(218.9,59.95) 218.87,59.98 218.87,62.02 218.08,62.81 v2(214.99,62.81) 214.61,62.81 214.34,63.08 C9202.1 ; Q9201.D 223.65,65.95 224.25,65.35 224.25,64.64 223.98,64.37 222.89,64.37 v1(222.27,64.99) 221.86,64.99 221.22,65.63 219.45,65.63 217.24,63.41 C9202.1
  L2SGND w0.254: v1(36.76,26.17) 34.16,28.77 29.7,28.77 28.77,29.7 21.38,29.7 20.81,30.28 20.81,30.94 20.96,31.09 v1(20.99,31.09)
  L3 w0.254: v1(206.35,31.16) 206,31.16 205.84,31.32 197.75,31.32 197.51,31.09 189.87,31.09 189.36,31.59 176.01,31.59 174.91,32.69 170.96,32.69 169.46,31.2 131.75,31.2 v1(131.22,31.73)
  L4 w0.254: v1(20.99,31.09) 20.83,31.25 20.53,31.25 20.08,31.7 20.08,35.76 19.52,36.31 19.52,39.27 19.08,39.71 19.08,40.24 18.63,40.69 18.63,49.73 19.3,50.39 19.3,56.57 19.57,56.85 v1(19.89,56.85) ; v1(215.22,57.23) 215.22,56.92 214.54,56.25 208.9,56.25 v1(208.12,55.46)
  L5SGND w0.254: v1(131.22,31.73) 130.7,32.25 130.19,32.25 128.36,34.08 124.64,34.08 121.76,31.2 121.18,31.2 121.17,31.21 120.75,31.21 120.45,30.91 120.28,30.32 119.19,29.66 118.52,29.66 116.59,28.38 109.16,28.38 108.66,27.88 93.5,27.88 92.75,28.63 91.75,28.63 90.69,27.57 39.16,27.57 37.77,26.17 v1(36.76,26.17) ; v1(206.35,31.16) 212.24,31.16 213.69,32.61 213.69,35.34 213.31,35.72 213.31,38.44 213.74,38.87 217.62,38.87 217.8,38.69 218.21,38.69 218.56,39.04 218.56,39.96 219.45,40.85 220.24,40.85 221.32,41.94 221.32,49.74 221.02,50.04 221.02,59.71 222.38,61.07 222.38,64.88 v1(222.27,64.99)
  BOTTOM w0.254: v1(222.27,64.99) 221.61,64.99 219.95,63.33 FP1.1 ; v1(215.22,57.23) 216.5,57.23 216.6,57.33 216.7,57.33 217.24,57.87 217.24,58.29 v1(218.9,59.95) ; ED9202.5 208.08,55.42 v1(208.12,55.46)
FP_EN#: length 9.9
  TOP w0.102: Q9201.G 223.38,68.38 222.73,68.38 222.08,67.73 C9203.1 221.52,67.74 R9212.2 221.24,68.38 221.09,68.24 221.09,66.46 v2(221.57,65.99) 221.97,65.59 223.06,65.59 223.32,65.33 223.32,65.33 Q9202.D
FPR_SCAN#: length 295.8
  TOP w0.089: v1(27.13,26.82) 26.97,26.98 v2(26.97,28.27) 26.97,28.99 v1(26.93,29.03) ; U2401.42 28.76,57.89 28.64,57.77 28.64,56.86 27.49,55.72 27.49,54.89 26.82,54.22 26.19,54.22 25.07,55.33 25.07,57.05 24.47,57.65 24.47,58.22 24.02,58.67 21.62,58.67 21.36,58.4 R2458.2 21.36,57.25 20.29,56.19 v1(19.89,56.19)
  L3 w0.089: v1(19.89,56.19) 19.89,56.08 20.32,55.65 20.32,52.46 20.06,52.2 20.06,50.25 19.26,49.46 19.26,45.7 19.26,45.36 19.26,45.16 21.25,43.17 21.25,42.2 22.59,40.85 22.59,38.09 21.89,37.39 21.89,31.9 22,31.8 24.34,29.46 26.5,29.46 v1(26.93,29.03) ; v1(27.13,26.82) 27.78,26.17 33.13,26.17 35.37,28.41 41.37,28.41 41.41,28.41 41.94,28.41 42.76,29.23 45.21,29.23 46.05,28.39 55.41,28.39 55.84,28.81 73.93,28.81 78.13,33.02 89.82,33.02 90.17,33.37 91.53,33.37 92.28,34.12 93.12,34.12 93.74,34.12 94.06,34.45 101.06,34.45 101.95,35.33 103.63,35.33 106.01,37.72 106.75,37.72 107.01,37.98 107.78,37.98 108.54,37.98 108.86,38.29 110.67,40.11 119.5,40.11 120.54,39.07 120.83,39.07 123.75,39.07 126.16,36.66 126.92,36.66 131.07,32.51 136.14,32.51 136.77,31.88 137.41,31.88 138.42,32.88 146.07,32.88 147.28,31.67 169.26,31.67 170.87,33.28 175.13,33.28 176.34,32.07 189.56,32.07 190.07,31.56 197.32,31.56 197.58,31.83 208.44,31.83 209.07,31.2 212.13,31.2 215.09,34.16 221.14,34.16 222.58,35.6 224.75,35.6 225.45,36.31 225.45,41.79 223.37,43.87 223.37,61.55 223.55,61.72 223.55,63.4 v1(223.98,63.83)
  BOTTOM w0.089: FP1.7 222.95,63.06 223.24,63.35 223.5,63.35 v1(223.98,63.83)
GPD11/LANPHYPC: length 35.4
  L3 w0.102: v1(113.78,81.04) 114.24,81.04 114.56,80.72 115.61,80.72 115.87,80.46 120.09,80.46 120.12,80.43 121.39,80.43 121.61,80.65 122.91,80.65 126.58,76.98 128.03,76.98 128.4,77.34 128.86,77.34 128.98,77.47 130.7,77.47 130.79,77.38 130.79,77.37 131.04,77.12 131.05,77.12 131.06,77.1 131.54,77.1 v1(132.08,77.65)
  BOTTOM w0.076: CPU1.BU34 112.44,85.43 112.46,85.24 112.58,85.12 112.58,84.84 112.61,84.78 112.61,84.48 112.6,84.48 112.59,84.45 112.58,84.43 112.58,84.19 112.6,84.14 112.76,83.98 112.76,83.23
  BOTTOM w0.089: 112.76,83.23 112.76,82.74 113,82.5 113.21,82.5
  BOTTOM w0.102: v1(132.08,77.65) 132.62,78.18 v2(132.83,78.18) 133.03,78.18 134.53,76.68 137.99,76.68 139.01,77.7 139.01,78.4 R1721.2 ; v1(113.78,81.04) 113.78,81.06 113.69,81.15 113.69,82.02 113.21,82.5
GPD_7: length 35.6
  L3 w0.102: v1(131.26,78.19) 130.97,77.9 128.86,77.9 128.69,77.74 128.24,77.74 127.87,77.37 126.74,77.37 123.06,81.05 121.49,81.05 121.24,80.8 120.27,80.8 119.89,81.18 114.77,81.18 v1(114.18,81.76)
  BOTTOM w0.076: CPU1.BV35 113.08,84.51 113.23,84.36 113.23,83.43 113.58,83.08 113.58,82.51
  BOTTOM w0.102: 113.58,82.51 114.18,81.91 v1(114.18,81.76) ; v1(131.26,78.19) 131.24,78.2 131.24,78.41 134.29,81.46 134.75,81.46 134.95,81.66 v2(134.95,81.85) 134.48,82.31 134.48,83.03 134.64,83.19 134.89,83.19 135.02,83.32 135.89,83.32 136.25,82.95 136.25,82.68 136.71,82.22 138.92,82.22 139.2,82.5
GPP_E23_STRAP: length 18.7
  BOTTOM w0.102: CPU1.CN4 121.49,104.4 122.08,104.4 122.23,104.55 122.68,104.55 123.07,104.94 130.39,104.94 132.36,106.92 132.36,111.67 TP402.1
GPP_H1_SFRM: length 248.5
  TOP w0.089: R1913.2 36.55,106 36.78,105.77 v2(36.83,105.77) 37.16,106.1 v1(37.16,106.91)
  L4 w0.089: v1(148.58,60.24) 148.58,60.26 148.98,60.66 148.98,62.96 146.61,65.32 146.61,66.24 142.15,70.71 133.4,75.66 133.31,75.75 133.21,75.81 132.8,76.22 132.8,76.26 v1(132.57,76.5) ; v1(37.16,106.91) 37.7,106.38 37.7,98.78 39.17,97.31 39.17,95.84 39.47,95.54 39.47,80.64 38.71,79.88 38.71,78.56 39,78.28 39,76.97 37.68,75.65 24.03,75.65 23.37,74.98 23.37,74.41 22.81,73.86 21.71,73.86 20.57,72.72 20.25,72.72 19.69,72.17 19.69,70.43 19,69.74 18.5,69.74 18.15,69.39 18.15,66.92 17.65,66.42 v1(17.65,66.07)
  BOTTOM w0.089: v1(148.58,60.24) 148.28,59.94 111.99,59.94 108.71,63.22 94.94,63.22 90.03,58.31 89.9,58.3 56.75,58.3 56.6,58.15 50.32,57.66 36.3,56.16 34.61,56.16 33.64,57.13 33.64,57.21 32.52,58.33 32.52,62.24 30.85,63.92 28.16,63.92 25.83,66.25 25.47,66.25 24.84,66.87 22.24,66.87 21.51,66.14 21.51,66.14 21.23,65.87 17.85,65.87 v1(17.65,66.07) ; v1(132.57,76.5) 132.14,76.92 130.96,76.92 129.99,77.88 128.04,77.88 127.74,77.58 126.9,77.58 123.11,81.37 123.11,82.41 122.23,83.29 122.23,83.42 121.8,83.86 121.8,84.15 121.58,84.37 121.58,84.73 121.41,84.9 121.2,84.9 120.55,85.54 120.26,85.54 119.98,85.83 119.68,85.83 119.39,86.11 CPU1.CJ32
GPP_H2_CLKREQ0: length 250
  TOP w0.089: v1(37.16,107.54) 36.67,107.54 R1912.2 ; v2(19.31,68.12) 19.05,67.87 v1(18.67,67.87)
  L4 w0.089: v1(118.02,88.65) 118.43,89.07 119.24,89.07 119.76,88.54 120.51,88.54 121.49,87.56 128.85,87.56 132,84.4 132.01,84.4 133.33,83.09 133.33,79.76 134.77,78.32 135.65,78.32 139.03,74.94 139.95,74.94 148.05,66.84 148.05,65.92 150.75,63.22 v1(150.75,61.8) ; v1(37.16,107.54) 37.94,106.77 37.94,98.79 39.35,97.38 39.35,95.91 39.65,95.61 39.65,80.54 38.89,79.78 38.89,78.67 39.27,78.28 39.27,76.99 37.75,75.47 24.11,75.47 23.55,74.91 23.55,74.34 22.99,73.78 22.89,73.68 21.78,73.68 20.65,72.54 20.32,72.54 19.88,72.1 19.88,71.77 19.87,71.77 19.87,70.34 19.1,69.57 18.58,69.57 18.38,69.37 18.38,68.16 v1(18.67,67.87)
  BOTTOM w0.089: v1(118.02,88.65) 118.03,88.64 118.19,88.64 CPU1.CH29 ; v1(18.67,67.87) 18.69,67.87 19.7,67.87 19.75,67.92 20.63,68.81 21.19,68.81 21.66,68.33 22.19,68.33 22.37,68.51 22.89,68.51 23.35,68.05 25.33,68.05 25.93,67.46 28.67,67.46 28.88,67.25 30.28,67.25 30.58,66.95 30.58,66.82 32.52,64.88 34.1,64.88 34.94,64.04 39.31,64.04 40.93,65.67 42.47,65.67 43.52,64.62 45.87,64.62 48.08,62.41 48.23,62.41 48.23,62.41 74.71,62.41 79.41,67.1 121.43,67.1 123.33,65.2 141.72,65.2 142.75,64.17 142.89,64.17 143.1,64.17 143.85,64.17 144.56,64.88 145.69,64.88 148.77,61.8 v1(150.75,61.8)
GPP_H21: length 24.2
  L3 w0.102: v1(137.4,86.66) 136.14,87.92 127.37,87.92 127.34,87.89 122.46,87.89 120.35,89.99 v1(119.89,89.99)
  BOTTOM w0.102: R1522.2 138.31,86.54 137.67,85.91 137.49,85.91 v2(137.44,85.95) 137.4,85.99 v1(137.4,86.66) ; CPU1.CF25 117.75,90.98 119.37,90.98 119.89,90.46 v1(119.89,89.99)
GPP_H23: length 21.3
  L4 w0.102: v1(124.72,89.36) 125.13,88.95 129.11,88.95 130.88,87.17 132.18,87.17 134.25,85.09 134.25,84.32 v1(134.55,84.02)
  BOTTOM w0.076: CPU1.CM26 121,90.61 121.51,90.51 122.35,90.51 122.53,90.44 123.42,90.44
  BOTTOM w0.102: 123.42,90.44 124.01,89.84 124.13,89.84 124.62,89.36 v1(124.72,89.36) ; R1513.2 137.47,84.76 v2(137.37,84.66) 136.88,84.66 136.25,84.02 v1(134.55,84.02)
GPPC_H18_VCCIO_LPM: length 155.9
  TOP w0.089: v1(89.55,41.49) 89.36,41.49 v2(88.94,41.07) 88.94,40.95 89.14,40.74 R4034.1
  L3 w0.089: v1(89.55,41.49) 90.07,42.01 91.69,42.01 91.7,42 96.86,42 98.72,43.86 99.41,43.86 99.6,43.67 100.67,43.67 101.85,44.86 103.01,44.86 103.28,44.58 107.28,44.58 108.13,45.43 121.72,45.43 123.84,43.31 127.63,43.31 130.75,40.18 131.82,40.18 132.79,41.15 136.81,41.15 137.47,40.49 v1(137.47,40.41)
  L4 w0.089: v1(137.47,40.41) 149.67,40.41 150.94,39.14 156.62,39.14 156.65,39.17 159.25,39.17 159.85,39.77 160.99,39.77 161.26,40.04 161.26,40.57 164.6,43.91 164.6,49.93 158.38,56.16 158.21,56.16 151.52,62.85 151.52,63.31 148.7,66.13 148.7,67.09 140.23,75.55 139.38,75.55 138.41,76.51 138.41,77.22 137.78,77.86 137.78,78.39 138.51,79.12 138.51,81.81 137.87,82.46 136.53,82.46 136.22,82.77 136.22,82.94 135.8,83.35 134.33,83.35 133.77,83.92 133.77,85.02 132.53,86.25 132.18,86.25 132.03,86.1 131.26,86.1 129.07,88.29 124.9,88.29 123.9,89.28 v1(123.9,89.38)
  BOTTOM w0.089: v1(123.9,89.38) 123.78,89.51 123.03,89.51 122.89,89.65 122.89,89.71 122.63,89.97 122.08,89.97 CPU1.CN27
GPU_THM_SMBCLK: length 321.1
  TOP w0.14: U2401.12 23.12,68.09 22.83,68.38 22.28,68.38 21.75,67.84 v2(21.52,67.84) 21.34,67.84 21.01,68.17 v1(21.01,68.32) ; R2460.2 211.89,55.7 212.07,55.53 212.63,55.53 212.78,55.37 R2459.2 212.78,54.33 v1(213.01,54.1) ; Q5801.3 40.56,92.78 41,93.22 v1(41.24,93.22)
  L4 w0.127: v1(41.24,93.22) 40.99,92.97 40.99,76.7 37.71,73.43 25.22,73.43 23.95,72.15 23.95,71.61 23.22,70.88 23.22,70.31 22.89,69.99 21.75,69.99 21.1,69.34 21.1,68.41 v1(21.01,68.32) 21.01,67.83 20.59,67.41 20.59,67.37 19.88,66.66 19.88,65.32 16.27,61.72 15.86,61.72 15.14,61 15.14,50.54 14.38,49.78 14.38,48.59 12.07,46.28 12.07,41.38 13.85,39.6 14.48,39.6 15.06,39.02 15.06,35.46 15.17,35.34 15.17,31.7 21.7,25.18 28.28,25.18 28.82,25.71 32.53,25.71 36.19,29.36 42.01,29.36 42.82,30.18 53.16,30.18 53.7,30.72 74.3,30.72 77.05,33.47 100.4,33.47 101.41,32.46 104.72,32.46 112.87,40.61 119.77,40.61 121.28,39.1 122.01,39.1 124.44,36.67 127.34,36.67 130.41,33.61 133.47,33.61 135.21,31.86 139.84,31.86 140.34,31.36 170.07,31.36 170.83,32.12 172.21,32.12 172.51,31.83 172.51,31.82 173.05,31.28 182.1,31.28 183.13,32.31 186.44,32.31 189.28,35.15 189.28,35.97 190.06,36.74 190.63,36.74 190.93,37.05 190.93,37.12 191.01,37.2 191.01,37.23 191.03,37.25 191.03,38.61 192.14,39.72 192.14,40.02 192.42,40.3 193.17,40.3 193.18,40.31 195.79,40.31 195.8,40.31 197.99,40.31 198.13,40.17 199.64,40.17 201.61,42.14 203.03,42.14 204.94,40.23 206.73,40.23 207.17,40.67 207.17,41.35 207.58,41.77 208.08,41.77 208.68,42.37 209.61,42.37 210.75,43.52 210.75,46.45 212.42,48.12 212.42,53.56 212.96,54.1 v1(213.01,54.1)
GPU_THM_SMBDAT: length 329.7
  TOP w0.14: v1(20.45,67.9) 20.42,67.92 20.42,68.43 20.82,68.83 v2(22.28,68.83) 22.78,68.83 23.12,68.49 U2401.11 ; Q5801.6 39.1,94.14 39.1,95.33 39.35,95.58 40.75,95.58 41.05,95.88 41.99,95.88 42.25,95.62 42.25,95.19 v1(41.77,94.7) ; R2447.2 212.42,53.24 212.65,53.47 v1(212.96,53.47) 213.01,53.42 213.01,51.87 213.69,51.18 R2455.2
  L4 w0.127: v1(41.77,94.7) 41.2,94.7 40.74,94.24 40.74,76.81 37.61,73.68 25.08,73.68 23.66,72.26 23.66,71.72 22.97,71.03 22.44,71.03 20.81,69.41 20.81,68.78 20.45,68.41 v1(20.45,67.9) 20.22,67.67 20.22,67.36 19.62,66.76 19.62,65.43 16.17,61.97 15.75,61.97 14.83,61.05 14.83,50.59 14.13,49.89 14.13,48.7 11.81,46.39 11.81,41.23 13.8,39.24 14.47,39.24 14.8,38.91 14.8,35.35 14.92,35.24 14.92,31.6 21.59,24.92 28.39,24.92 28.92,25.45 32.64,25.45 36.29,29.11 42.11,29.11 42.93,29.92 53.27,29.92 53.81,30.46 74.41,30.46 77.16,33.21 100.3,33.21 101.3,32.21 104.83,32.21 112.97,40.36 119.66,40.36 121.18,38.85 121.91,38.85 124.33,36.42 127.18,36.42 130.25,33.36 133.36,33.36 135.11,31.61 139.53,31.61 139.73,31.61 140.31,31.03 182.21,31.03 183.24,32.06 186.65,32.06 189.61,35.02 189.61,35.83 190.25,36.46 190.71,36.46 191.19,36.94 191.19,37.02 191.26,37.1 191.26,37.13 191.28,37.15 191.28,38.14 191.65,38.51 192.19,38.51 193.05,39.37 193.05,39.79 193.06,39.8 193.06,39.83 193.29,40.05 195.9,40.05 195.9,40.06 197.89,40.06 198.03,39.92 199.75,39.92 201.72,41.89 202.92,41.89 204.83,39.97 206.83,39.97 207.42,40.56 207.42,41.25 207.69,41.51 208.19,41.51 208.8,42.11 209.71,42.11 211.01,43.41 211.01,46.35 212.68,48.02 212.68,53.19 v1(212.96,53.47)
GSENSOR_CS: length 7.7
  TOP w0.102: R7006.1 144.72,76.72 v1(143.75,76.72) ; U7001.2 140.55,78.66 v1(140.1,78.21)
  BOTTOM w0.102: v1(140.1,78.21) v2(141,78.21) 141.05,78.16 141.05,77.45 141.3,77.19 143.29,77.19 v1(143.75,76.72)
GSENSOR_SDO: length 2.6
  TOP w0.102: U7001.3 141.13,78.16 140.68,77.72 v2(140.52,77.72) 139.75,77.72 139.73,77.73 139.4,78 R7007.2
H_CPUPWRGD: length 17.8
  BOTTOM w0.102: CPU1.AR2 98.95,106.45 98.95,107.7 99.83,108.57 99.83,109.6 99.84,109.61 99.84,109.73 100.57,110.46 100.57,110.52 102.14,112.08 102.14,112.24 R1714.1 v2(102.57,117.58) 102.57,118.38 103.52,119.33 105.43,119.33 ED301.2
H_PECI: length 3.8
  TOP w0.203: C2405.1 40.9,71.72 40.41,71.7 v2(40.34,71.63) 40.28,71.69 U2401.94
  TOP w0.254: C2405.1 42.04,72.44 R2437.1
HDA_BITCLK_CODEC: length 164.1
  TOP w0.14: v1(24.96,27.26) 24.96,24.96 v2(25.27,24.65) 25.29,24.63 25.29,24.17 25.3,24.16 25.3,21.21 26.26,20.25 26.26,18.57 EC1901.2 26.66,18.18 26.66,17.76 27.13,17.29 HDA27.5
  L4 w0.127: v1(24.96,27.26) 24.96,27.31 23.79,28.49 21.87,28.49 18.61,31.75 18.61,35.6 18.36,35.85 18.36,39.01 18.01,39.36 18.01,39.89 17.15,40.75 17.15,44.26 17.54,44.66 17.54,51.44 18.12,52.02 18.12,57.41 18.55,57.84 18.55,57.86 20.69,60.01 21.22,60.01 22.27,61.06 22.27,63.04 22.58,63.34 22.58,64.24 22.18,64.64 22.18,65.98 22.8,66.6 22.8,66.61 24.22,68.02 24.22,68.58 24.87,69.24 25.92,69.24 27.47,70.79 28.05,70.79 29.29,72.03 29.57,72.22 v1(29.63,72.36)
  BOTTOM w0.14: v1(29.63,72.36) 29.63,72.37 29.63,72.46 30.86,73.68 35.25,73.68 35.27,73.67 38.35,73.67 39.22,74.54 44.99,74.54 45.72,75.27 49.16,75.27 49.72,74.71 50.89,74.71 51.44,74.16 55.29,74.16 56.05,74.92 76.54,74.92 78.34,73.12 109.63,73.12 110.37,73.86 110.37,74.06 109.72,74.7 109.72,74.9 109.93,75.1 110.13,75.1 110.77,74.46 110.97,74.46 111.18,74.67 111.18,74.86 110.53,75.51 110.53,75.71 110.74,75.91 110.94,75.91 111.58,75.27 111.78,75.27 111.98,75.48 111.98,75.67 111.34,76.32 111.34,76.5 111.55,76.71 111.76,76.71 112.39,76.08 112.59,76.08 112.98,76.47 112.98,77.42 113.07,77.51 113.07,78.53 R1920.1
HDA_BITCLK_CPU: length 6.4
  BOTTOM w0.076: CPU1.BN37 109.67,83.8 109.81,83.66 109.81,82.91 109.86,82.86 109.86,82.09
  BOTTOM w0.14: 109.86,82.09 109.86,80.67 110.85,79.68 v2(111.05,79.68) 111.64,79.68 112.04,79.28 R1920.2
HDA_CODEC_SDIN0: length 9.4
  TOP w0.14: HDA27.7 26.33,16.93 26.16,17.1 26.11,17.1 25.43,17.78 25.2,17.78 24.93,18.05 24.93,19.54 24.48,19.99 v2(24.48,20.63) 24.62,20.77 24.62,23.86 24.34,24.14 24.34,24.52 R2724.2
HDA_RST_N_CPU: length 4.4
  BOTTOM w0.14: TP1901.1 108.61,83.33 108.13,83.81 108.13,84.96 CPU1.BL35
HDA_SDIN0_CPU: length 161.2
  TOP w0.14: v1(23.8,27.13) 24.28,26.65 v2(24.35,26.65) 24.35,25.91 24.37,25.89 R2724.1
  L4 w0.127: v1(23.8,27.13) 23.32,27.61 21.67,27.61 17.85,31.43 17.85,35.25 17.6,35.5 17.6,38.69 17.25,39.04 17.25,39.57 16.39,40.43 16.39,40.64 16.39,41.51 16.23,41.66 16.23,42.28 16.39,42.43 16.39,44.58 16.78,44.97 16.78,51.76 17.36,52.33 17.36,57.73 17.73,58.1 17.73,59.92 19.33,61.52 19.69,61.52 19.95,61.78 19.95,62.19 20.37,62.61 20.37,64 21.33,64.95 21.33,66.21 22.04,66.92 22.04,66.92 22.09,66.97 22.09,67.97 25.25,71.13 26.7,71.13 28.13,72.56 28.44,72.56 28.53,72.47 v1(28.54,72.47)
  BOTTOM w0.076: CPU1.BN35 109.35,84.97 109.35,84.34 109.25,84.16 109.25,83.75 109.46,83.54 109.46,82.67 109.38,82.6 109.38,82.09
  BOTTOM w0.14: v1(28.54,72.47) 28.51,72.51 28.51,73.64 29.39,74.52 35.74,74.52 35.76,74.51 38,74.51 38.87,75.38 44.65,75.38 45.38,76.11 49.75,76.11 50.09,76.45 50.32,76.45 50.32,76.45 51.75,76.45 53.2,75 54.94,75 55.7,75.76 76.89,75.76 78.69,73.96 105.2,73.96 105.95,74.71 106.15,74.71 106.46,74.4 106.65,74.4 106.86,74.6 106.86,74.8 106.55,75.11 106.55,75.31 106.94,75.7 107.13,75.7 107.38,75.45 107.58,75.45 107.78,75.65 107.78,75.84 107.53,76.09 107.53,76.29 107.73,76.49 107.93,76.49 108.18,76.23 108.39,76.23 108.58,76.42 108.58,76.62 108.32,76.88 108.32,77.08 108.71,77.47 112.28,77.47 112.54,77.73 112.54,78.08 112.29,78.33 111.91,78.33 111.67,78.09 110.4,78.09 109.38,79.11 109.38,82.09
HDA_SDOUT_CODEC: length 3.9
  TOP w0.114: 27.84,17.55 27.53,17.24 v2(27.53,17.17) HDA27.4
  TOP w0.14: 27.84,17.55 27.84,19.04 EC1903.1 27.94,19.84 R1921.1
HDA_SDOUT_CPU: length 166.7
  TOP w0.14: R1921.2 27,20.3 25.89,21.41 25.89,21.74 25.88,21.74 25.88,22.17 R1909.2 25.88,22.22 25.88,22.65 25.89,22.65 v2(25.89,23.16) 25.89,24.86 25.7,25.04 25.7,26.64 v1(25.52,26.82)
  L4 w0.127: v1(25.52,26.82) 25.51,26.81 24.75,26.81 23.58,27.98 21.66,27.98 18.11,31.54 18.11,35.36 17.86,35.61 17.86,38.8 17.5,39.15 17.5,39.67 16.64,40.54 16.64,44.47 17.03,44.87 17.03,51.65 17.61,52.23 17.61,57.62 17.99,58 17.99,59.81 19.44,61.26 19.8,61.26 20.21,61.67 20.21,62.09 20.63,62.51 20.63,63.86 21.58,64.81 21.58,66.1 22.3,66.81 22.3,66.82 23.71,68.23 23.71,68.8 25.69,70.78 26.74,70.78 27.91,71.95 v1(28.18,71.95)
  BOTTOM w0.076: CPU1.BN36 109.67,84.58 109.57,84.39 109.42,84.12 109.42,83.82 109.62,83.61 109.62,82.54 109.61,82.53 109.61,82.09
  BOTTOM w0.14: v1(28.18,71.95) 28.79,71.95 29.06,72.22 29.06,73.8 29.5,74.24 35.48,74.24 35.5,74.23 38.12,74.23 38.99,75.1 44.76,75.1 45.49,75.83 49.86,75.83 50.2,76.17 51.64,76.17 51.85,75.95 51.85,75.75 51.42,75.32 51.42,75.12 51.61,74.92 51.81,74.92 52.25,75.36 52.45,75.36 53.08,74.72 55.06,74.72 55.82,75.48 76.77,75.48 78.57,73.68 108.61,73.68 109.12,74.19 109.12,74.5 108.97,74.65 108.97,74.95 109.83,75.8 109.83,76 109.62,76.2 109.62,76.4 109.82,76.6 110.02,76.6 110.22,76.4 110.42,76.4 111.21,77.19 112.32,77.19 112.77,77.63 112.77,78.18 111.69,79.25 R1512.2 109.61,79.62 109.61,82.09
HDA_SPKR_R: length 2.9
  TOP w0.254: D2703.1 23.26,23.69 23.17,23.79 v2(23.17,24.17) 23.17,24.47 22.56,25.08 R2740.2
HDA_SYNC_CODEC: length 164
  TOP w0.14: HDA27.9 25.53,16.59 25.26,16.85 24.86,16.85 24.55,17.17 v2(24.55,17.17) 24.19,17.17 23.29,18.07 23.29,19.41 23.93,20.04 23.93,21.87 24.34,22.28 24.34,23.74 23.62,24.47 23.62,24.66 23.5,24.78 v2(23.5,25.77) 23.42,25.84 23.42,26.77 v1(23.04,27.15)
  L4 w0.127: v1(23.04,27.15) 21.77,27.15 17.6,31.33 17.6,35.11 17.31,35.39 17.31,38.62 16.97,38.96 16.97,39.24 15.38,40.83 15.38,42.08 15.93,42.62 15.93,44.48 16.53,45.08 16.53,51.86 17.1,52.44 17.1,57.83 17.48,58.21 17.48,60.03 18.71,61.26 18.71,61.82 20.09,63.21 20.09,64.08 21.07,65.05 21.07,66.31 21.15,66.39 21.15,67.29 21.83,67.97 21.83,68.07 25.18,71.42 26.32,71.42 27.83,72.92 29.73,72.92 v1(30.31,72.34)
  BOTTOM w0.14: v1(30.31,72.34) 30.64,72.34 31.42,73.13 35.02,73.13 35.03,73.11 38.61,73.11 38.99,73.48 39.78,73.48 40.15,73.11 40.77,73.11 41.65,73.98 45.23,73.98 45.96,74.71 46.72,74.71 47.28,74.15 50.66,74.15 51.2,73.61 55.52,73.61 56.28,74.37 76.31,74.37 78.11,72.57 109.87,72.57 112.74,75.44 112.94,75.44 112.99,75.39 113.18,75.39 113.39,75.6 113.39,75.8 113.34,75.85 113.34,76.04 113.54,76.24 113.54,78.75 112.29,80 R1908.1
HDA_SYNC_CPU: length 6.5
  BOTTOM w0.076: 110.2,82.09 110.2,82.87 109.97,83.1 109.97,85.63 CPU1.BN34
  BOTTOM w0.14: R1908.2 110.56,80.61 v2(110.28,80.89) 110.2,80.96 110.2,82.09
HDD2_SATA_RX_CON_N: length 5.7
  TOP w0.127: v1(163.7,40.42) 163.41,40.12 163.41,39.7 163.63,39.48 ED6001.4 ED6001.7 163.63,37.97 162.97,37.31 C6030.2
  BOTTOM w0.127: v1(163.7,40.42) 163.7,40.41 163.39,40.1 163.39,39.71 163.65,39.45 HDD2.5 HDD1.16
HDD2_SATA_RX_CON_P: length 5.6
  TOP w0.127: v1(163.07,40.41) 163.15,40.33 ED6001.5 ED6001.6 163.15,37.83 162.83,37.52 162.66,37.52 C6031.2
  BOTTOM w0.127: v1(163.07,40.41) 163.15,40.33 HDD2.6 HDD1.15
HDD2_SATA_TX_CON_N: length 5.6
  TOP w0.127: C6029.2 165.23,37.42 164.67,37.98 ED6001.9 ED6001.2 164.67,39.65 164.75,39.73 164.75,40.26 v1(164.54,40.46)
  BOTTOM w0.127: HDD1.18 HDD2.3 164.65,39.43 164.73,39.5 164.73,40.34 164.6,40.46 v1(164.54,40.46)
HDD2_SATA_TX_CON_P: length 5.8
  TOP w0.127: v1(165.18,40.46) 164.99,40.28 164.99,39.71 165.15,39.56 ED6001.1 ED6001.10 165.15,38.16 165.94,37.37 165.94,37.13 C6028.2
  BOTTOM w0.127: HDD1.19 HDD2.2 165.15,39.43 164.97,39.61 164.97,40.31 165.12,40.46 v1(165.18,40.46)
HDD_DET#: length 91.7
  TOP w0.102: R2047.2 134.96,86.82 134.38,86.24 132.78,86.24 v1(132.36,85.82)
  L4 w0.102: v1(117.74,93.93) 117.82,93.84 117.82,93.42 116.96,92.56 116.96,91.67 118.23,90.4 120.35,90.4 122.66,88.09 128.99,88.09 131.26,85.82 v1(132.36,85.82) 132.36,85.05 134.25,83.16 135.72,83.16 136.02,82.86 136.02,82.4 135.84,82.22 133.94,82.22 133.56,81.84 133.56,79.81 134.85,78.51 135.84,78.51 139.22,75.13 140.03,75.13 148.25,66.92 148.25,66 151.06,63.18 151.06,62.73 162.99,50.81 162.99,44.51 159.54,41.06 159.54,40.5 159.29,40.25 v1(159.29,40.25)
  BOTTOM w0.102: v1(117.74,93.93) 118.02,94.21 CPU1.CG20 ; HDD1.6 158.65,39.61 159.29,40.25 v1(159.29,40.25)
HDD_DEVSLP: length 135.1
  TOP w0.102: R6002.1 153.25,36.03 v2(153.19,36.09) 152.75,36.09 v1(152.47,35.82)
  L2SGND w0.102: v1(155.83,71.32) 156.37,71.32 156.75,70.94 156.75,69.29 160.15,65.89 160.15,65.51 159.69,65.05 159.69,64.44 164.88,59.26 166.09,59.26 173.66,51.69 175.67,51.69 177.11,50.25 177.11,41.49 175.11,39.5 172.52,39.5 170.46,37.44 170.46,35.97 170.11,35.61 167.49,35.61 166.6,36.5 166.6,38.08 168.58,40.06 168.58,40.97 168.42,41.13 155.23,41.13 154.46,40.36 154.46,39.01 152.59,37.14 152.59,35.94 v1(152.47,35.82)
  L4 w0.102: v1(127.59,102.57) 127.59,102.54 128.45,101.68 133.22,101.68 136.65,98.25 136.65,96.78 139.83,93.59 139.83,92.95 144.31,88.47 144.49,88.47 144.84,88.12 144.85,88.12 145.22,87.75 145.4,87.75 149.36,83.8 149.36,83.34 149.65,83.05 149.65,79.87 150.23,79.29 150.23,77.81 152.41,75.63 152.78,75.63 156.01,72.39 156.01,71.68 155.83,71.5 v1(155.83,71.32)
  BOTTOM w0.076: 123.73,101.73 123.31,102.14 122.9,102.14 122.72,101.96 122.42,101.96 122.4,101.98 122.12,102.13 121.97,102.21 CPU1.CP8
  BOTTOM w0.102: 123.73,101.73 126.95,101.73 127.59,102.36 v1(127.59,102.57)
HDD_DEVSLP_R: length 11
  TOP w0.102: R6002.2 155.08,35.19 v2(155.1,35.21) 155.1,35.57 v1(154.88,35.78)
  BOTTOM w0.102: HDD1.13 162.15,37.69 160.96,36.5 160.43,36.5 160.2,36.73 155.84,36.73 v1(154.88,35.78)
HDD_SATA_RX_N11: length 133.7
  TOP w0.127: C6030.1 162.68,35.86 162.68,33.81 162.8,33.69 v1(163.02,33.69)
  L4 w0.114: v1(163.02,33.69) 163.02,33.42 162.91,33.31 162.54,33.31 162.42,33.19 162.42,32.75 162.54,32.62 163.54,32.62 165.07,34.16 167.07,34.16 168.07,33.17 169.77,33.17 173.93,37.34 174.24,38.19 174.25,38.24 175.45,41.56 175.45,44.87 175.58,45 176.48,45.9 176.48,50.28 166.19,60.57 166.19,61.15 159.39,67.94 159.39,68.78 157.24,70.94 157.24,72.65 153.09,76.8 152.62,76.8 151.44,77.98 151.44,83.36 148.36,86.44 148.36,86.69 137.95,97.1 137.95,100.67 134.71,103.91 131.58,103.91 131,104.49 124.55,104.49 123.88,103.81 123.88,101.5 123.29,100.91 122.09,100.91 120.69,99.51 116.88,99.51 116.67,99.72 114.5,99.72 112.88,101.35 111.78,101.35 111.45,101.01 110.59,101.01 110.41,101.19 110.26,101.19 v1(109.99,100.92)
  BOTTOM w0.127: v1(109.99,100.92) 109.81,100.74 109.62,100.74 109.49,100.87 CPU1.BN10
HDD_SATA_RX_P11: length 133.9
  TOP w0.127: C6031.1 162.44,35.92 162.44,33.93 v1(162.19,33.69)
  L4 w0.114: v1(109.99,101.6) 110.17,101.42 110.5,101.42 110.69,101.24 111.35,101.24 111.69,101.58 112.97,101.58 114.6,99.95 116.77,99.95 116.98,99.74 120.59,99.74 122,101.14 123.2,101.14 123.65,101.6 123.65,103.91 124.46,104.72 131.1,104.72 131.67,104.14 134.81,104.14 138.18,100.77 138.18,97.19 148.59,86.79 148.59,86.54 151.67,83.46 151.67,78.08 152.72,77.02 153.19,77.02 157.47,72.75 157.47,71.04 159.62,68.88 159.62,68.04 166.42,61.24 166.42,60.66 176.71,50.37 176.71,45.8 175.68,44.77 175.68,41.52 174.47,38.16 174.47,38.16 174.45,38.12 174.13,37.21 169.86,32.94 167.97,32.94 166.98,33.93 165.17,33.93 163.63,32.4 162.45,32.4 162.19,32.66 v1(162.19,33.69)
  BOTTOM w0.127: CPU1.BN8 v1(109.99,101.6)
HDD_SATA_TX_N11: length 140.6
  TOP w0.127: C6029.1 165.45,35.92 165.45,33.13 165.59,32.99 165.59,32.74 v1(165.36,32.52)
  L4 w0.114: v1(111.03,107.88) 111.43,108.28 111.61,108.28 111.74,108.15 111.74,107.54 111.56,107.37 111.56,106.21 112.3,104.24 112.3,102.69 114.76,100.23 116.66,100.23 117.07,100.64 120.29,100.64 122.56,102.91 122.56,104.99 123.14,105.57 123.44,105.62 127.38,105.1 131.53,105.1 132.11,104.52 135.07,104.52 138.64,100.96 138.64,97.28 148.69,87.22 149.16,87.22 151.69,84.7 151.69,84.03 152.09,83.63 152.09,78.9 157.85,73.14 157.85,71.2 160.02,69.02 160.02,68.18 166.88,61.32 166.88,60.74 177.1,50.52 177.1,45.65 176.06,44.61 176.06,41.46 175.23,39.14 174.46,37 173.41,35.95 173.41,35.95 169.94,32.48 167.88,32.48 166.81,33.55 166.04,33.55 165.61,33.12 165.61,32.76 v1(165.36,32.52)
  BOTTOM w0.076: v1(111.03,107.88) 110.82,108.08 110.16,108.08 109.79,107.71 109.79,106.48 109.76,106.4 109.76,106.18 109.79,106.12 109.79,106.11 109.79,105.82 109.77,105.79 109.77,105.78 109.73,105.68 109.61,105.56 109.61,105.17 109.36,104.91 CPU1.BN4
HDD_SATA_TX_P11: length 140.4
  TOP w0.127: C6028.1 165.69,35.82 165.69,33.23 165.83,33.09 165.83,32.69 v1(166.01,32.51)
  L4 w0.114: v1(111,108.51) 111.71,108.51 111.97,108.25 111.97,107.45 111.79,107.27 111.79,106.25 112.53,104.28 112.53,102.79 114.86,100.46 116.57,100.46 116.98,100.86 120.19,100.86 122.33,103 122.33,105.08 123.03,105.78 123.1,105.79 123.43,105.85 127.4,105.32 131.63,105.32 132.21,104.75 135.17,104.75 138.87,101.05 138.87,97.37 148.78,87.45 149.26,87.45 151.92,84.79 151.92,84.12 152.31,83.73 152.31,78.99 158.07,73.23 158.07,71.29 160.25,69.12 160.25,68.27 167.1,61.42 167.1,60.84 177.33,50.62 177.33,45.56 176.29,44.52 176.29,41.42 175.47,39.15 174.66,36.88 173.64,35.86 170.03,32.25 167.79,32.25 166.72,33.32 166.13,33.32 165.84,33.03 165.84,32.68 v1(166.01,32.51)
  BOTTOM w0.076: v1(111,108.51) 110.75,108.26 110.09,108.26 109.61,107.78 109.61,106.51 109.58,106.43 109.58,106.15 109.61,106.07 109.61,105.86 109.61,105.85 109.58,105.78 109.43,105.64 109.43,105.39 CPU1.BN3
