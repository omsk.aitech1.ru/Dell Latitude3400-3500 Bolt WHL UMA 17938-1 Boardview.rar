# Allegro board 17938-1.1228WZS1107.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
C0201-TO0D1H16
  custom 0.079x0.079 smd: 1(0,0.254) 2(0,-0.254)
C0201H14
  custom 0.076x0.076 smd: 1(0,0.279) 2(0,-0.279)
C402-TO0D2H28
  custom 0.14x0.14 smd: 1(0,0.457) 2(0,-0.457)
C402H22
  custom 0.114x0.114 smd: 1(0,0.457) 2(0,-0.457)
C402H24
  custom 0.114x0.114 smd: 1(0,0.457) 2(0,-0.457)
C603H32
  custom 0.197x0.197 smd: 1(0,0.66) 2(0,-0.66)
C603H36
  custom 0.197x0.197 smd: 1(0,0.66) 2(0,-0.66)
C603H38
  custom 0.197x0.197 smd: 1(0,0.66) 2(0,-0.66)
C603H40
  custom 0.197x0.197 smd: 1(0,0.66) 2(0,-0.66)
C805H54
  rect 1.473x0.889 smd: 1(0,0.838) 2(0,-0.838)
C805H56
  rect 1.473x0.889 smd: 1(0,0.838) 2(0,-0.838)
C805H58
  rect 1.473x0.889 smd: 1(0,0.838) 2(0,-0.838)
C1808H56
  rect 2.235x1.143 smd: 1(0,2.057) 2(0,-2.057)
CON2O-U
  custom 0.159x0.159 smd: 1(0,0.254) 2(0,-0.254)
CSP15G154256H24
  round 0.356 smd: A1(0.5,1) A2(0,1) A3(-0.5,1) B1(0.5,0.5) B2(0,0.5) B3(-0.5,0.5) C1(0.5,0) C2(0,0) C3(-0.5,0) D1(0.5,-0.5) D2(0,-0.5) D3(-0.5,-0.5) E1(0.5,-1) E2(0,-1) E3(-0.5,-1)
CSP16G2D2H24
  round 0.356 smd: A1(-0.75,0.75) A2(-0.25,0.75) A3(0.25,0.75) A4(0.75,0.75) B1(-0.75,0.25) B2(-0.25,0.25) B3(0.25,0.25) B4(0.75,0.25) C1(-0.75,-0.25) C2(-0.25,-0.25) C3(0.25,-0.25) C4(0.75,-0.25) D1(-0.75,-0.75) D2(-0.25,-0.75) D3(0.25,-0.75) D4(0.75,-0.75)
CT7343H79
  rect 2.413x1.905 smd: 1(0,2.959) 2(0,-2.959)
CT7343H83
  rect 2.413x1.905 smd: 1(0,2.959) 2(0,-2.959)
D1006-0305AK-UH22
  rect 0.61x0.432 smd: A(0,0.34) K(0,-0.34)
D1608AK-UH28
  rect 0.559x0.711 smd: A(0,0.702) K(0,-0.702)
D4724AKH44
  rect 2.007x1.295 smd: A(0,2.094) K(0,-2.094)
DF30FC-20DP-D4V-81
  rect 0.203x0.787 smd: 1(-1.8,-1.412) 2(-1.8,1.412) 3(-1.4,-1.412) 4(-1.4,1.412) 5(-1,-1.412) 6(-1,1.412) 7(-0.6,-1.412) 8(-0.6,1.412) 9(-0.2,-1.412) 10(-0.2,1.412) 11(0.2,-1.412) 12(0.2,1.412) 13(0.6,-1.412) 14(0.6,1.412) 15(1,-1.412) 16(1,1.412) 17(1.4,-1.412) 18(1.4,1.412) 19(1.8,-1.412) 20(1.8,1.412)
DFN6F2-G1711-UH32
  rect 0.406x0.508 smd: 1(0.65,1.067) 2(0,1.067) 3(-0.65,1.067) 4(-0.65,-1.067) 5(0,-1.067) 6(0.65,-1.067)
  rect 1.702x1.092 smd: 7(0,0)
DFN6G1820-G1511-UH24
  rect 0.305x0.508 smd: 1(0.5,1.006) 2(0,1.006) 3(-0.5,1.006) 4(-0.5,-1.006) 5(0,-1.006) 6(0.5,-1.006)
  rect 1.499x1.092 smd: 7(0,0)
DFN8F3-G2517H32
  rect 0.406x0.686 smd: 1(0.975,1.411) 2(0.325,1.411) 3(-0.325,1.411) 4(-0.975,1.411) 5(-0.975,-1.411)
  rect 0.025x0.025 smd: 6(-0.325,-1.411) 8(0.975,-1.411)
  custom 0.171x0.171 smd: 7(0.325,-1.411)
  rect 2.489x1.676 smd: 9(0,0)
DFN8G2-G1710-U1H40
  rect 0.305x0.559 smd: 1(0.75,1.043) 2(0.25,1.043) 3(-0.25,1.043) 4(-0.75,1.043) 5(-0.75,-1.043) 6(-0.25,-1.043) 7(0.25,-1.043) 8(0.75,-1.043)
  rect 1.702x0.94 smd: 9(0,0)
DFN10G2510H22
  rect 0.305x0.66 smd: 1(1,0.43) 5(-1,0.43) 6(-1,-0.43) 10(1,-0.43)
  rect 0.254x0.66 smd: 2(0.521,0.43) 4(-0.521,0.43) 7(-0.521,-0.43) 9(0.521,-0.43)
  rect 0.025x0.025 smd: 3(0,0.43)
  rect 0.406x1.499 smd: 8(0,-0.43)
DFN14J32-G255D95H32
  custom 0.14x0.14 smd: 1(1.2,0.975) 6(-0.8,0.975) 8(-1.2,-0.975) 13(0.8,-0.975)
  rect 0.025x0.025 smd: 2(0.8,0.975) 7(-1.2,0.975) 9(-0.8,-0.975) 14(1.2,-0.975)
  rect 0.203x0.559 smd: 3(0.4,0.975) 4(0,0.975) 5(-0.4,0.975) 10(-0.4,-0.975) 11(0,-0.975) 12(0.4,-0.975)
  rect 2.54x0.94 smd: 15(0,0)
DM-87212-1400N-02
  rect 0.61x1.549 smd: 1(-6.5,-2.525) 2(-5.5,-2.525) 3(-4.5,-2.525) 4(-3.5,-2.525) 5(-2.5,-2.525) 6(-1.5,-2.525) 7(-0.5,-2.525) 8(0.5,-2.525) 9(1.5,-2.525) 10(2.5,-2.525) 11(3.5,-2.525) 12(4.5,-2.525) 13(5.5,-2.525) 14(6.5,-2.525)
  rect 1.194x1.803 smd: 15(-7.797,0) 16(7.797,0)
FFSKL05007N12C
  rect 0.305x1.092 smd: 1(-2.75,3.3) 2(-2.25,3.3) 3(-1.75,3.3) 4(-1.25,3.3) 5(-0.75,3.3) 6(-0.25,3.3) 7(0.25,3.3) 8(0.75,3.3) 9(1.25,3.3) 10(1.75,3.3) 11(2.25,3.3) 12(2.75,3.3)
  rect 1.448x2.007 smd: 13(-5.125,0) 14(5.125,0)
FH52-8S-D5SH
  rect 0.305x0.838 smd: 1(-1.75,3.175) 2(-1.25,3.175) 3(-0.75,3.175) 4(-0.25,3.175) 5(0.25,3.175) 6(0.75,3.175) 7(1.25,3.175) 8(1.75,3.175)
  rect 0.813x2.007 smd: 9(3.45,0) 10(-3.45,0)
GAP-CLOSE-PWR
  rect 0.66x0.762 smd: 1(-0.305,0) 2(0.305,0)
GAP-CLOSE-PWR-3
  rect 0.66x0.762 smd: 1(-0.305,0) 2(0.305,0)
GAP-CLOSE-PWR-0805-NP
  custom 0.34x0.34 smd: 1(0,0.681)
  custom 0.339x0.339 smd: 2(0,-0.681)
GAP-CLOSE-PWR-0805-NP-5
  custom 0.327x0.327 smd: 1(0,0.654) 2(0,-0.654)
HOLE233R142
  round 5.918 hole 3.607: 1(0,0)
HOLE256R115
  round 6.502 hole 2.921: 1(0,0)
HOLE335R178
  round 8.509 hole 4.521: 1(0,0)
HOLE335R229
  round 8.509 hole 5.817: 1(0,0)
L402H24
  custom 0.127x0.127 smd: 1(0,0.432) 2(0,-0.432)
L7066-1830-UH119
  rect 3.505x2.667 smd: 1(0,2.653) 2(0,-2.653)
L7366-1830H119
  rect 3.505x2.692 smd: 1(0,2.815) 2(0,-2.815)
L20125H42
  rect 1.346x0.94 smd: 1(0,0.838) 2(0,-0.838)
L125100-4P-3H24
  rect 0.356x0.635 smd: 1(-0.275,-0.559) 2(0.275,-0.559) 3(0.275,0.559) 4(-0.275,0.559)
L125100-4P-4H24
  rect 0.635x0.432 smd: 1(-0.562,0.341) 2(0.562,0.341) 3(0.562,-0.341) 4(-0.562,-0.341)
L125100-4P-4H28
  rect 0.635x0.432 smd: 1(-0.562,0.341) 2(0.562,0.341) 3(0.562,-0.341) 4(-0.562,-0.341)
L125100-4P-5H24
  rect 0.457x0.711 smd: 1(-0.326,0.523) 2(0.326,0.523) 3(-0.326,-0.523) 4(0.326,-0.523)
L11510030H158
  rect 3.505x3.632 smd: 1(0,4.435) 2(0,-4.435)
LED3020-3P-19H44
  rect 1.499x0.991 smd: 1(0,1.5) 3(0,-1.5)
  rect 0.889x0.889 smd: 2(0.65,0)
LED11516AKH28
  rect 0.94x0.813 smd: A(0,0.648) K(0,-0.648)
LGA12G2H40
  rect 0.381x0.381 smd: 1(0.809,0.809) 4(-0.809,0.809) 7(-0.809,-0.809) 10(0.809,-0.809)
  rect 0.305x0.432 smd: 2(0.25,0.784) 3(-0.25,0.784) 8(-0.25,-0.784) 9(0.25,-0.784)
  rect 0.432x0.305 smd: 5(-0.784,0.25) 6(-0.784,-0.25) 11(0.784,-0.25) 12(0.784,0.25)
MSOP8-1H44
  rect 0.356x1.397 smd: 1(-0.975,-1.991) 2(-0.325,-1.991) 3(0.325,-1.991) 4(0.975,-1.991) 5(0.975,1.991) 6(0.325,1.991) 7(-0.325,1.991) 8(-0.975,1.991)
MSS3-Q-T-R
  round 0.254 hole 0.965 unplated: (-1.5,0) (1.5,0)
  rect 0.61x1.499 smd: 1(-2.25,1.75) 2(0.751,1.75) 3(2.25,1.75)
  rect 0.991x0.813 smd: 4(-3.65,1.056) 5(-3.65,-1.056) 6(3.65,1.056) 7(3.65,-1.056)
NFSM0-S6701-TSH4-U
  round 0.254 hole 1.168 unplated: (-10,0)
  round 0.254 hole 1.651 unplated: (10,0)
  rect 0.305x1.346 smd: 1(-9.25,5.173) 2(-9,-2.173) 3(-8.75,5.173) 4(-8.5,-2.173) 5(-8.25,5.173) 6(-8,-2.173) 7(-7.75,5.173) 8(-7.5,-2.173) 9(-7.25,5.173) 10(-7,-2.173) 11(-6.75,5.173) 12(-6.5,-2.173) 13(-6.25,5.173) 14(-6,-2.173) 15(-5.75,5.173) 16(-5.5,-2.173) 17(-5.25,5.173) 18(-5,-2.173) 19(-4.75,5.173) 20(-4.5,-2.173) 21(-4.25,5.173) 22(-4,-2.173) 23(-3.75,5.173) 24(-3.5,-2.173) 25(-3.25,5.173) 26(-3,-2.173) 27(-2.75,5.173) 28(-2.5,-2.173) 29(-2.25,5.173) 30(-2,-2.173) 31(-1.75,5.173) 32(-1.5,-2.173) 33(-1.25,5.173) 34(-1,-2.173) 35(-0.75,5.173) 36(-0.5,-2.173) 37(-0.25,5.173) 38(0,-2.173) 39(0.25,5.173) 40(0.5,-2.173) 41(0.75,5.173) 42(1,-2.173) 43(1.25,5.173) 44(1.5,-2.173) 45(1.75,5.173) 46(2,-2.173) 47(2.25,5.173) 48(2.5,-2.173) 49(2.75,5.173) 50(3,-2.173) 51(3.25,5.173) 52(3.5,-2.173) 53(3.75,5.173) 54(4,-2.173) 55(4.25,5.173) 56(4.5,-2.173) 57(4.75,5.173) 58(5,-2.173) 67(7.25,5.173) 68(7.5,-2.173) 69(7.75,5.173) 70(8,-2.173) 71(8.25,5.173) 72(8.5,-2.173) 73(8.75,5.173) 74(9,-2.173) 75(9.25,5.173)
  rect 1.194x2.743 smd: 76(-10.35,4.5) 77(10.35,4.5)
NTC-402H22-U
  custom 0.127x0.127 smd: 1(0,0.432) 2(0,-0.432)
NTC-402H24-U
  custom 0.127x0.127 smd: 1(0,0.432) 2(0,-0.432)
NTC-603H38
  rect 0.914x0.787 smd: 1(0,0.66) 2(0,-0.66)
OSC-3225-4P-4H36
  rect 1.397x1.067 smd: 1(-1.171,-0.756) 2(1.171,-0.756) 3(1.171,0.756) 4(-1.171,0.756)
POLYSW-2114H30
  rect 1.6x0.889 smd: 1(0,0.865) 2(0,-0.865)
POLYSW-4633-UH43
  rect 3.505x1.626 smd: 1(0,1.834) 2(0,-1.834)
PPAK-8P-3232H36
  rect 0.406x0.66 smd: 1(-0.975,-2.142) 2(-0.325,-2.142) 3(0.325,-2.142) 4(0.975,-2.142)
  rect 3.353x2.438 smd: 5(0,0)
  rect 0.025x0.025 smd: 6(0.65,0.838) 7(0,0.838) 8(-0.65,0.838)
QFN16-G1D8-UH32
  rect 0.305x0.66 smd: 1(0.75,1.487) 2(0.25,1.487) 3(-0.25,1.487) 4(-0.75,1.487) 9(-0.75,-1.487) 10(-0.25,-1.487) 11(0.25,-1.487) 12(0.75,-1.487)
  rect 0.66x0.305 smd: 5(-1.487,0.75) 6(-1.487,0.25) 7(-1.487,-0.25) 8(-1.487,-0.75) 13(1.487,-0.75) 14(1.487,-0.25) 15(1.487,0.25) 16(1.487,0.75)
  rect 1.778x1.778 smd: 17(0,0)
QFN20J3-G1D8H32
  rect 0.203x0.635 smd: 1(0.8,1.437) 2(0.4,1.437) 3(0,1.437) 4(-0.4,1.437) 5(-0.8,1.437) 11(-0.8,-1.437) 12(-0.4,-1.437) 13(0,-1.437) 14(0.4,-1.437) 15(0.8,-1.437)
  rect 0.635x0.203 smd: 6(-1.437,0.8) 7(-1.437,0.4) 8(-1.437,0) 9(-1.437,-0.4) 10(-1.437,-0.8) 16(1.437,-0.8) 17(1.437,-0.4) 18(1.437,0) 19(1.437,0.4) 20(1.437,0.8)
  rect 1.803x1.803 smd: 21(0,0)
QFN20Z3-G1D1H36
  custom 0.064x0.064 smd: 1(0.9,1.297) 5(-0.9,1.297) 6(-1.297,0.9) 10(-1.297,-0.9) 11(-0.9,-1.297) 15(0.9,-1.297) 16(1.297,-0.9) 20(1.297,0.9)
  rect 0.254x0.914 smd: 2(0.45,1.297) 3(0,1.297) 4(-0.45,1.297) 12(-0.45,-1.297) 13(0,-1.297) 14(0.45,-1.297)
  rect 0.914x0.254 smd: 7(-1.297,0.45) 8(-1.297,0) 9(-1.297,-0.45) 17(1.297,-0.45) 18(1.297,0) 19(1.297,0.45)
  rect 1.092x1.092 smd: 21(0,0)
QFN22G4-G2PH42
  rect 0.305x0.66 smd: 1(1.25,1.924) 2(0.75,1.924) 3(0.25,1.924) 4(-0.25,1.924) 5(-0.75,1.924) 6(-1.25,1.924) 16(0.75,-1.924) 17(1.25,-1.924)
  custom 0.326x0.326 smd: 7(-1.924,1.25)
  rect 0.025x0.025 smd: 8(-1.924,0.75) 9(-1.924,0.25) 10(-1.924,-0.75) 13(-0.75,-1.924) 14(-0.25,-1.924) 15(0.25,-1.924)
  custom 0.232x0.232 smd: 11(-1.924,-1.25)
  custom 0.165x0.165 smd: 12(-1.25,-1.924)
  rect 0.66x0.305 smd: 18(1.924,-1.25) 19(1.924,-0.75) 20(1.924,-0.25) 21(1.924,0.25) 22(1.924,1.25)
QFN24-G2D8-UH24
  rect 0.305x0.635 smd: 1(1.25,1.981) 2(0.751,1.981) 3(0.25,1.981) 4(-0.25,1.981) 5(-0.751,1.981) 6(-1.25,1.981) 13(-1.25,-1.981) 14(-0.751,-1.981) 15(-0.25,-1.981) 16(0.25,-1.981) 17(0.751,-1.981) 18(1.25,-1.981)
  rect 0.635x0.305 smd: 7(-1.981,1.25) 8(-1.981,0.751) 9(-1.981,0.25) 10(-1.981,-0.25) 11(-1.981,-0.751) 12(-1.981,-1.25) 19(1.981,-1.25) 20(1.981,-0.751) 21(1.981,-0.25) 22(1.981,0.25) 23(1.981,0.751) 24(1.981,1.25)
  rect 2.794x2.794 smd: 25(0,0)
QFN31G5-G4P-9H34
  rect 0.305x0.66 smd: 1(1.75,2.424) 2(1.25,2.424) 3(0.75,2.424) 4(0.25,2.424) 5(-0.25,2.424) 6(-0.75,2.424) 7(-1.25,2.424) 8(-1.75,2.424)
  rect 0.025x0.025 smd: 9(-2.424,1.75) 10(-2.424,1.25) 11(-2.424,0.75) 12(-2.424,-0.25) 13(-2.424,-0.75) 14(-2.424,-1.25) 15(-2.424,-1.75) 17(-1.25,-2.424) 18(-0.75,-2.424) 19(-0.25,-2.424) 20(0.25,-2.424) 21(0.75,-2.424) 22(1.25,-2.424) 23(1.75,-2.424) 25(2.424,-1.25) 26(2.424,-0.75)
  custom 0.165x0.165 smd: 16(-1.75,-2.424) 24(2.424,-1.75)
  rect 0.61x0.305 smd: 27(2.424,-0.25)
  rect 0.66x0.305 smd: 28(2.424,0.25) 29(2.424,0.75) 30(2.424,1.25) 31(2.424,1.75)
  rect 1.422x1.143 smd: 32(1.038,1.183)
  custom 0.326x0.326 smd: 33(-1.175,1.183)
  custom 0.542x0.542 smd: 34(-0.669,-0.742)
  rect 0.559x0.406 smd: 35(1.66,-0.25)
QFN32G5-G3D75-UH40
  rect 0.305x0.66 smd: 1(1.75,2.43) 2(1.25,2.43) 3(0.75,2.43) 4(0.25,2.43) 5(-0.25,2.43) 6(-0.75,2.43) 7(-1.25,2.43) 8(-1.75,2.43) 17(-1.75,-2.43) 18(-1.25,-2.43) 19(-0.75,-2.43) 20(-0.25,-2.43) 21(0.25,-2.43) 22(0.75,-2.43) 23(1.25,-2.43) 24(1.75,-2.43)
  rect 0.66x0.305 smd: 9(-2.43,1.75) 10(-2.43,1.25) 11(-2.43,0.75) 12(-2.43,0.25) 13(-2.43,-0.25) 14(-2.43,-0.75) 15(-2.43,-1.25) 16(-2.43,-1.75) 25(2.43,-1.75) 26(2.43,-1.25) 27(2.43,-0.75) 28(2.43,-0.25) 29(2.43,0.25) 30(2.43,0.75) 31(2.43,1.25) 32(2.43,1.75)
  rect 3.759x3.759 smd: 33(0,0)
QFN32J4-G2D85H34
  rect 0.203x0.61 smd: 1(1.4,1.958) 2(1,1.958) 3(0.6,1.958) 4(0.2,1.958) 5(-0.2,1.958) 6(-0.6,1.958) 7(-1,1.958) 8(-1.4,1.958) 17(-1.4,-1.958) 18(-1,-1.958) 19(-0.6,-1.958) 20(-0.2,-1.958) 21(0.2,-1.958) 22(0.6,-1.958) 23(1,-1.958) 24(1.4,-1.958)
  rect 0.61x0.203 smd: 9(-1.958,1.4) 10(-1.958,1) 11(-1.958,0.6) 12(-1.958,0.2) 13(-1.958,-0.2) 14(-1.958,-0.6) 15(-1.958,-1) 16(-1.958,-1.4) 25(1.958,-1.4) 26(1.958,-1) 27(1.958,-0.6) 28(1.958,-0.2) 29(1.958,0.2) 30(1.958,0.6) 31(1.958,1) 32(1.958,1.4)
  rect 2.845x2.845 smd: 33(0,0)
QFN32J4-G2D85H36
  rect 0.203x0.61 smd: 1(1.4,1.958) 2(1,1.958) 3(0.6,1.958) 4(0.2,1.958) 5(-0.2,1.958) 6(-0.6,1.958) 7(-1,1.958) 8(-1.4,1.958) 17(-1.4,-1.958) 18(-1,-1.958) 19(-0.6,-1.958) 20(-0.2,-1.958) 21(0.2,-1.958) 22(0.6,-1.958) 23(1,-1.958) 24(1.4,-1.958)
  rect 0.61x0.203 smd: 9(-1.958,1.4) 10(-1.958,1) 11(-1.958,0.6) 12(-1.958,0.2) 13(-1.958,-0.2) 14(-1.958,-0.6) 15(-1.958,-1) 16(-1.958,-1.4) 25(1.958,-1.4) 26(1.958,-1) 27(1.958,-0.6) 28(1.958,-0.2) 29(1.958,0.2) 30(1.958,0.6) 31(1.958,1) 32(1.958,1.4)
  rect 2.845x2.845 smd: 33(0,0)
QFN32J4-G3PH32
  rect 0.203x0.559 smd: 1(1.4,1.975) 2(1,1.975) 3(0.6,1.975) 4(0.2,1.975) 5(-0.2,1.975) 6(-0.6,1.975) 7(-1,1.975) 8(-1.4,1.975) 21(0.2,-1.975) 22(0.6,-1.975) 23(1,-1.975) 24(1.4,-1.975)
  rect 0.559x0.203 smd: 9(-1.975,1.4) 10(-1.975,1) 25(1.975,-1.4) 26(1.975,-1) 27(1.975,-0.6) 28(1.975,-0.2) 29(1.975,0.2) 30(1.975,0.6) 31(1.975,1) 32(1.975,1.4)
  rect 0.025x0.025 smd: 11(-1.975,0.6) 12(-1.975,0.2) 13(-1.975,-0.2) 14(-1.975,-0.6) 15(-1.975,-1) 17(-1.4,-1.975) 18(-1,-1.975) 19(-0.6,-1.975) 20(-0.2,-1.975)
  custom 0.14x0.14 smd: 16(-1.975,-1.4)
  rect 1.168x1.219 smd: 33(0.895,0.86)
  rect 1.168x1.524 smd: 34(0.895,-0.72)
  custom 0.401x0.401 smd: 35(-0.762,0)
QFN40J5-G3D6-DIFF-H34
  rect 0.203x0.66 smd: 1(1.8,2.388) 10(-1.8,2.388) 21(-1.8,-2.388) 30(1.8,-2.388)
  rect 0.203x0.737 smd: 2(1.4,2.388) 3(1,2.388) 4(0.6,2.388) 5(0.2,2.388) 6(-0.2,2.388) 7(-0.6,2.388) 8(-1,2.388) 9(-1.4,2.388) 22(-1.4,-2.388) 23(-1,-2.388) 24(-0.6,-2.388) 25(-0.2,-2.388) 26(0.2,-2.388) 27(0.6,-2.388) 28(1,-2.388) 29(1.4,-2.388)
  rect 0.66x0.203 smd: 11(-2.388,1.8) 20(-2.388,-1.8) 31(2.388,-1.8) 40(2.388,1.8)
  rect 0.737x0.203 smd: 12(-2.388,1.4) 13(-2.388,1) 14(-2.388,0.6) 15(-2.388,0.2) 16(-2.388,-0.2) 17(-2.388,-0.6) 18(-2.388,-1) 19(-2.388,-1.4) 32(2.388,-1.4) 33(2.388,-1) 34(2.388,-0.6) 35(2.388,-0.2) 36(2.388,0.2) 37(2.388,0.6) 38(2.388,1) 39(2.388,1.4)
  rect 3.607x3.607 smd: 41(0,0)
QFN40J5-G3D75H36
  rect 0.203x0.66 smd: 1(1.8,2.489) 2(1.4,2.489) 3(1,2.489) 4(0.6,2.489) 5(0.2,2.489) 6(-0.2,2.489) 7(-0.6,2.489) 8(-1,2.489) 9(-1.4,2.489) 10(-1.8,2.489) 21(-1.8,-2.489) 22(-1.4,-2.489) 23(-1,-2.489) 24(-0.6,-2.489) 25(-0.2,-2.489) 26(0.2,-2.489) 27(0.6,-2.489) 28(1,-2.489) 29(1.4,-2.489) 30(1.8,-2.489)
  rect 0.66x0.203 smd: 11(-2.489,1.8) 12(-2.489,1.4) 13(-2.489,1) 14(-2.489,0.6) 15(-2.489,0.2) 16(-2.489,-0.2) 17(-2.489,-0.6) 18(-2.489,-1) 19(-2.489,-1.4) 20(-2.489,-1.8) 31(2.489,-1.8) 32(2.489,-1.4) 33(2.489,-1) 34(2.489,-0.6) 35(2.489,-0.2) 36(2.489,0.2) 37(2.489,0.6) 38(2.489,1) 39(2.489,1.4) 40(2.489,1.8)
  rect 3.759x3.759 smd: 41(0,0)
QFN40J4060-G2848H32
  rect 0.203x0.635 smd: 1(1.4,2.936) 2(1,2.936) 3(0.6,2.936) 4(0.2,2.936) 5(-0.2,2.936) 6(-0.6,2.936) 7(-1,2.936) 8(-1.4,2.936) 21(-1.4,-2.936) 22(-1,-2.936) 23(-0.6,-2.936) 24(-0.2,-2.936) 25(0.2,-2.936) 26(0.6,-2.936) 27(1,-2.936) 28(1.4,-2.936)
  rect 0.635x0.203 smd: 9(-1.936,2.2) 10(-1.936,1.8) 11(-1.936,1.4) 12(-1.936,1) 13(-1.936,0.6) 14(-1.936,0.2) 15(-1.936,-0.2) 16(-1.936,-0.6) 17(-1.936,-1) 18(-1.936,-1.4) 19(-1.936,-1.8) 20(-1.936,-2.2) 29(1.936,-2.2) 30(1.936,-1.8) 31(1.936,-1.4) 32(1.936,-1) 33(1.936,-0.6) 34(1.936,-0.2) 35(1.936,0.2) 36(1.936,0.6) 37(1.936,1) 38(1.936,1.4) 39(1.936,1.8) 40(1.936,2.2)
  rect 2.794x4.801 smd: 41(0,0)
QFN60J9050-G7131H32
  rect 0.203x0.66 smd: 1(3.8,2.335) 20(-3.8,2.335) 31(-3.8,-2.335) 50(3.8,-2.335)
  rect 0.203x0.838 smd: 2(3.4,2.335) 3(3,2.335) 4(2.6,2.335) 5(2.2,2.335) 6(1.8,2.335) 7(1.4,2.335) 8(1,2.335) 9(0.6,2.335) 10(0.2,2.335) 11(-0.2,2.335) 12(-0.6,2.335) 13(-1,2.335) 14(-1.4,2.335) 15(-1.8,2.335) 16(-2.2,2.335) 17(-2.6,2.335) 18(-3,2.335) 19(-3.4,2.335) 32(-3.4,-2.335) 33(-3,-2.335) 34(-2.6,-2.335) 35(-2.2,-2.335) 36(-1.8,-2.335) 37(-1.4,-2.335) 38(-1,-2.335) 39(-0.6,-2.335) 40(-0.2,-2.335) 41(0.2,-2.335) 42(0.6,-2.335) 43(1,-2.335) 44(1.4,-2.335) 45(1.8,-2.335) 46(2.2,-2.335) 47(2.6,-2.335) 48(3,-2.335) 49(3.4,-2.335)
  rect 0.66x0.203 smd: 21(-4.335,1.8) 30(-4.335,-1.8) 51(4.335,-1.8) 60(4.335,1.8)
  rect 0.838x0.203 smd: 22(-4.335,1.4) 23(-4.335,1) 24(-4.335,0.6) 25(-4.335,0.2) 26(-4.335,-0.2) 27(-4.335,-0.6) 28(-4.335,-1) 29(-4.335,-1.4) 52(4.335,-1.4) 53(4.335,-1) 54(4.335,-0.6) 55(4.335,-0.2) 56(4.335,0.2) 57(4.335,0.6) 58(4.335,1) 59(4.335,1.4)
  rect 7.112x3.099 smd: 61(0,0)
R0201H12
  custom 0.076x0.076 smd: 1(0,0.279) 2(0,-0.279)
R402-PAD-NP
  custom 0.127x0.127 smd: 1(0,0.432) 2(0,-0.432)
R402H14
  custom 0.127x0.127 smd: 1(0,0.432) 2(0,-0.432)
R402H15
  custom 0.127x0.127 smd: 1(0,0.432) 2(0,-0.432)
R402H16
  custom 0.127x0.127 smd: 1(0,0.432) 2(0,-0.432)
R603H22
  custom 0.197x0.197 smd: 1(0,0.66) 2(0,-0.66)
R603H24
  custom 0.197x0.197 smd: 1(0,0.66) 2(0,-0.66)
R805H24
  rect 1.473x0.889 smd: 1(0,0.838) 2(0,-0.838)
R1206H24
  rect 1.854x1.016 smd: 1(0,1.346) 2(0,-1.346)
R1206H26
  rect 1.854x1.016 smd: 1(0,1.346) 2(0,-1.346)
R1206H28
  rect 1.854x1.016 smd: 1(0,1.346) 2(0,-1.346)
R3720H40
  rect 4.013x1.041 smd: 1(0,0.867) 2(0,-0.867)
S-OSC3-2016H28
  rect 0.889x0.635 smd: 1(-0.718,-0.517) 3(0.718,0.517)
  custom 0.417x0.417 smd: 2(0.718,-0.517)
SC70-2D2-312H44
  custom 0.152x0.152 smd: 1(-0.65,-0.864) 2(0.65,-0.864) 3(0,0.864)
SC70-5-1H44
  rect 0.356x1.092 smd: 1(-0.65,-0.859) 2(0,-0.859) 3(0.65,-0.859) 4(0.65,0.857) 5(-0.65,0.857)
SC70-5H44
  rect 0.356x0.762 smd: 1(0.65,0.935) 2(0,0.935) 3(-0.65,0.935) 4(-0.65,-0.935) 5(0.65,-0.935)
SKT-HDMI23-188139-2
  oval 0.813x0.914 hole 0.559: 1(-4.5,6.5) 2(-4,8.05) 3(-3.5,6.5) 4(-3,8.05) 5(-2.5,6.5) 6(-2,8.05) 7(-1.5,6.5) 8(-1,8.05) 9(-0.5,6.5) 10(0,8.05) 11(0.5,6.5) 12(1,8.05) 13(1.5,6.5) 14(2,8.05) 15(2.5,6.5) 16(3,8.05) 17(3.5,6.5) 18(4,8.05) 19(4.5,6.5)
  oval 1.626x2.311 hole 0.914x1.6: 20(-7.25,8.2) 21(7.25,8.2) 22(-9.15,0) 23(9.15,0)
SKT-USB13-160146-4-U
  round 1.321 hole 0.914: 1(3.5,7.7) 2(1,7.7) 3(-1,7.7) 4(-3.5,7.7)
  round 1.219 hole 0.914: 5(-4,6.2) 6(-2,6.2) 7(0,6.2) 8(2,6.2) 9(4,6.2)
  oval 1.397x3.124 hole 0.711x2.413: 10(-7.85,0) 11(7.85,0)
  oval 1.422x2.388 hole 0.711x1.803: 12(-6.4,6.8) 13(6.4,6.8)
SKT-USB36-124102-1
  round 0.254 hole 0.762 unplated: (-3.45,5.8) (3.45,5.8)
  oval 1.321x2.134 hole 0.61x1.6: 13(-6.075,0) 22(6.075,0)
  oval 1.321x2.311 hole 0.61x1.6: 14(-6.075,3.865) 21(6.075,3.865)
  oval 1.041x1.829 hole 0.508x1.118: 15(-4.475,6.2) 20(4.475,6.2)
  custom 0.076x0.076 smd: 16(-3.2,6.49) 19(3.2,6.49) A1(-2.75,5.74) A12(2.75,5.74)
  rect 0.508x0.305 smd: 17(-1,6.49) 18(1,6.49)
  rect 0.305x0.61 smd: A2(-2.25,5.74) A3(-1.75,5.74) A4(-1.25,5.74) A5(-0.75,5.74) A6(-0.25,5.74) A7(0.25,5.74) A8(0.75,5.74) A9(1.25,5.74) A10(1.75,5.74) A11(2.25,5.74)
  oval 1.651x0.991 hole 1.016x0.508: B1(3.2,4.665) B12(-3.2,4.665)
  round 0.66 hole 0.406: B2(2.5,3.765) B3(1.7,3.765) B4(1.3,4.665) B5(0.85,3.765) B6(0.4,4.665) B7(-0.4,4.665) B8(-0.85,3.765) B9(-1.3,4.665) B10(-1.7,3.765) B11(-2.5,3.765)
SLP2510P8-1H22
  rect 0.305x0.635 smd: 1(-1,-0.437) 5(1,-0.437) 6(1,0.437) 10(-1,0.437)
  rect 0.203x0.635 smd: 2(-0.5,-0.437) 4(0.5,-0.437) 7(0.5,0.437) 9(-0.5,0.437)
  rect 0.406x0.635 smd: 3(0,-0.437) 8(0,0.437)
SMD49-12H34
  rect 1.753x1.27 smd: 1(0,1.231) 2(0,-1.231)
SMD-ARES4
  rect 0.356x0.61 smd: 1(-0.325,-0.457) 2(0.325,-0.457) 3(0.325,0.457) 4(-0.325,0.457)
SMD-ARES4H18
  rect 0.356x0.61 smd: 1(-0.325,-0.457) 2(0.325,-0.457) 3(0.325,0.457) 4(-0.325,0.457)
SMD-ARES4H20
  rect 0.356x0.61 smd: 1(-0.325,-0.457) 2(0.325,-0.457) 3(0.325,0.457) 4(-0.325,0.457)
SOD123AK-2H43
  rect 1.143x1.245 smd: A(0,1.631) K(0,-1.631)
SOD123AK-3718-1H40
  rect 1.245x1.549 smd: A(0,1.456)
  rect 1.245x2.667 smd: K(0,-0.897)
SOD323-2513AKH36
  rect 0.559x1.041 smd: A(0,0.987) K(0,-0.987)
SOD323AKH38
  rect 0.559x0.813 smd: A(0,1.1) K(0,-1.1)
SOD323AKH40
  rect 0.559x0.813 smd: A(0,1.1) K(0,-1.1)
SOD323AKH44
  rect 0.559x0.813 smd: A(0,1.1) K(0,-1.1)
SOD523AKH26
  rect 0.559x0.813 smd: A(0,0.66) K(0,-0.66)
SOD882-10D6-1H20
  rect 0.61x0.457 smd: 1(0,0.457) 2(0,-0.457)
SOD882-10D6-UH22
  rect 0.61x0.457 smd: 1(0,0.457) 2(0,-0.457)
SOD-523-2H26
  rect 0.559x0.762 smd: 1(0,0.724) 2(0,-0.724)
SOIC8-1H86
  rect 0.635x1.524 smd: 1(-1.905,-3.442) 2(-0.635,-3.442) 3(0.635,-3.442) 4(1.905,-3.442) 5(1.905,3.442) 6(0.635,3.442) 7(-0.635,3.442) 8(-1.905,3.442)
SOIC8-G3530H63
  rect 0.635x1.524 smd: 1(-1.905,-2.492) 2(-0.635,-2.492) 3(0.635,-2.492) 4(1.905,-2.492) 5(1.905,2.492) 6(0.635,2.492) 7(-0.635,2.492) 8(-1.905,2.492)
  rect 3.505x2.997 smd: 9(0,0)
SOT23-2D4-312H44
  custom 0.171x0.171 smd: 1(-0.95,-1.069) 2(0.95,-1.069) 3(0,1.069)
SOT23-2D4-312H46
  custom 0.171x0.171 smd: 1(-0.95,-1.069) 2(0.95,-1.069) 3(0,1.069)
SOT23-2D8-312H58
  custom 0.171x0.171 smd: 1(-0.95,-1.21) 2(0.95,-1.21) 3(0,1.21)
SOT23CBE2D4H44
  custom 0.165x0.165 smd: B(-0.95,-1.073) C(0,1.073) E(0.95,-1.073)
SOT23CBE2D4H46-U
  custom 0.165x0.165 smd: B(-0.95,-1.073) C(0,1.073) E(0.95,-1.073)
SOT23CBE2D6H62
  custom 0.165x0.165 smd: B(-0.95,-1.016) C(0,1.016) E(0.95,-1.016)
SOT23DGS2D4H44
  custom 0.171x0.171 smd: D(0,1.069) G(-0.95,-1.069) S(0.95,-1.069)
SOT323CBE2D2H40
  custom 0.152x0.152 smd: B(-0.65,-0.864) C(0,0.864) E(0.65,-0.864)
SOT-6H58
  rect 0.61x0.813 smd: 1(-0.95,-1.219) 2(0,-1.219) 3(0.95,-1.219) 4(0.95,1.219) 5(0,1.219) 6(-0.95,1.219)
SOT-23-5H52
  rect 0.686x0.864 smd: 1(-0.953,-1.232) 2(0,-1.232) 3(0.953,-1.232) 4(0.953,1.232) 5(-0.953,1.232)
SOT-23-5H56
  rect 0.686x0.864 smd: 1(-0.953,-1.232) 2(0,-1.232) 3(0.953,-1.232) 4(0.953,1.232) 5(-0.953,1.232)
SOT-23-5H58
  rect 0.686x0.864 smd: 1(-0.953,-1.232) 2(0,-1.232) 3(0.953,-1.232) 4(0.953,1.232) 5(-0.953,1.232)
SOT-23-9H44
  custom 0.165x0.165 smd: 1(-0.953,-1.056) 2(0.953,-1.056) 3(0,1.056)
SOT-323H44
  custom 0.152x0.152 smd: 1(-0.65,-1.011) 2(0.65,-1.011) 3(0,1.011)
SOT-363H44
  rect 0.356x0.965 smd: 1(-0.65,-0.826) 2(0,-0.826) 3(0.65,-0.826) 4(0.65,0.826) 5(0,0.826) 6(-0.65,0.826)
SPR5128H111
  rect 4.801x2.489 smd: 1(-1.397,0)
SPR5630H142
  rect 5.283x2.692 smd: 1(-2.413,0)
STF237R113H86
  round 6.02 hole 2.87: 1(0,0)
TPAD14-5
  round 0.356 smd: 1(0,0)
TPAD14-OP
  round 0.356 smd: 1(0,0)
TPAD28
  round 0.711 smd: 1(0,0)
TQFP128-2H48
  rect 0.203x1.27 smd: 1(6.2,7.62) 2(5.8,7.62) 3(5.4,7.62) 4(5,7.62) 5(4.6,7.62) 6(4.2,7.62) 7(3.8,7.62) 8(3.4,7.62) 9(3,7.62) 10(2.6,7.62) 11(2.2,7.62) 12(1.8,7.62) 13(1.4,7.62) 14(0.999,7.62) 15(0.599,7.62) 16(0.199,7.62) 17(-0.199,7.62) 18(-0.599,7.62) 19(-0.999,7.62) 20(-1.4,7.62) 21(-1.8,7.62) 22(-2.2,7.62) 23(-2.6,7.62) 24(-3,7.62) 25(-3.4,7.62) 26(-3.8,7.62) 27(-4.2,7.62) 28(-4.6,7.62) 29(-5,7.62) 30(-5.4,7.62) 31(-5.8,7.62) 32(-6.2,7.62) 65(-6.2,-7.62) 66(-5.8,-7.62) 67(-5.4,-7.62) 68(-5,-7.62) 69(-4.6,-7.62) 70(-4.2,-7.62) 71(-3.8,-7.62) 72(-3.4,-7.62) 73(-3,-7.62) 74(-2.6,-7.62) 75(-2.2,-7.62) 76(-1.8,-7.62) 77(-1.4,-7.62) 78(-0.999,-7.62) 79(-0.599,-7.62) 80(-0.199,-7.62) 81(0.199,-7.62) 82(0.599,-7.62) 83(0.999,-7.62) 84(1.4,-7.62) 85(1.8,-7.62) 86(2.2,-7.62) 87(2.6,-7.62) 88(3,-7.62) 89(3.4,-7.62) 90(3.8,-7.62) 91(4.2,-7.62) 92(4.6,-7.62) 93(5,-7.62) 94(5.4,-7.62) 95(5.8,-7.62) 96(6.2,-7.62)
  rect 1.27x0.203 smd: 33(-7.62,6.2) 34(-7.62,5.8) 35(-7.62,5.4) 36(-7.62,5) 37(-7.62,4.6) 38(-7.62,4.2) 39(-7.62,3.8) 40(-7.62,3.4) 41(-7.62,3) 42(-7.62,2.6) 43(-7.62,2.2) 44(-7.62,1.8) 45(-7.62,1.4) 46(-7.62,0.999) 47(-7.62,0.599) 48(-7.62,0.199) 49(-7.62,-0.199) 50(-7.62,-0.599) 51(-7.62,-0.999) 52(-7.62,-1.4) 53(-7.62,-1.8) 54(-7.62,-2.2) 55(-7.62,-2.6) 56(-7.62,-3) 57(-7.62,-3.4) 58(-7.62,-3.8) 59(-7.62,-4.2) 60(-7.62,-4.6) 61(-7.62,-5) 62(-7.62,-5.4) 63(-7.62,-5.8) 64(-7.62,-6.2) 97(7.62,-6.2) 98(7.62,-5.8) 99(7.62,-5.4) 100(7.62,-5) 101(7.62,-4.6) 102(7.62,-4.2) 103(7.62,-3.8) 104(7.62,-3.4) 105(7.62,-3) 106(7.62,-2.6) 107(7.62,-2.2) 108(7.62,-1.8) 109(7.62,-1.4) 110(7.62,-0.999) 111(7.62,-0.599) 112(7.62,-0.199) 113(7.62,0.199) 114(7.62,0.599) 115(7.62,0.999) 116(7.62,1.4) 117(7.62,1.8) 118(7.62,2.2) 119(7.62,2.6) 120(7.62,3) 121(7.62,3.4) 122(7.62,3.8) 123(7.62,4.2) 124(7.62,4.6) 125(7.62,5) 126(7.62,5.4) 127(7.62,5.8) 128(7.62,6.2)
unnamed#2
  round 0.254 hole 2.616 unplated: (0,0)
XFORM12A127096H81
  rect 0.762x1.6 smd: 1(-4.445,-4.255) 2(-3.175,-4.255) 3(-1.905,-4.255) 4(1.905,-4.255) 5(3.175,-4.255) 6(4.445,-4.255) 7(4.445,4.255) 8(3.175,4.255) 9(1.905,4.255) 10(-1.905,4.255) 11(-3.175,4.255) 12(-4.445,4.255)

## Nets
1V_CPU_CORE: CPU1.AN9 CPU1.AN10 CPU1.AN24 CPU1.AN26 CPU1.AN27 CPU1.AP2 CPU1.AP9 CPU1.AP24 CPU1.AP26 CPU1.AR5 CPU1.AR6 CPU1.AR7 CPU1.AR8 CPU1.AR10 CPU1.AR25 CPU1.AR27 CPU1.AT9 CPU1.AT24 CPU1.AT26 CPU1.AU5 CPU1.AU6 CPU1.AU7 CPU1.AU8 CPU1.AU9 CPU1.AU24 CPU1.AU25 CPU1.AU26 CPU1.AU27 CPU1.AV2 CPU1.AV5 CPU1.AV7 CPU1.AV10 CPU1.AV27 CPU1.AW5 CPU1.AW6 CPU1.AW7 CPU1.AW8 CPU1.AW9 CPU1.AW10 CPU1.AW24 CPU1.AW25 CPU1.AW26 CPU1.AW27 CPU1.AY24 CPU1.AY26 CPU1.BA5 CPU1.BA7 CPU1.BA8 CPU1.BA25 CPU1.BA27 CPU1.BB2 CPU1.BB26 CPU1.BC5 CPU1.BC6 CPU1.BC7 CPU1.BC9 CPU1.BC10 CPU1.BC26 CPU1.BC27 CPU1.BD5 CPU1.BD8 CPU1.BD10 CPU1.BD25 CPU1.BD27 CPU1.BE9 CPU1.BE24 CPU1.BE25 CPU1.BE26 CPU1.BE27 CPU1.BF2 CPU1.BF9 CPU1.BF24 CPU1.BF26 CPU1.BG27 FC8907.1 FC8908.1 FC8909.1 FC8910.1 PC1002.1 PC1003.1 PC1004.1 PC1005.1 PC1006.1 PC1007.1 PC1008.1 PC1009.1 PC1010.1 PC1011.1 PC1012.1 PC1013.1 PC1014.1 PC1015.1 PC1016.1 PC1017.1 PC1018.1 PC1019.1 PC1020.1 PC1021.1 PC1022.1 PC1023.1 PC1024.1 PC1025.1 PC1026.1 PC1027.1 PC1028.1 PC1029.1 PC1030.1 PC1031.1 PC1032.1 PC1034.1 PC1036.1 PC1079.1 PC1080.1 PC1081.1 PC1082.1 PC1083.1 PC1084.1 PG4809.2 PG4815.2 PL4801.2 PL4802.2 PR4631.2 PT4802.1 PT4803.1 R707.1 R811.1 R815.1 R816.1
1V_GT_CORE: CPU1.AA9 CPU1.AB2 CPU1.AB8 CPU1.AB9 CPU1.AB10 CPU1.AC8 CPU1.AD9 CPU1.AE8 CPU1.AE9 CPU1.AE10 CPU1.AF2 CPU1.AF8 CPU1.AF10 CPU1.AG8 CPU1.AG9 CPU1.AH9 CPU1.AJ8 CPU1.AJ10 CPU1.AK2 CPU1.AK9 CPU1.AL8 CPU1.AL9 CPU1.AL10 CPU1.AM8 CPU1.V2 CPU1.Y8 CPU1.Y10 R811.2 R812.1 R815.2 R816.2 R817.1
1V_VCCGT: C1102.1 C1103.1 C1104.1 C1105.1 C1106.1 C1107.1 CPU1.A5 CPU1.A6 CPU1.A8 CPU1.A11 CPU1.A12 CPU1.A14 CPU1.A15 CPU1.A17 CPU1.A18 CPU1.A20 CPU1.B3 CPU1.B4 CPU1.B6 CPU1.B8 CPU1.B11 CPU1.B14 CPU1.B17 CPU1.B20 CPU1.C2 CPU1.C3 CPU1.C6 CPU1.C7 CPU1.C8 CPU1.C11 CPU1.C12 CPU1.C14 CPU1.C15 CPU1.C17 CPU1.C18 CPU1.C20 CPU1.D4 CPU1.D7 CPU1.D11 CPU1.D12 CPU1.D14 CPU1.D15 CPU1.D17 CPU1.D18 CPU1.D20 CPU1.E4 CPU1.F5 CPU1.F6 CPU1.F7 CPU1.F8 CPU1.F11 CPU1.F14 CPU1.F17 CPU1.F20 CPU1.G11 CPU1.G12 CPU1.G14 CPU1.G15 CPU1.G17 CPU1.G18 CPU1.G20 CPU1.H5 CPU1.H6 CPU1.H7 CPU1.H8 CPU1.H11 CPU1.H12 CPU1.H14 CPU1.H15 CPU1.H17 CPU1.H18 CPU1.H20 CPU1.J7 CPU1.J8 CPU1.J11 CPU1.J14 CPU1.J17 CPU1.J20 CPU1.K2 CPU1.K11 CPU1.L7 CPU1.L8 CPU1.L10 CPU1.M9 CPU1.N7 CPU1.N8 CPU1.N9 CPU1.N10 CPU1.P2 CPU1.P8 CPU1.R9 CPU1.T8 CPU1.T9 CPU1.T10 CPU1.U8 CPU1.U10 CPU1.V9 CPU1.W8 CPU1.W9 EC4701.1 FC8905.1 FC8906.1 PC1001.1 PC1037.1 PC1038.1 PC1039.1 PC1040.1 PC1041.1 PC1042.1 PC1043.1 PC1044.1 PC1045.1 PC1046.1 PC1047.1 PC1048.1 PC1049.1 PC1050.1 PC1051.1 PC1052.1 PC1053.1 PC1054.1 PC1055.1 PC1056.1 PC1057.1 PC1058.1 PC1059.1 PC1060.1 PC1061.1 PC1062.1 PC1063.1 PC1064.1 PC1065.1 PC1066.1 PC1067.1 PC1068.1 PC1069.1 PC1070.1 PG4708.2 PL4701.2 PR4663.1 PT4701.1 R807.1 R812.2 R817.2
1V_VCCIO: C1108.1 C1109.1 C1110.1 C1111.1 C1133.1 C1134.1 C1135.1 C4007.1 CPU1.AK24 CPU1.AK26 CPU1.AL24 CPU1.AL25 CPU1.AL26 CPU1.AL27 CPU1.AM25 CPU1.AM27 CPU1.BH24 CPU1.BH25 CPU1.BH26 CPU1.BH27 CPU1.BJ24 CPU1.BJ26 CPU1.BP16 CPU1.BP18 R401.1 R602.2 R604.1 R4042.1 U4002.6 U4002.7 U4002.8
1V_VCCSA: CPU1.BG8 CPU1.BG10 CPU1.BH9 CPU1.BJ8 CPU1.BJ9 CPU1.BJ10 CPU1.BK8 CPU1.BK25 CPU1.BK27 CPU1.BL8 CPU1.BL9 CPU1.BL10 CPU1.BL24 CPU1.BL26 CPU1.BM24 CPU1.BN25 EC5001.1 PC1071.1 PC1072.1 PC1073.1 PC1074.1 PC1075.1 PC1076.1 PC1077.1 PC1078.1 PG5001.2 PL5001.2 R810.1
1V_VCCST_CPU: C801.1 C805.2 C806.2 C807.2 CPU1.BP2 CPU1.BP11 CPU1.BR11 CPU1.BT11 PC4602.1 PR4603.1 PR4604.1 PR4605.1 PR4606.1 R308.1 R704.1 R705.1 R706.1 R4036.2
1V_VCCST_CPU_R: C4012.1 R4036.1 U4006.6 U4006.7 U4006.8
1V_VCCSTG: C802.1 CPU1.BG1 CPU1.BG2 CPU1.BG3 R301.1 R309.2 R310.2 R311.2 R312.2 R313.2 R314.2 R315.2 R4042.2
3V5V_CT1: C4001.1 U4001.12
3V5V_CT2: C4002.1 U4004.12
3V_5V_DSW_OK: D2503.3 PR5308.1 R2514.2 U2502.4
3V_5V_EN: C4009.1 D4001.A PR4504.1 PR4516.1 R4006.1 R4009.1 R4014.1
3V_5V_POK: D2503.1 ED1703.2 PR4505.2 PU4501.9 PU4501.10 PU4502.9 PU4502.10 Q1701.2 R4033.1
3V_5V_POK#: Q1701.5 Q1701.6 R1726.1
5V_3V_TPAN_PWR: C5520.1 R5560.2 R5561.2 U5502.6 U5502.7
5V_AUX_S5: PG4528.2
5V_FAN_VCC: AFTP2603.1 C2603.1 C2604.1 C2605.1 D2601.K FAN1.1 R2612.2
5V_HDD_S0: C6007.1 C6008.1 FC8916.1 HDD1.8 HDD1.10 HDD1.11 HDD1.12 HDD2.9 HDD2.10 HDD2.11 R6001.2
5V_HDMI: C5736.2 F5701.2 HDMI1.18 U5702.2
5V_IRLED: C5504.1 F5506.2 LCD1.24
5V_ODD_S0: AFTP6006.1 AFTP6007.1 C6018.1 C6019.1 ODD1.12 ODD1.13 ODD1.14 ODD1.15 R6003.2
5V_S0: AFTP4003.1 C4005.1 D5701.3 EC8933.1 EC8934.1 EC8935.1 EC8936.1 EC8937.1 EC8938.1 EC8939.1 ED5502.5 F5506.1 F5701.1 F6501.1 FC8903.1 FC8912.1 FC8913.1 Q5701.G Q6505.E R2612.1 R2701.1 R2703.2 R2736.1 R5502.1 R6001.1 R6003.1 R7014.1 U4004.13 U4004.14 U5702.3 VGABD1.1
5V_S5: AFTP4501.1 AFTP4502.1 C3507.1 C3602.1 C4031.1 C4032.1 C4041.1 C7205.1 C7206.1 C7403.1 C7404.1 EC6601.1 EC8947.1 EC8948.1 ED6601.5 FC8973.1 FC8975.1 FC8976.1 FC8990.1 IOBD1.17 IOBD1.18 IOBD1.19 IOBD1.20 PC4514.1 PC4515.1 PC4516.1 PC4517.1 PC4518.1 PC4527.1 PC4529.1 PC4766.1 PC4866.1 PC4877.1 PC5001.1 PC5120.1 PC5121.1 PC5202.1 PC5301.1 PG4527.2 PL4502.2 PR4610.1 PR4670.2 PR4704.2 PR4813.2 PR4825.2 PR5108.1 PU4701.29 PU4801.29 PU4802.29 PU5001.6 PU5101.6 PU5201.21 PU5301.6 Q6403.E Q6404.E Q6405.E R3602.1 R3605.1 R3606.1 R4303.1 R5560.1 R7205.1 U3502.5 U3601.1 U4001.4 U4002.3 U4003.3 U4004.1 U4004.2 U4004.4 U4006.3 U5502.4 U7202.2 U7403.A1 U7403.A2
5V_TPAN_PWR: F5505.1 R5502.2 U5502.8 U5502.9
5V_TPAN_VDD: C5516.1 C5517.1 F5505.2 LCD1.25
5V_USB30_VCCA: AFTP3508.1 C3516.1 C3517.1 C3518.1 C3519.1 R3513.1 U3502.1 USB2.1
5V_VCONN_EN: R7205.2 U7202.3
5V_VCONN_P1: R7203.1 U7202.5 U7202.6
5V_VCONN_P1_CCG4: R7203.2 U7201.5
19V_AD+: C4303.1 C4304.1 C4305.1 C4306.1 PD4401.1 PD4408.1 PR4464.2 PR4465.1 PR4473.1 PU4301.5 PU4301.6 PU4301.7 PU4301.8 PU4302.5 PU4302.6 PU4302.7 PU4302.8 R4311.1 R4316.1
20V_DCBATOUT: AFTP4408.1 PC4402.1 PC4403.1 PC4404.1 PC4405.1 PG4402.1 PG4419.1 PR4401.2 PR4439.1 PU4403.5 PU4403.6 PU4403.7 PU4403.8
20V_VCCPD_VBUS: AFTP7301.1 AFTP7302.1 C7214.1 C7302.1 C7303.1 C7304.1 C7305.1 C7306.1 C7307.1 D7401.K JUSB1.A4 JUSB1.A9 JUSB1.B4 JUSB1.B9 R7201.2 R7217.1 R7410.1 R7423.1 R7425.1 R7426.1 U7203.6 U7403.C2 U7403.D1 U7403.D2 U7419.B2 U7419.C2 U7419.D2 U7419.E1 U7419.E2
20V_VCCPD_VBUS_R: C7201.2 R7201.1 R7213.2 U7201.3
+1.8VALW_EC: C2423.1 R2462.1 U2401.54
+3V_1D8V_DVDD: C2720.1 C2721.1 C2723.1 C2736.1 C2740.1 C2741.1 HDA27.1 HDA27.8 R2710.1 R2715.2 R2717.1
+3VALW_EC: C2410.1 C2411.1 C2412.1 C2413.1 C2414.1 C2420.1 C2422.1 C2429.1 DBEC1.1 ED4304.2 ED4305.2 ED4306.2 Q2417.2 Q2417.5 R2414.2 R2415.2 R2424.2 R2443.1 R2446.2 R2450.2 R2480.2 R2608.1 R7215.1 RN2402.1(A) RN2402.2(A) RN2403.1(A) RN2403.2(A) RN2403.3(A) RN2403.4(A) RN2404.1(A) RN2404.2(A) RN2404.3(A) RN2404.4(A) RN2407.1(A) RN2407.2(A) RN2409.1(A) RN2409.2(A) RN2409.3(A) RN2409.4(A) RN2410.1(A) RN2410.2(A) RN2410.3(A) RN2410.4(A) RN2411.1(A) RN2411.2(A) RN2412.1(A) RN2412.2(A) RN2412.3(A) RN2412.4(A) RN2413.1(A) RN2413.2(A) U2401.5 U2401.19 U2401.22 U2401.43 U2401.65 U2401.82 U2401.103 U2401.115
+5V_AVDD: C2706.1 C2707.1 HDA27.20 R2703.1
+5V_KB_BL: C6501.1 F6501.2 KBBL1.1
+5V_PVDD: C2713.1 C2714.1 C2717.1 C2718.1 HDA27.34 HDA27.39 R2701.2 R2736.2
GND: AFTP2604.1 AFTP4306.1 AFTP4307.1 AFTP4308.1 AFTP6403.1 AFTP6501.1 AFTP6531.1 AFTP6537.1 BATT1.8 BATT1.9 BATT1.10 BATT1.11 BATT1.12 BIOS1.4 BIOS2.4 C501.2 C801.2 C802.2 C803.2 C804.2 C805.1 C806.1 C807.1 C1102.2 C1103.2 C1104.2 C1105.2 C1106.2 C1107.2 C1108.2 C1109.2 C1110.2 C1111.2 C1112.2 C1113.2 C1114.2 C1115.2 C1116.2 C1117.2 C1118.2 C1119.2 C1120.2 C1121.2 C1122.2 C1123.2 C1128.2 C1129.2 C1130.2 C1131.2 C1132.2 C1133.2 C1134.2 C1135.2 C1136.2 C1137.2 C1138.2 C1139.2 C1140.2 C1141.2 C1142.2 C1202.2 C1203.2 C1204.2 C1205.2 C1206.2 C1207.2 C1208.2 C1209.2 C1210.2 C1214.2 C1215.2 C1216.2 C1217.2 C1218.2 C1219.2 C1220.2 C1221.2 C1223.2 C1225.2 C1226.2 C1227.2 C1228.2 C1229.2 C1231.2 C1301.2 C1303.2 C1304.2 C1305.2 C1306.2 C1307.2 C1308.2 C1309.2 C1310.2 C1311.2 C1313.2 C1315.2 C1316.2 C1317.2 C1318.2 C1319.2 C1320.2 C1321.2 C1322.2 C1324.2 C1325.2 C1326.2 C1327.2 C1328.2 C1329.2 C1701.2 C1702.2 C1703.2 C1711.2 C1803.2 C1804.2 C1805.2 C1806.2 C1807.1 C1808.1 C1809.2 C2201.2 C2202.2 C2203.2 C2204.2 C2205.2 C2206.2 C2207.2 C2208.2 C2209.2 C2210.2 C2211.2 C2212.2 C2213.2 C2214.2 C2215.2 C2216.2 C2217.2 C2218.2 C2219.2 C2220.2 C2221.2 C2222.2 C2223.2 C2224.2 C2225.2 C2226.2 C2227.2 C2228.2 C2229.2 C2230.2 C2231.2 C2405.2 C2406.2 C2407.1 C2408.1 C2409.2 C2410.2 C2411.2 C2412.2 C2413.2 C2414.2 C2416.2 C2418.2 C2420.2 C2421.2 C2422.2 C2423.2 C2424.1 C2425.1 C2426.2 C2428.2 C2429.2 C2431.2 C2432.2 C2435.2 C2501.2 C2502.2 C2503.2 C2517.2 C2525.2 C2601.2 C2602.2 C2603.2 C2604.2 C2605.2 C2610.2 C2612.2 C2613.2 C2614.2 C2704.2 C2705.1 C2709.2 C2713.2 C2714.2 C2717.2 C2718.2 C2720.2 C2721.2 C2722.2 C2723.2 C2736.2 C2740.2 C2741.2 C3103.2 C3108.2 C3110.2 C3112.2 C3115.2 C3116.2 C3117.2 C3118.2 C3119.2 C3120.2 C3121.2 C3122.2 C3123.2 C3124.2 C3125.2 C3126.2 C3202.2 C3203.2 C3507.2 C3516.2 C3517.2 C3518.2 C3519.2 C3524.2 C3525.2 C3526.2 C3527.2 C3602.2 C4001.2 C4002.2 C4004.2 C4005.2 C4006.2 C4007.2 C4008.2 C4009.2 C4010.2 C4011.2 C4012.2 C4013.2 C4014.2 C4015.2 C4017.2 C4031.2 C4032.2 C4033.2 C4034.2 C4035.2 C4036.2 C4041.2 C4043.2 C4302.2 C4303.2 C4304.2 C4305.2 C4306.2 C4344.2 C5503.2 C5504.2 C5505.2 C5512.2 C5513.2 C5514.2 C5516.2 C5517.2 C5520.2 C5528.2 C5529.2 C5530.2 C5531.2 C5535.2 C5536.2 C5538.2 C5539.2 C5540.2 C5541.2 C5599.2 C5736.1 C5809.1 C5810.2 C5811.2 C5812.2 C5813.2 C5863.2 C6007.2 C6008.2 C6018.2 C6019.2 C6102.2 C6104.2 C6105.2 C6106.2 C6304.2 C6305.2 C6306.2 C6307.2 C6308.2 C6317.2 C6318.2 C6319.2 C6320.2 C6321.2 C6322.2 C6323.2 C6324.2 C6401.2 C6405.2 C6501.2 C6505.2 C6506.2 C6507.2 C6508.2 C7003.2 C7004.2 C7115.1 C7116.1 C7117.1 C7118.1 C7119.2 C7120.2 C7165.1 C7166.1 C7201.1 C7202.2 C7203.2 C7204.2 C7205.2 C7206.2 C7207.2 C7208.2 C7209.2 C7210.2 C7211.2 C7212.2 C7213.2 C7214.2 C7215.1 C7216.2 C7217.2 C7302.2 C7303.2 C7304.2 C7305.2 C7306.2 C7307.2 C7403.2 C7404.2 C7405.2 C9104.2 C9106.2 C9108.2 C9109.2 C9112.2 C9113.2 C9201.2 C9202.2 C9203.2 CPU1.A3 CPU1.A4 CPU1.A32 CPU1.A36 CPU1.AB3 CPU1.AB4 CPU1.AB7 CPU1.AB27 CPU1.AB30 CPU1.AB33 CPU1.AB36 CPU1.AC5 CPU1.AC10 CPU1.AC27 CPU1.AC30 CPU1.AD33 CPU1.AD35 CPU1.AE7 CPU1.AE24 CPU1.AE25 CPU1.AE26 CPU1.AE27 CPU1.AE30 CPU1.AF3 CPU1.AF4 CPU1.AF7 CPU1.AF25 CPU1.AF27 CPU1.AF30 CPU1.AF33 CPU1.AF36 CPU1.AG5 CPU1.AG10 CPU1.AG24 CPU1.AG26 CPU1.AH24 CPU1.AH25 CPU1.AH27 CPU1.AH28 CPU1.AH29 CPU1.AH30 CPU1.AH31 CPU1.AH33 CPU1.AH35 CPU1.AJ7 CPU1.AJ25 CPU1.AJ28 CPU1.AK3 CPU1.AK4 CPU1.AK33 CPU1.AK36 CPU1.AL7 CPU1.AL28 CPU1.AL29 CPU1.AL32 CPU1.AM5 CPU1.AM10 CPU1.AM28 CPU1.AM33 CPU1.AM35 CPU1.AN7 CPU1.AN8 CPU1.AN25 CPU1.AN28 CPU1.AN29 CPU1.AN30 CPU1.AN31 CPU1.AP3 CPU1.AP4 CPU1.AP33 CPU1.AP36 CPU1.AR4 CPU1.AR28 CPU1.AT4 CPU1.AT33 CPU1.AT35 CPU1.AT36 CPU1.AU4 CPU1.AU10 CPU1.AU28 CPU1.AU29 CPU1.AU32 CPU1.AV3 CPU1.AV4 CPU1.AV6 CPU1.AV8 CPU1.AV25 CPU1.AV28 CPU1.AV33 CPU1.AV36 CPU1.AW1 CPU1.AW3 CPU1.AW4 CPU1.AW28 CPU1.AW29 CPU1.AW30 CPU1.AW31 CPU1.AY4 CPU1.AY33 CPU1.AY35 CPU1.B2 CPU1.B5 CPU1.B7 CPU1.B9 CPU1.B12 CPU1.B15 CPU1.B18 CPU1.B21 CPU1.B23 CPU1.B25 CPU1.B27 CPU1.B29 CPU1.B31 CPU1.B34 CPU1.B36 CPU1.B37 CPU1.BA3 CPU1.BA4 CPU1.BA6 CPU1.BA10 CPU1.BA28 CPU1.BB3 CPU1.BB4 CPU1.BB33 CPU1.BB36 CPU1.BC4 CPU1.BC8 CPU1.BC25 CPU1.BC29 CPU1.BC32 CPU1.BD4 CPU1.BD6 CPU1.BD7 CPU1.BD28 CPU1.BD33 CPU1.BD35 CPU1.BD36 CPU1.BE3 CPU1.BE4 CPU1.BE8 CPU1.BE10 CPU1.BE28 CPU1.BE29 CPU1.BE30 CPU1.BE31 CPU1.BF3 CPU1.BF4 CPU1.BF33 CPU1.BF36 CPU1.BG4 CPU1.BG25 CPU1.BG28 CPU1.BH28 CPU1.BH29 CPU1.BH32 CPU1.BH33 CPU1.BH35 CPU1.BJ7 CPU1.BK2 CPU1.BK3 CPU1.BK4 CPU1.BK7 CPU1.BK10 CPU1.BK28 CPU1.BK33 CPU1.BL7 CPU1.BL25 CPU1.BL28 CPU1.BL29 CPU1.BL30 CPU1.BL31 CPU1.BL32 CPU1.BM9 CPU1.BM33 CPU1.BM35 CPU1.BM36 CPU1.BN7 CPU1.BN30 CPU1.BP3 CPU1.BP4 CPU1.BP7 CPU1.BP12 CPU1.BP15 CPU1.BP19 CPU1.BP25 CPU1.BP32 CPU1.BP33 CPU1.BP36 CPU1.BR16 CPU1.BR19 CPU1.BR22 CPU1.BR25 CPU1.BT5 CPU1.BT14 CPU1.BT15 CPU1.BT16 CPU1.BT25 CPU1.BT28 CPU1.BT33 CPU1.BT35 CPU1.BT36 CPU1.BU7 CPU1.BU11 CPU1.BU16 CPU1.BU20 CPU1.BU23 CPU1.BU24 CPU1.BU25 CPU1.BV3 CPU1.BV4 CPU1.BV11 CPU1.BV31 CPU1.BV33 CPU1.BW7 CPU1.BW11 CPU1.BW15 CPU1.BW24 CPU1.BY5 CPU1.BY11 CPU1.BY15 CPU1.BY18 CPU1.BY19 CPU1.BY22 CPU1.BY25 CPU1.BY28 CPU1.BY33 CPU1.BY35 CPU1.BY36 CPU1.C1 CPU1.C4 CPU1.C9 CPU1.C21 CPU1.C25 CPU1.C29 CPU1.C33 CPU1.C36 CPU1.C37 CPU1.CA11 CPU1.CA15 CPU1.CA22 CPU1.CA25 CPU1.CB2 CPU1.CB3 CPU1.CB4 CPU1.CB7 CPU1.CB11 CPU1.CB18 CPU1.CB19 CPU1.CB20 CPU1.CB24 CPU1.CB25 CPU1.CB33 CPU1.CC7 CPU1.CC11 CPU1.CC14 CPU1.CC16 CPU1.CC20 CPU1.CC24 CPU1.CC25 CPU1.CC28 CPU1.CC31 CPU1.CD11 CPU1.CD12 CPU1.CD14 CPU1.CD20 CPU1.CD24 CPU1.CD25 CPU1.CE7 CPU1.CE33 CPU1.CE35 CPU1.CE36 CPU1.CF2 CPU1.CF3 CPU1.CF4 CPU1.CF11 CPU1.CF14 CPU1.CF19 CPU1.CF23 CPU1.CF28 CPU1.CG7 CPU1.CG33 CPU1.CH31 CPU1.CJ2 CPU1.CJ3 CPU1.CJ4 CPU1.CJ11 CPU1.CJ14 CPU1.CJ19 CPU1.CJ23 CPU1.CJ28 CPU1.CJ33 CPU1.CJ35 CPU1.CJ36 CPU1.CK1 CPU1.CK4 CPU1.CK7 CPU1.CK37 CPU1.CL2 CPU1.CM1 CPU1.CM4 CPU1.CM5 CPU1.CM9 CPU1.CM13 CPU1.CM17 CPU1.CM21 CPU1.CM25 CPU1.CM29 CPU1.CM31 CPU1.CM33 CPU1.CM37 CPU1.CN1 CPU1.CN2 CPU1.CN5 CPU1.CN9 CPU1.CN13 CPU1.CN17 CPU1.CN21 CPU1.CN25 CPU1.CN29 CPU1.CN37 CPU1.CP1 CPU1.CP2 CPU1.CP9 CPU1.CP11 CPU1.CP13 CPU1.CP15 CPU1.CP19 CPU1.CP21 CPU1.CP27 CPU1.CP35 CPU1.CP37 CPU1.CR2 CPU1.CR6 CPU1.CR34 CPU1.CR36 CPU1.D1 CPU1.D5 CPU1.D6 CPU1.D8 CPU1.D9 CPU1.D21 CPU1.D25 CPU1.E9 CPU1.E23 CPU1.E27 CPU1.E29 CPU1.E31 CPU1.E33 CPU1.E35 CPU1.F2 CPU1.F3 CPU1.F4 CPU1.F12 CPU1.F15 CPU1.F18 CPU1.F21 CPU1.F24 CPU1.F33 CPU1.G9 CPU1.G21 CPU1.G27 CPU1.G33 CPU1.G35 CPU1.G36 CPU1.H9 CPU1.H21 CPU1.H27 CPU1.J5 CPU1.J6 CPU1.J12 CPU1.J15 CPU1.J18 CPU1.J21 CPU1.J24 CPU1.J33 CPU1.J36 CPU1.K3 CPU1.K4 CPU1.K9 CPU1.K21 CPU1.K22 CPU1.K24 CPU1.K25 CPU1.K27 CPU1.K28 CPU1.K29 CPU1.K30 CPU1.K31 CPU1.K32 CPU1.L6 CPU1.L27 CPU1.L33 CPU1.L35 CPU1.L36 CPU1.N6 CPU1.N25 CPU1.N27 CPU1.P3 CPU1.P4 CPU1.P7 CPU1.P10 CPU1.P33 CPU1.P36 CPU1.R27 CPU1.R28 CPU1.R29 CPU1.R30 CPU1.R31 CPU1.T7 CPU1.T27 CPU1.T30 CPU1.T33 CPU1.T35 CPU1.T36 CPU1.U7 CPU1.U24 CPU1.U26 CPU1.V3 CPU1.V4 CPU1.V26 CPU1.V27 CPU1.V30 CPU1.V33 CPU1.V36 CPU1.W7 CPU1.W10 CPU1.W27 CPU1.W30 CPU1.Y7 CPU1.Y26 CPU1.Y27 CPU1.Y30 CPU1.Y33 CPU1.Y35 D2601.A D4301.A D4302.1 D4304.A DBEC1.4 DBEC1.7 DBEC1.8 DBG1.3 DBG1.15 DBG1.16 DCIN1.9 DCIN1.10 DM1.1 DM1.2 DM1.5 DM1.6 DM1.9 DM1.10 DM1.14 DM1.15 DM1.18 DM1.19 DM1.22 DM1.23 DM1.26 DM1.27 DM1.30 DM1.31 DM1.35 DM1.36 DM1.39 DM1.40 DM1.43 DM1.44 DM1.47 DM1.48 DM1.51 DM1.52 DM1.56 DM1.57 DM1.60 DM1.61 DM1.64 DM1.65 DM1.68 DM1.69 DM1.72 DM1.73 DM1.77 DM1.78 DM1.81 DM1.82 DM1.85 DM1.86 DM1.89 DM1.90 DM1.93 DM1.94 DM1.98 DM1.99 DM1.102 DM1.103 DM1.106 DM1.107 DM1.167 DM1.168 DM1.171 DM1.172 DM1.175 DM1.176 DM1.180 DM1.181 DM1.184 DM1.185 DM1.188 DM1.189 DM1.192 DM1.193 DM1.196 DM1.197 DM1.201 DM1.202 DM1.205 DM1.206 DM1.209 DM1.210 DM1.213 DM1.214 DM1.217 DM1.218 DM1.222 DM1.223 DM1.226 DM1.227 DM1.230 DM1.231 DM1.234 DM1.235 DM1.238 DM1.239 DM1.243 DM1.244 DM1.247 DM1.248 DM1.251 DM1.252 DM1.261 DM1.262 DM2.1 DM2.2 DM2.5 DM2.6 DM2.9 DM2.10 DM2.14 DM2.15 DM2.18 DM2.19 DM2.22 DM2.23 DM2.26 DM2.27 DM2.30 DM2.31 DM2.35 DM2.36 DM2.39 DM2.40 DM2.43 DM2.44 DM2.47 DM2.48 DM2.51 DM2.52 DM2.56 DM2.57 DM2.60 DM2.61 DM2.64 DM2.65 DM2.68 DM2.69 DM2.72 DM2.73 DM2.77 DM2.78 DM2.81 DM2.82 DM2.85 DM2.86 DM2.89 DM2.90 DM2.93 DM2.94 DM2.98 DM2.99 DM2.102 DM2.103 DM2.106 DM2.107 DM2.167 DM2.168 DM2.171 DM2.172 DM2.175 DM2.176 DM2.180 DM2.181 DM2.184 DM2.185 DM2.188 DM2.189 DM2.192 DM2.193 DM2.196 DM2.197 DM2.201 DM2.202 DM2.205 DM2.206 DM2.209 DM2.210 DM2.213 DM2.214 DM2.217 DM2.218 DM2.222 DM2.223 DM2.226 DM2.227 DM2.230 DM2.231 DM2.234 DM2.235 DM2.238 DM2.239 DM2.243 DM2.244 DM2.247 DM2.248 DM2.251 DM2.252 DM2.261 DM2.262 EC1202.2 EC1203.2 EC1303.2 EC1707.2 EC1712.2 EC1801.2 EC1803.1 EC1901.1 EC1903.2 EC2201.2 EC2501.2 EC2502.2 EC2503.2 EC2504.2 EC2505.2 EC2506.2 EC2601.2 EC2602.2 EC2701.2 EC2702.2 EC2703.2 EC2704.2 EC2705.2 EC2901.2 EC2902.2 EC2903.2 EC2904.2 EC3513.2 EC4306.1 EC4307.2 EC4308.2 EC4309.2 EC4310.2 EC4311.2 EC4701.2 EC5001.2 EC5503.2 EC5504.2 EC6401.2 EC6402.2 EC6403.2 EC6404.2 EC6405.2 EC6501.2 EC6502.2 EC6503.2 EC6504.2 EC6601.2 EC8902.2 EC8904.2 EC8906.2 EC8909.2 EC8910.2 EC8911.2 EC8912.2 EC8913.2 EC8914.2 EC8915.2 EC8923.2 EC8924.2 EC8932.2 EC8933.2 EC8934.2 EC8935.2 EC8936.2 EC8937.2 EC8938.2 EC8939.2 EC8947.2 EC8948.2 EC8950.2 EC8951.2 EC8952.2 EC8953.2 EC8955.2 EC8956.1 EC8962.1 EC8963.2 ED301.3 ED1217.3 ED1302.3 ED1701.1 ED1702.1 ED1703.1 ED1705.1 ED1706.1 ED1707.1 ED1801.1 ED1802.1 ED2403.3 ED2910.3 ED2911.3 ED2912.3 ED3201.3 ED3201.8 ED3202.3 ED3202.8 ED3501.3 ED3501.8 ED3502.2 ED3503.3 ED3503.8 ED4303.2 ED4304.1 ED4305.1 ED4306.1 ED5502.2 ED5701.3 ED5701.8 ED5702.3 ED5702.8 ED5703.3 ED5703.8 ED6001.3 ED6001.8 ED6401.3 ED6601.2 ED7301.3 ED7301.8 ED7302.3 ED7302.8 ED7307.3 ED7311.1 ED7312.1 ED7313.1 ED7314.1 ED7315.3 ED9202.2 EL4303.2 EL4304.2 FAN1.2 FAN1.5 FAN1.6 FC1102.2 FC1103.2 FC4534.2 FC5501.2 FC5502.2 FC5503.2 FC5504.2 FC5505.2 FC5506.2 FC8901.2 FC8902.2 FC8903.2 FC8904.2 FC8905.2 FC8906.2 FC8907.2 FC8908.2 FC8909.2 FC8910.2 FC8911.2 FC8912.2 FC8913.2 FC8914.2 FC8915.2 FC8916.2 FC8917.2 FC8918.2 FC8919.2 FC8920.2 FC8921.2 FC8922.2 FC8923.2 FC8924.2 FC8925.2 FC8926.2 FC8927.2 FC8928.2 FC8929.2 FC8930.2 FC8931.2 FC8932.2 FC8933.2 FC8934.2 FC8935.2 FC8936.2 FC8937.2 FC8938.2 FC8939.2 FC8940.2 FC8941.2 FC8942.2 FC8943.2 FC8944.2 FC8945.2 FC8946.2 FC8947.2 FC8948.2 FC8949.2 FC8950.2 FC8951.2 FC8952.2 FC8953.2 FC8954.2 FC8955.2 FC8956.2 FC8957.2 FC8958.2 FC8959.2 FC8960.2 FC8961.2 FC8962.2 FC8963.2 FC8964.2 FC8965.2 FC8966.2 FC8967.2 FC8968.2 FC8969.2 FC8970.2 FC8971.2 FC8972.2 FC8973.2 FC8974.2 FC8975.2 FC8976.2 FC8977.2 FC8978.2 FC8979.2 FC8980.2 FC8981.2 FC8982.2 FC8983.2 FC8984.2 FC8985.2 FC8986.2 FC8987.2 FC8988.2 FC8989.1 FC8990.2 FP1.5 FP1.8 FP1.9 FP1.10 G1801.1 G6401.2 G6402.2 H9.1 H10.1 H11.1 H12.1 H13.1 H14.1 H16.1 H17.1 H18.1 H19.1 H20.1 H21.1 H22.1 HDA27.41 HDD1.1 HDD1.2 HDD1.3 HDD1.4 HDD1.14 HDD1.17 HDD1.20 HDD1.21 HDD1.22 HDD1.23 HDD1.24 HDD2.1 HDD2.4 HDD2.7 HDD2.13 HDD2.14 HDMI1.2 HDMI1.5 HDMI1.8 HDMI1.11 HDMI1.17 HDMI1.20 HDMI1.21 HDMI1.22 HDMI1.23 HS3.1 IOBD1.1 IOBD1.4 IOBD1.7 IOBD1.10 IOBD1.21 IOBD1.22 JUSB1.13 JUSB1.14 JUSB1.15 JUSB1.16 JUSB1.17 JUSB1.18 JUSB1.19 JUSB1.20 JUSB1.21 JUSB1.22 JUSB1.A1 JUSB1.A12 JUSB1.B1 JUSB1.B12 KB1.1 KB1.31 KB1.32 KBBL1.5 KBBL1.6 LCD1.1 LCD1.4 LCD1.7 LCD1.11 LCD1.17 LCD1.41 LCD1.42 LCD1.43 LCD1.44 LED1.3 MESW1.4 MESW1.5 MESW1.6 MESW1.7 ODD1.3 ODD1.6 ODD1.9 ODD1.10 ODD1.17 ODD1.18 PC1001.2 PC1002.2 PC1003.2 PC1004.2 PC1005.2 PC1006.2 PC1007.2 PC1008.2 PC1009.2 PC1010.2 PC1011.2 PC1012.2 PC1013.2 PC1014.2 PC1015.2 PC1016.2 PC1017.2 PC1018.2 PC1019.2 PC1020.2 PC1021.2 PC1022.2 PC1023.2 PC1024.2 PC1025.2 PC1026.2 PC1027.2 PC1028.2 PC1029.2 PC1030.2 PC1031.2 PC1032.2 PC1034.2 PC1036.2 PC1037.2 PC1038.2 PC1039.2 PC1040.2 PC1041.2 PC1042.2 PC1043.2 PC1044.2 PC1045.2 PC1046.2 PC1047.2 PC1048.2 PC1049.2 PC1050.2 PC1051.2 PC1052.2 PC1053.2 PC1054.2 PC1055.2 PC1056.2 PC1057.2 PC1058.2 PC1059.2 PC1060.2 PC1061.2 PC1062.2 PC1063.2 PC1064.2 PC1065.2 PC1066.2 PC1067.2 PC1068.2 PC1069.2 PC1070.2 PC1071.2 PC1072.2 PC1073.2 PC1074.2 PC1075.2 PC1076.2 PC1077.2 PC1078.2 PC1079.2 PC1080.2 PC1081.2 PC1082.2 PC1083.2 PC1084.2 PC4402.2 PC4403.2 PC4404.2 PC4405.2 PC4406.2 PC4407.2 PC4408.2 PC4409.2 PC4410.2 PC4411.2 PC4412.2 PC4413.2 PC4414.2 PC4416.1 PC4417.1 PC4418.2 PC4419.2 PC4420.1 PC4421.2 PC4422.2 PC4424.1 PC4426.1 PC4427.2 PC4429.2 PC4430.2 PC4431.2 PC4432.2 PC4433.2 PC4434.2 PC4435.2 PC4437.2 PC4439.1 PC4440.1 PC4441.2 PC4446.2 PC4447.2 PC4448.2 PC4501.2 PC4502.2 PC4503.2 PC4504.2 PC4505.2 PC4507.2 PC4508.2 PC4509.2 PC4510.2 PC4511.2 PC4512.2 PC4513.2 PC4514.2 PC4515.2 PC4516.2 PC4517.2 PC4518.2 PC4519.2 PC4520.2 PC4522.2 PC4523.2 PC4524.2 PC4525.2 PC4527.2 PC4529.2 PC4530.2 PC4531.2 PC4532.2 PC4601.2 PC4602.2 PC4603.1 PC4604.1 PC4606.2 PC4607.2 PC4610.1 PC4612.2 PC4613.2 PC4614.2 PC4615.1 PC4620.2 PC4621.1 PC4622.2 PC4624.2 PC4629.1 PC4631.2 PC4633.2 PC4637.2 PC4638.2 PC4639.2 PC4640.2 PC4641.2 PC4644.2 PC4651.2 PC4701.2 PC4702.2 PC4703.2 PC4704.2 PC4706.2 PC4708.2 PC4766.2 PC4802.2 PC4803.2 PC4804.2 PC4805.2 PC4809.2 PC4810.2 PC4812.2 PC4813.2 PC4814.2 PC4815.2 PC4816.2 PC4817.2 PC4866.2 PC4877.2 PC5001.2 PC5002.2 PC5003.2 PC5004.2 PC5103.2 PC5104.2 PC5105.2 PC5106.2 PC5107.2 PC5112.2 PC5113.2 PC5114.2 PC5115.2 PC5116.2 PC5117.2 PC5118.2 PC5119.2 PC5120.2 PC5121.2 PC5122.2 PC5123.2 PC5124.2 PC5127.2 PC5201.2 PC5202.2 PC5203.2 PC5205.2 PC5206.2 PC5208.2 PC5209.2 PC5210.2 PC5211.2 PC5213.2 PC5214.2 PC5215.2 PC5216.2 PC5217.2 PC5301.2 PC5302.2 PC5303.2 PC5305.2 PC5306.2 PD5101.A PMBD1.11 PQ4405.1 PQ4405.4 PQ4415.1 PQ4415.4 PQ4416.1 PQ4416.4 PQ4417.S PQ4418.1 PQ4418.4 PR4406.2 PR4410.1 PR4413.2 PR4417.1 PR4426.2 PR4436.2 PR4447.2 PR4451.2 PR4453.1 PR4474.1 PR4475.2 PR4485.2 PR4492.2 PR4494.2 PR4497.1 PR4508.2 PR4512.2 PR4513.2 PR4514.2 PR4551.2 PR4608.1 PR4614.2 PR4617.2 PR4621.1 PR4627.1 PR4628.2 PR4629.2 PR4639.2 PR4644.2 PR4654.2 PR4655.1 PR4659.1 PR4661.2 PR5104.2 PR5109.2 PR5114.2 PR5120.2 PR5203.2 PR5204.2 PR5305.2 PT4701.2 PT4702.2 PT4802.2 PT4803.2 PT4807.2 PU4401.33 PU4404.1 PU4404.2 PU4404.3 PU4406.1 PU4406.2 PU4406.3 PU4501.7 PU4501.8 PU4501.18 PU4501.21 PU4502.7 PU4502.8 PU4502.18 PU4502.21 PU4601.41 PU4701.12 PU4701.13 PU4701.14 PU4701.15 PU4701.28 PU4701.32 PU4701.34 PU4801.12 PU4801.13 PU4801.14 PU4801.15 PU4801.28 PU4801.32 PU4801.34 PU4802.12 PU4802.13 PU4802.14 PU4802.15 PU4802.28 PU4802.32 PU4802.34 PU5001.4 PU5001.9 PU5003.1 PU5003.2 PU5003.3 PU5101.1 PU5102.4 PU5102.11 PU5102.12 PU5102.13 PU5102.14 PU5102.15 PU5102.16 PU5102.30 PU5102.32 PU5102.33 PU5201.4 PU5201.12 PU5201.13 PU5201.14 PU5201.15 PU5201.19 PU5301.1 PWR1.5 PWR1.7 PWR1.8 Q401.1 Q401.4 Q501.S Q502.S Q1701.1 Q1701.4 Q1702.1 Q1702.4 Q2408.S Q2505.S Q2510.S Q4302.E Q4304.E Q4349.1 Q4349.4 Q5504.2 Q5505.2 Q5701.S Q6301.S Q6302.S Q6501.S Q6503.S Q7001.1 Q7001.4 Q7201.S Q7404.1 Q7404.4 Q7405.4 Q7406.1 Q7406.4 Q7407.1 Q7407.4 Q7408.S Q9202.S R304.2 R305.2 R316.2 R317.2 R318.2 R403.1 R501.2 R502.2 R503.2 R601.2 R708.2 R808.2 R809.2 R1205.2 R1209.2 R1210.2 R1212.2 R1216.2 R1303.2 R1307.2 R1309.2 R1311.2 R1516.2 R1517.2 R1518.2 R1521.2 R1603.2 R1714.2 R1715.2 R1717.2 R1719.2 R1803.2 R1817.2 R1901.2 R1911.2 R2007.2 R2009.2 R2063.2 R2101.2 R2108.2 R2112.2 R2114.2 R2116.2 R2118.2 R2417.2 R2436.2 R2441.2 R2444.2 R2448.2 R2449.1 R2454.2 R2465.2 R2504.2 R2517.2 R2518.2 R2610.2 R2704.2 R2705.2 R2735.2 R3102.2 R3113.2 R3603.1 R3604.1 R4006.2 R4301.1 R4302.2 R4308.2 R4312.2 R4315.1 R4316.2 R4377.2 R4381.1 R5544.1 R5549.1 R5552.2 R5555.2 R5764.1 R5782.2 R5804.2 R5808.1 R5810.1 R5812.1 R5814.1 R5816.1 R5818.2 R5819.2 R5823.1 R6101.2 R6121.2 R6122.2 R6335.2 R6336.2 R6337.2 R6413.1 R6508.2 R6804.2 R7007.1 R7011.2 R7102.1 R7129.1 R7130.1 R7141.2 R7143.2 R7144.2 R7146.2 R7170.2 R7172.2 R7173.2 R7185.2 R7186.2 R7187.2 R7188.2 R7213.1 R7214.2 R7218.2 R7219.2 R7330.1 R7331.1 R7404.2 R7405.1 R7415.2 R7418.2 R7422.2 R7429.2 R7430.2 R7431.2 R7432.2 R7434.2 R9101.1 R9323.1 R9324.1 R9325.1 R9326.1 R9327.1 R9328.1 R9329.1 R9330.1 R9331.1 R9332.1 R9333.1 R9334.1 R9335.1 R9336.1 R9337.1 R9338.1 RJ1.9 RJ1.10 RJ1.11 RJ1.12 RN1201.2(A) RN1301.2(A) RN1602.3(B) RN1602.4(B) RN1703.1(A) RN1703.2(A) RN5502.5(B) RN5502.6(B) RN5502.7(B) RN5502.8(B) SPK1.5 SPK1.6 SPR3.1 SPR4.1 SPR5.1 SPR6.1 SPR7.1 SPR8.1 SPR9.1 SSD1.1 SSD1.3 SSD1.9 SSD1.15 SSD1.21 SSD1.27 SSD1.33 SSD1.39 SSD1.45 SSD1.51 SSD1.57 SSD1.71 SSD1.73 SSD1.75 SSD1.76 SSD1.77 TP1.5 TP1.9 TP1.10 U2401.17 U2401.51 U2401.64 U2401.84 U2401.100 U2401.112 U2401.124 U2402.3 U2502.2 U2601.5 U3101.33 U3502.2 U3601.14 U3601.17 U4001.11 U4001.15 U4002.5 U4003.5 U4004.11 U4004.15 U4006.5 U4007.3 U4302.3 U5501.2 U5502.11 U5502.15 U5702.1 U5802.11 U5802.19 U5802.52 U5802.61 U6101.2 U6301.A6 U6301.C4 U6301.E7 U6301.G5 U6301.H10 U6301.J5 U6301.K8 U6301.N2 U6301.N5 U6301.P4 U6301.P6 U7001.5 U7001.6 U7001.7 U7001.8 U7101.41 U7102.5 U7102.21 U7201.19 U7201.25 U7202.1 U7202.7 U7203.3 U7203.7 U7403.B3 U7403.C3 U7403.D3 U7419.B3 U7419.C3 U7419.D3 U7419.E3 U9103.16 U9103.23 U9103.33 USB1.4 USB1.7 USB1.10 USB1.11 USB1.12 USB1.13 USB2.4 USB2.7 USB2.10 USB2.11 USB2.12 USB2.13 VGABD1.6 VGABD1.9 VGABD1.12 VGABD1.15 VGABD1.20 VGABD1.21 VGABD1.22 VGABD1.23 VGABD1.24 WLAN1.1 WLAN1.7 WLAN1.13 WLAN1.18 WLAN1.19 WLAN1.33 WLAN1.39 WLAN1.45 WLAN1.51 WLAN1.57 WLAN1.63 WLAN1.69 WLAN1.75 WLAN1.76 WLAN1.77 WWAN1.7 WWAN1.18 WWAN1.22 WWAN1.25 WWAN1.28 WWAN1.31 WWAN1.34 WWAN1.35 WWAN1.36 X3101.2 X3101.4
V0.85A_VID0: CPU1.CB36 TP2201.1
V0.85A_VID1: CPU1.CB35 TP2202.1
V3D3_STB: HDA27.16 R2708.2
VBUS_P_CTRL: Q7404.2 R7405.2 U7201.14 U7403.B4
VBUS_P_CTRL_R: Q7404.5 Q7404.6 R7423.2 R7430.1
VCC3PD: D7201.K D7202.K R7204.1 R7210.1 R7433.1
VCCCORE_SENSE: CPU1.AN6 PR4665.1 R707.2
VCCDSW_ON: C2525.1 D2503.2 R2520.2 U2401.88
VCCGT_SENSE: CPU1.E3 PR4667.1 R807.2
VCCPD_VBUS_ACK: PR4430.2 R7424.2 U7419.A2
VCCRTCEXT: C2201.1 CPU1.BP24
VCCSA_SENSE: CPU1.BG7 PR4601.2 R810.2
VCCST_PWRGD_R: C1711.1 CPU1.BJ2 ED1707.2 R1716.2 R1719.1
VCCSTG_EN_R1: C4033.1 R4017.2 U4002.4 U4003.4 U4007.4
VCCSTU_EN_R: C4034.1 R4024.2 U4006.4
VDD: PC4422.1 PR4405.2 PR4427.1 PR4429.1 PR4448.1 PR4449.1 PU4401.18
VDD10: C3108.1 C3112.1 C3115.1 C3119.1 C3120.1 C3122.1 C3123.1 C3126.1 R3101.2 U3101.3 U3101.8 U3101.22 U3101.30
VDDD: C7203.1 C7204.1 C7207.1 R7202.1 R7204.2 R7211.2 R7212.1 RN7201.1(A) RN7201.2(A) RN7202.1(A) RN7202.2(A) U7201.20
VDDI: C6320.1 C6323.1 U6301.C2
VDDIO: C7210.1 C7211.1 C7212.1 R7210.2 R7402.2 R7414.1 U7201.21
VDDQ_PWRGD: PG5114.1 R4011.1
VSSCORE_SENSE: CPU1.AN5 PR4666.1 R708.1
VSSGT_SENSE: CPU1.D2 PR4668.1 R808.1
VSSSA_SENSE: CPU1.BE7 PR4602.2 R809.1
0D6V_PWR: PC5116.1 PC5117.1 PG5112.2 PG5113.2 PU5102.29 PU5102.31
0D6V_S0: C1223.1 C1225.1 C1226.1 C1227.1 C1324.1 C1325.1 C1326.1 C1327.1 DM1.258 DM2.258 PG5112.1 PG5113.1
