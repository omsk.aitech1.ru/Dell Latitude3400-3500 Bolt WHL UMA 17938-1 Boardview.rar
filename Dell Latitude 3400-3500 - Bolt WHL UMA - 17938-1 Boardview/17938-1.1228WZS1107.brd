# Allegro board 17938-1.1228WZS1107.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3VALW_EC: length 333.5
  TOP w0.203: R2415.2 21.74,61.73 v1(20.99,61.73) ; C2410.1 38.52,58.42 38.51,58.43 38.51,58.51 38.47,58.55 38.47,58.94 ; 38.47,58.94 38.47,59.02 38.85,59.4 38.85,59.97 U2401.65 ; 38.47,58.94 38.35,58.94 38.17,59.12 38.17,59.12 37.88,59.4 37.88,59.41 37.75,59.54 37.63,59.54 35.89,61.28 35.89,62.83 33.02,65.7 v1(33.02,66.04) 31.66,67.41 31.66,71.78 31.22,72.22 31.22,72.42 30.58,73.05 30.56,73.05 30.36,73.25 U2401.115 30.36,74.82 30.47,74.93 v1(30.47,74.98) ; DBEC1.1 43.38,76.03 42.52,75.16 40.63,75.16 39.91,75.88 38.51,75.88 37.9,75.28 37.9,73.15 36.72,71.97 36.26,71.97 35.04,70.76 35.04,69.43 36.2,68.27 36.2,67.36 v1(36.1,67.26) ; U2401.22 23.07,64.09 22.93,63.95 22.13,63.95 v1(21.96,64.12) ; v1(35.15,75.02) U2401.103 ; U2401.82 39.89,66.89 40.06,66.73 R2480.2 40.58,66.74 40.58,67.47 C2413.1 40.86,68.1 v1(40.92,68.12) ; 29.16,57.78 U2401.43 29.16,60.85 29.97,61.67 30.02,61.67 v1(30.04,61.68) ; U2401.5 22.92,70.89 22.89,70.93 22.34,70.93 22.21,70.8 21.58,70.8 v1(21.52,70.86) ; U2401.19 22.81,65.29 22.72,65.2 v1(22.72,65.18)
  TOP w0.254: 29.16,57.78 28.99,57.61 C2420.1
  TOP w0.305: v1(35.15,75.02) 34.89,75.29 C2414.1 ; v1(28.32,55.65) 28.32,55.9 28.98,56.56 C2420.1 ; v1(30.59,77.76) 30.03,77.76 29.75,77.47 C2422.1 C2411.1 29.75,75.95 30.47,75.22 v1(30.47,74.98) ; v1(34.86,77.8) 34.86,77.75 34.65,77.55 R2443.1 ; v1(21.52,70.86) 21.22,71.16 C2412.1 20.61,70.78 20.61,70.45 RN2402.1 19.81,70.21 19.63,70.04 19.63,69.76 19.83,69.56 RN2402.2 ; R7215.1 40.87,115.11 v1(40.34,115.11)
  TOP w0.508: v1(43.97,68.76) 43.97,68.78 43.89,68.86 43.89,69.52 R2414.2 43.79,69.95 43.32,69.95 42.91,70.36 R2446.2 ; v2(27.67,94.24) 27.67,93.95 v1(27.97,93.65)
  L2SGND w0.305: v1(22.72,65.18) 22.75,65.21 22.83,65.21 23.24,65.62 23.24,70.65 22.91,70.98 22.46,70.98 22.14,70.66 21.72,70.66 v1(21.52,70.86) 21.34,71.04 21.34,74.78 21.76,75.2 23.04,75.2 24.04,74.19 30.08,74.19 30.47,74.59 v1(30.47,74.98) 30.52,74.93 30.55,74.93 31.23,74.25 34.38,74.25 v1(35.15,75.02) ; v1(34.86,77.8) 34.86,77.78 34.34,77.27 30.97,77.27 30.64,77.6 30.64,77.72 v1(30.59,77.76)
  L2SGND w0.381: v1(75.47,36.23) 75.47,35.05 75.83,34.69 75.83,34.21 74.37,32.74 65.84,32.74 62.69,29.59 55.02,29.59 54.44,29.02 53.97,29.02 53.76,29.23 43.23,29.23 42.78,28.78 38,28.78 37.19,29.59 35.23,29.59 33.89,30.94 31.29,30.94 29.77,32.46 28.5,32.46 27.7,33.26 27.7,35.32 28.72,36.34 28.72,41.3 24.69,45.33 24.69,51.42 26.82,53.56 26.97,53.91 27.38,54.32 27.38,54.96 28.07,55.65 v1(28.32,55.65)
  L3 w0.305: v1(43.97,68.76) 43.89,68.76 43.74,68.61 41.41,68.61 v1(40.92,68.12) 39.56,66.76 36.85,66.76 36.84,66.77 36.58,66.77 v1(36.1,67.26) 35.49,66.65 34.57,66.65 33.96,66.04 v1(33.02,66.04) 33.02,65.8 31.26,64.04 31.26,62.59 31.26,62.59 31.26,61.46 30.94,61.15 30.5,61.15 30.08,61.57 30.08,61.64 v1(30.04,61.68) ; v1(34.41,110.75) 34.41,110.48 34.79,110.11 35.31,110.11 35.68,110.48 35.68,110.96 37.86,113.13 39.86,113.13 40.95,114.22 40.95,114.81 40.64,115.11 v1(40.34,115.11) ; v1(121.36,41.12) 121.36,41.99 120.36,42.99 109.46,42.99 108.17,41.69 106.9,41.69 106.29,41.07 104,41.07 102.31,39.38 101.92,39.38 101.82,39.38 100.67,38.23 98.66,38.23 98.03,37.6 92.61,37.6 92.43,37.42 92.43,37.42 92.28,37.27 83.69,37.27 83.29,37.67 76.36,37.67 75.47,36.78 v1(75.47,36.23) ; v1(28.53,95.61) 28.93,95.61 29.75,96.42 29.75,97.23 34.57,102.06 v1(34.57,102.08)
  L4 w0.305: v1(34.57,102.08) 34.88,102.39 34.88,108.08 34.41,108.54 v1(34.41,110.75) ; v1(20.99,61.73) 21.27,61.73 21.67,62.14 21.67,63.83 v1(21.96,64.12) ; v1(28.53,95.61) 28.53,94.82 27.97,94.26 v1(27.97,93.65) 30.04,91.58 37.58,91.58 37.71,91.45 37.71,81.47 36.66,80.42 36.66,78.74 36.35,78.44 35.67,78.44 35.04,77.8 v1(34.86,77.8) ; v1(121.36,41.12) 121.36,41.02 121.82,40.57 122.53,40.57 124.36,38.73 124.39,38.73 124.87,38.25 127.87,38.25 v1(129.09,37.03)
  BOTTOM w0.305: v1(21.96,64.12) 21.96,64.4 22.13,64.57 R2424.2 22.58,65.05 22.71,65.18 v1(22.72,65.18) 22.74,65.15 22.78,65.15 22.8,65.13 C2429.1 ; v1(129.09,37.03) 128.67,37.45 ED4305.2 ; R2608.1 28.1,93.52 v1(27.97,93.65) ; v1(121.36,41.12) 121.34,41.11 121.34,40.06 122.2,39.19 ED4306.2 122.43,38.74 124.14,37.03 ED4304.2
  BOTTOM w0.508: v1(28.53,95.61) 28.1,96.04 v2(27.84,96.04)
+5V_AVDD: length 10.1
  TOP w0.203: HDA27.20 23.88,11.97 23.59,11.68 v2(23.59,11.48)
  TOP w0.305: v1(17.86,10.34) R2703.1 ; C2707.1 21.92,11.43 v1(22,11.51) 22.43,11.08 C2706.1 23.19,11.08 v2(23.59,11.48)
  L3 w0.305: v1(17.86,10.34) 17.86,11.38 18.24,11.76 21.75,11.76 v1(22,11.51)
+5V_KB_BL: length 8.3
  TOP w0.508: v1(85.39,38.49) 85.32,38.49 84.93,38.1 C6501.1 v2(84.93,36.81)
  BOTTOM w0.305: 83.99,37.3 KBBL1.1 85.34,38.45 v1(85.39,38.49)
  BOTTOM w0.508: F6501.2 81.6,35.48 83.42,37.3 83.99,37.3
+5V_PVDD: length 2.6
  TOP w0.203: 30.3,12.98 30.12,13.17 HDA27.34 ; HDA27.39 29.71,15.17 29.91,15.37 29.91,15.39 30.32,15.8 30.81,15.8
  vias: v2(34.1,17.57) v2(34.71,13.29)
GND: length 2576.1
  TOP w0.089: v1(156.49,111.81) 156.9,111.81 157.25,112.16 157.25,112.65 157.5,112.9 U6301.N2 ; 183.17,30.35 184.77,30.35
  TOP w0.127: v1(143.09,76.71) 143.18,76.79 U7001.7 ; v1(34.93,116.26) 34.53,116.26 U7102.5 ; C5541.2 220.81,41.32 220.1,41.32 v1(219.81,41.61) ; C7003.2 145.21,77.98 C7004.2 ; C7003.2 144.33,77.79 v1(143.93,77.4) ; C7003.2 144.14,78.16 U7001.8 ; U6301.P4 158.45,113.95 158.55,114.05 v1(158.55,114.05) ; U6301.N5 U6301.P6 158.05,114.95 158.47,115.37 v1(158.58,115.37) ; U6301.C4 153,114.45 v1(153,114.64) ; U7001.5 142.12,77.04 v1(142.45,76.71) 142.62,76.88 U7001.6
  TOP w0.152: C2412.2 20.08,71.26 20.61,71.79 v1(20.63,71.79) ; v1(137.35,77.9) 137.35,77.62 136.36,76.63 134.55,76.63 133.96,77.22 133.96,77.83 C1803.2
  TOP w0.203: 43.03,73.62 43.28,73.88 43.28,74.39 43.41,74.51 DBEC1.4 ; 43.03,73.62 41.82,73.62 C2405.2 41.5,73.3 C2406.2 40.62,73.3 v1(40.21,73.71) ; 43.03,73.62 43.64,73.01 44.87,73.01 45.35,72.53 DBEC1.8 ; C4041.2 143.32,84.91 143.96,84.27 Q7001.1 144.29,83.91 144.83,84.45 146.78,84.45 v1(146.81,84.43) ; Q7001.4 142.66,81.29 R7011.2 142.6,80.93 v1(142.95,80.57) ; ED1706.1 32.35,56.86 U2401.51 ; v1(34.83,72.67) 34.95,72.67 35.15,72.87 36.15,72.87 36.35,73.08 U2401.100 ; v1(208.99,47.45) 208.98,47.45 208.54,47.02 208.54,46.62 208.82,46.34 209.57,46.34 C5520.2 ; C2612.2 22.72,66.45 23.07,66.09 U2401.17 24.39,66.09 24.84,65.65 v1(24.84,65.48) ; R7187.2 16.11,107.88 v1(15.71,107.48) ; v1(15.24,105.21) 15.93,104.52 R7185.2 ; C7208.2 43.94,112.51 45.03,112.51 45.34,112.82 45.49,112.83 46.07,112.83 46.28,113.04 R5812.1 ; v1(16.15,62.9) 16.25,63.01 Q1701.1 ; DBEC1.7 45.99,77.02 v1(44.83,78.18) ; v1(31.73,75.05) 31.55,74.87 U2401.112 ; C2424.1 26.9,75.56 26.9,75.38 v1(26.9,74.97) 26.9,74.94 26.75,74.79 U2401.124 ; v1(37.95,67.34) 38.31,67.69 U2401.84 39.66,67.69 40.14,68.16 40.14,68.43 C2421.2 ; R7331.1 16.69,109.27 16.84,109.42 R7186.2 19.16,109.42 v1(19.22,109.37) ; v1(161.02,146.67) 161.02,146.46 160.79,146.22 160.49,146.22 160.33,146.05 R9332.1 R9336.1 R9330.1 ; C2210.2 117.91,90.02 v1(118.03,89.9) ; U5802.11 50.9,116.59 v1(50.7,116.79) ; v1(24.15,74.91) 24.15,75.11 R2454.2 ; v1(148.98,135.47) 149.47,134.98 149.47,133.9 149.95,133.42 C5530.2 149.6,133.4 R5552.2 148.79,131.82 C5535.2 ; U6301.A6 151.45,114.95 151.01,115.39 v1(151.01,115.72) ; R2417.2 43.08,68.02 v1(42.4,68.02) 42.04,68.02 C2413.2 ; R7188.2 16.61,102.06 C5736.1 17.86,101.3 v1(17.94,101.22) ; U5802.52 47.02,119.23 ; R6413.1 39.75,78.08 C2407.1 38.81,78.08 37.92,77.19 C2435.2 ; U5802.19 54.1,116.01 52.28,117.83 v1(50.7,117.83) ; v1(23.09,79.36) 23.09,78.21 23.22,78.08 C2426.2 ; R5549.1 146.62,133.78 C5529.2 145.9,133.83 v1(145.82,133.76) ; PR4474.1 147.5,144.21 147.69,144.4 147.69,144.44 148.07,144.82 PQ4405.4 ; v1(219.81,41.61) 219.4,41.19 FC8971.2 ; v1(38.04,58.3) 37.98,58.35 37.98,58.39 37.91,58.46 37.91,58.48 37.71,58.67 U2401.64 37.55,57.36 C2410.2 ; C2414.2 33.45,75.29 33.18,75.01 v1(33.12,75.01)
  TOP w0.254: v1(108.91,88.67) 108.89,88.64 R503.2 ; FC8939.2 171.92,60.15 v1(171.56,60.51) ; R7219.2 25.67,111.77 v1(25.76,111.85) 25.95,111.66 R7102.1 ; U7419.C3 40.6,123.07 v1(40.91,122.76) 41.05,122.76 41.34,123.05 U7403.D3 U7403.C3 U7403.B3 ; U7419.C3 U7419.D3 U7419.E3 ; U7419.C3 U7419.B3 ; v1(123.12,101.75) 122.81,102.06 C2219.2 ; EC1903.2 27.03,18.72 EC1901.1 27.38,17.77 v1(27.35,17.74) ; C2211.2 132.52,93.63 v1(132.34,93.45) ; v1(55.58,44.44) 56.02,44.44 C501.2 ; v1(215.19,45.42) 215.34,45.26 EC5503.2 ; v1(215.19,45.42) 215.04,45.26 FC8920.2 ; v1(215.19,45.42) 215.19,45.67 215.57,46.05 C5505.2 ; 117.64,91.79 v1(117.64,91.88) ; 117.64,91.79 118.3,91.13 R2114.2 ; 117.64,91.79 117.64,91.68 117.33,91.37 C2227.2 C2225.2 115.93,91.37 C2206.2 ; v1(15.66,95.66) 16.21,95.11 16.21,94.3 16.42,94.08 17.4,94.08 17.68,94.36 ED5703.8 ; v1(10.17,127.31) 10.52,126.96 12.1,126.96 12.31,126.75 PQ4418.1 ; C2226.2 C2213.2 ; C2213.2 112.34,92.44 v1(112.31,92.41) ; C2213.2 112.34,93.23 C2228.2 ; v1(216.49,59.13) 216.54,59.13 216.62,59.05 WWAN1.28 ; v1(19.41,64.21) 18.93,64.69 18.6,64.69 18.57,64.66 Q1701.4 18.14,64.77 18.98,65.61 EC1712.2 ; R6121.2 34,103.78 v1(34.24,103.54) 34.77,104.06 R6122.2 ; C1804.2 137.87,78.79 138.36,78.79 138.52,78.95 138.52,80.92 138.37,81.07 134.43,81.07 134.15,80.79 v1(134.15,80.06) ; v1(162.46,142.19) 163.12,142.85 R9331.1 163.54,143.01 163.76,143.22 R9333.1 163.5,144.59 163.35,144.74 163.35,144.8 163.32,144.82 163.32,145.28 v1(163.14,145.46) ; EC5504.2 216.06,43.44 216.62,44 217.47,44 217.6,43.88 218.88,43.88 219.33,44.33 WWAN1.36 221.08,44.33 221.62,43.79 C5516.2 222.35,43 C5517.2 ; R7130.1 36.25,119.86 v1(36.78,119.33) ; v1(160.86,84.18) 161.06,83.97 FC8942.2 161.06,82.68 FC8941.2 161.06,81.89 FC8940.2 ; v1(28.32,55) 28.4,55 28.96,55.56 C2420.2 ; C2231.2 124.51,101.3 124.25,101.3 123.93,100.97 123.93,100.6 123.9,100.58 v1(123.9,100.41) 123.96,100.35 123.98,100.35 124.13,100.2 R2108.2 ; v1(39.45,118.57) 39.45,118.91 39.16,119.2 39.16,119.75 C7405.2 ; v1(10.26,125.88) 11.01,125.14 PQ4418.4 ; AFTP2604.1 161.04,88.34 v1(160.96,88.27) ; EC1803.1 25.63,79.33 25.5,79.21 25.43,79.21 v1(25.42,79.21) 25.42,79.21 25.61,79.02 R2465.2 ; RN1201.2 71.12,43.12 70.64,43.61 70.14,43.61 69.88,43.34 69.88,42.4 R1209.2 ; 47.02,119.23 49.3,119.23 v1(50.7,117.83) ; v1(111.65,97.45) 111.51,97.6 C2220.2 ; Q7406.4 29.63,107.05 29.13,107.77 v1(28.86,107.77) ; v1(137.66,132.07) 137.6,132.02 FC8938.2 138.16,130.6 FC8937.2 ; PR4426.2 208.29,47.67 208.33,47.72 208.5,47.72 208.85,48.07 208.98,48.07 209,48.09 v1(209.05,48.09) ; Q4302.E 21.88,96.54 ; v1(21.27,51.69) 21.52,51.44 U3601.14 ; WWAN1.34 218.12,62.05 218.36,61.81 218.36,60.79 218.12,60.55 WWAN1.31 217.2,60.55 217.02,60.74 216.9,60.74 216.54,61.09 v1(216.54,61.09) ; C2230.2 110.25,90.75 110.08,90.92 110.08,91.25 110.36,91.53 v1(110.36,91.58)
  TOP w0.305: C5538.2 216.18,38.48 C5536.2 216.18,38.13 C5513.2 216.16,36.96 C5512.2 216.28,36.83 216.84,36.27 v1(217.66,36.27) ; EC8939.2 97.63,40.19 97.63,40.67 97.16,41.14 97.04,41.14 97.02,41.15 v1(97.01,41.15) ; U6301.G5 154.57,114.52 v1(154.57,115.38) ; v1(58.49,118.69) 57.99,118.19 57.89,118.19 R5823.1 ; v1(35.69,122.56) 35.69,122.45 36.17,121.97 R7404.2 ; v1(190.96,34.8) 190.96,34.35 189.84,33.22 C6018.2 189.59,33.28 C6019.2 ; v1(86.13,38.48) 86.11,38.46 86.11,38.28 85.85,38.02 C6501.2 R6508.2 ; C1803.2 134.43,78.78 134.42,78.78 134.15,79.04 v1(134.15,80.06) ; v1(15.83,56.57) 15.87,56.53 C3525.2 EC3513.2 ; v1(135.03,84.55) 135.08,84.51 C4010.2 135.97,84.53 136.36,84.53 136.74,84.91 R2101.2 137.44,85.2 137.72,85.48 U4003.5 ; v1(42.55,112.32) 43.06,112.83 43.39,113.02 C7208.2 ; v1(109.1,30.28) 108.97,30.41 EC6502.2 ; v1(150.22,44.4) 150.21,44.4 149.71,43.9 C1301.2 149.71,43.16 149.99,42.88 R1311.2 ; 216.91,47.92 216.91,48.28 217.18,48.55 WWAN1.7 ; v1(100.07,37.18) 100.07,37.15 100.05,37.14 100.05,35.57 PC5301.2 ; PR4453.1 197.23,47.85 197.1,47.72 197.1,47.69 196.73,47.32 196.7,47.32 196.65,47.27 196.42,47.27 196.19,47.04 PR4447.2 ; C5810.2 45.14,120.52 R5814.1 45.15,121.04 46.29,121.04 v1(46.43,120.91) ; C1104.2 77.77,102.91 v1(77.72,102.87) ; C7403.2 45.6,122.18 46.4,122.98 46.44,122.98 ; EC6504.2 v1(106.56,29.9) 106.26,29.6 105.89,29.6 C6505.2 105.83,29.6 105.19,29.6 104.75,30.04 104.75,30.5 104.73,30.52 EC6501.2 ; v1(28.82,112.02) 28.86,112.06 Q7407.1 29.4,112.75 29.58,112.93 30.55,112.93 30.7,113.09 Q7407.4 ; v1(43.74,86.41) C3116.2 43.31,87.05 42.95,87.4 v1(42.95,88.52) 42.95,89.18 43.48,89.71 X3101.2 44.88,90.53 47.21,90.53 47.5,90.24 v1(47.5,87.81) ; C2218.2 123.28,90.64 v1(123.28,89.93) ; C2214.2 122.63,118.07 C1129.2 123.68,118.24 v1(123.68,118.39) ; EC2602.2 31.81,55.3 EC2601.2 31.24,55.82 v1(31.52,56.1) ; R2118.2 124.94,98.32 124.64,98.02 v1(124.25,98.02) ; v1(155.47,115.02) 155.5,114.99 U6301.J5 ; v1(147.4,146.54) 146.98,146.12 PQ4405.1 ; Q4349.4 30.51,120.1 v1(30.69,120.27) ; 23.95,119.99 v1(23.96,119.97) 23.97,119.96 R4312.2 ; R1209.2 v1(69.98,41.56) ; EC8935.2 167.67,34.81 EC8934.2 167.9,34.49 v1(168.33,34.06) ; R2441.2 37.04,76.43 C2435.2 37.04,77.4 v1(36.53,77.9) ; G6402.2 207.86,59.69 207.91,59.64 207.91,59.57 207.91,59.34 207.91,59.17 207.91,59.17 208.09,58.99 208.09,58.77 208.13,58.73 v1(208.13,58.63) 208.17,58.59 208.17,58.15 EC6403.2 ; R2063.2 124.13,89.93 v1(123.28,89.93) ; R2444.2 33.86,77.51 33.86,77.66 v1(33.7,77.83) 33.43,77.83 33.07,77.47 C2408.1 ; R305.2 112.8,91.42 v1(112.96,91.58) ; v1(31.25,17.5) 31.14,17.5 31.12,17.48 C2721.2 30.69,17.5 C2723.2 ; PC5103.2 113.9,29.95 113.39,29.95 113.2,30.14 v3(113.11,30.14) ; WWAN1.22 218.33,56.05 219,55.37 219.69,55.37 v1(219.87,55.55) ; C2221.2 138.77,89.23 139.22,88.79 C1805.2 139.47,88.66 140.36,87.76 v1(140.43,87.76) ; C1103.2 83.15,104.65 C1107.2 83.15,103.57 v1(83.14,103.56) ; v1(219.87,56.35) 219.47,56.35 218.27,57.55 WWAN1.25 ; v1(198.94,39.43) 199.61,39.43 EC6601.2 ; v1(28.19,74.94) 28.32,75.08 28.32,75.15 28.65,75.48 C2425.1 ; C2602.2 133.07,121.95 133.35,121.67 133.35,121.41 v1(132.74,120.8) ; v1(110.36,94.93) 110.36,95.05 110.72,95.4 C1116.2 ; EC8948.2 52.96,41.93 v1(53.33,41.57) ; v1(126.77,122.86) 126.25,123.38 126.25,125.27 127.03,126.05 U2601.5 ; v1(108.51,49.61) 108.62,49.51 FC1102.2 ; EC5504.2 216.09,42.13 216.53,41.69 v1(216.53,41.63) 216.6,41.63 217,41.23 C5599.2 ; Q2408.S 51.14,93.12 51.55,93.52 51.55,95.16 v1(51.37,95.34) ; R7405.1 v1(40.64,119.76) ; U6301.E7 153.65,115.45 154.03,115.83 v1(154.03,116.33) 154.22,116.53 154.68,116.53 154.92,116.77 154.92,116.83 155,116.91 U6301.H10 ; R304.2 112.09,90.82 111.66,91.24 v1(111.66,91.58) ; C2411.2 C2422.2 31.19,77.09 C2431.2 31.35,77.62 31.55,77.82 v1(31.92,77.82) ; v1(137.44,91.49) 137.44,91.24 C1806.2 138.03,90.86 G1801.1 139.91,91.57 141.06,91.57 ED1802.1 ED1801.1 ; v1(176.93,35.66) 176.93,35.78 176.1,36.6 PR4494.2 176.33,36.9 R9338.1 ; v1(114.27,94.93) 114.35,95.01 C1114.2 ; AFTP6501.1 90.44,34.34 PR5305.2 90.64,35.03 v1(90.27,35.4) ; C2432.2 46.82,66.19 46.82,65.38 U2402.3 46.46,65.05 46.13,64.72 45.17,64.72 44.38,65.51 v1(44.38,65.61) ; R4308.2 28.14,127.98 v1(28.14,127.58) ; v1(224.46,44.1) 223.75,43.39 C5504.2 ; PC5213.2 117.68,142.17 117.93,141.91 118.46,141.91 118.98,142.43 v1(118.98,142.47) ; C3125.2 47.5,87.08 v1(47.5,87.81) ; v1(156.5,116.2) 156.48,116.2 156.48,116.19 156.23,115.95 U6301.K8 ; v1(168.99,34.06) 169.2,33.85 AFTP4306.1 ; ED1706.1 32.2,56.7 31.86,56.36 31.58,56.1 v1(31.52,56.1) ; v1(42.5,116.21) R5808.1 43.54,115.55 43.48,115.48 C5811.2 43.28,115.42 42.91,115.04 C7213.2 ; v1(154.96,110.05) 154.96,109.9 155.07,109.8 v1(155.07,109.32) ; v3(186.54,44.68) 186.54,44.57 186.15,44.18 R9337.1 ; FC8905.2 v1(70.79,131.19) ; v1(210.54,60.07) 210.75,59.86 210.75,58.87 210.34,58.46 EC6401.2 ; C2416.2 41.74,77.51 41.74,77.01 v1(41.76,76.99) ; v1(24.46,19.18) C2741.2 ; C2229.2 109.33,91.1 C2222.2 108.83,91.47 v1(108.46,91.85) 108.11,91.5 C803.2 107.67,90.6 R502.2 ; PC4610.1 139.95,143.38 PC4612.2 PC4651.2 141.26,143.71 v1(141.05,143.92) 140.82,144.14 ED2403.3 139.68,144.17 PC4602.2 ; v1(124.85,80.24) 124.54,79.94 124.54,77.14 R2007.2 ; v1(79.37,104.02) 79.37,104.02 FC8906.2 ; v1(123.28,89.93) 122.41,89.93 C1122.2 ; v1(155.07,109.32) 154.96,109.32 154.58,108.94 v1(154.41,108.94) 154.3,109.05 153.63,109.05 153.22,108.64 PR4436.2 152.83,108.64 152.49,108.29 150.71,108.29 Q6302.S 148.89,108.94 Q6301.S ; v1(155.07,109.32) 155.18,109.32 v1(155.63,108.87) ; v1(31.52,56.1) 31.58,56.1 31.62,56.06 32.77,56.06 33.23,55.6 C2423.2 ; 46.44,122.98 46.26,123.16 C7404.2 ; 46.44,122.98 v1(46.5,122.92) ; R1901.2 121.34,87.1 120.81,87.63 v1(120.55,87.63) ; EC6503.2 v1(102.29,30.28) ; ED6001.8 ED6001.3 v1(164.15,39.95) ; PC4433.2 195.81,43.74 196.07,43.48 v1(197.29,43.48) ; v3(36.68,35.49) 36.55,35.36 EC8952.2 ; v1(57.85,121.21) 57.81,121.21 57.79,121.24 56.36,121.24 C5812.2 ; C2223.2 126.06,117.93 125.71,118.28 v1(124.84,118.28) ; v1(206.46,46.87) 206.46,46.58 206.79,46.25 206.79,46.25 207.18,45.86 PR4475.2 ; X3101.4 47.11,88.2 v1(47.5,87.81) ; U7202.7 46.57,126.13 U7202.1 45.85,126.13 45.64,126.34 44.87,126.34 C7206.2 ; WWAN1.18 218.45,54.05 218.47,54.08 219.69,54.08 v1(219.87,54.26) ; Q7406.1 31.82,108.68 v1(32.12,108.38) 32.18,108.38 32.62,108.81 Q7408.S ; C1142.2 124.38,49.51 v1(124.46,49.59) ; C1804.2 137.62,78.17 v1(137.35,77.9)
  TOP w0.356: ED3202.3 37.48,84.42 v1(37.16,84.74) ; PC4429.2 176.29,35.08 176.69,35.08 176.93,35.32 v1(176.93,35.66)
  TOP w0.381: v1(111.36,47.35) 111.39,47.32 EC8913.2 ; v1(145.82,133.76) 145.82,133.94 145.26,134.5 C5531.2 144.46,134.5 R5555.2 ; 11.59,47.96 11.59,48.6 USB1.12 ; JUSB1.B1 6.71,127.59 6.51,127.79 6.51,128.14 ; 63.7,143.48 H13.1 65.72,147.82 ; C9203.2 221.67,66.81 v1(222.4,66.08) 222.42,66.1 222.42,66.85 Q9202.S ; PC4620.2 127.08,137.56 127.58,137.06 v1(128.37,137.06) 128.47,136.96 PC4621.1 ; v1(142.83,145.42) 142.04,144.63 PC4614.2 ; RJ1.11 1.28,84.72 ; JUSB1.B12 6.56,120.35 6.56,119.31 ; R601.2 90.13,105.48 89.25,105.48 88.88,105.11 R316.2 88.7,104.73 v1(88.7,104.15) ; v1(123.07,103.61) 122.56,104.12 R1603.2 ; PR4627.1 128.81,141.99 PC4613.2 129.67,141.86 130.84,141.86 131.3,142.32 131.3,143.21 v1(131.26,143.24) ; 226.01,68.89 226.01,69.47 225.56,69.91 ; FC8943.2 156.31,82.12 v1(156.29,82.14) ; v1(9.58,116.84) 9.99,117.24 C7307.2 C7303.2 ; FC5504.2 FC5503.2 FC5506.2 FC5505.2 ; FC5504.2 FC5501.2 FC5502.2 ; FC5504.2 215.97,54.26 v1(216.22,54.51) ; PC5303.2 95.95,32.98 v1(95.95,32.19) ; C7205.2 43.86,126.23 v1(44.13,126.5) 44.72,126.5 C7206.2 ; C805.1 111.87,104.21 v1(111.8,104.14) ; Q4349.1 27.84,121.41 R4381.1 26.86,121.86 26.86,121.5 v1(26.75,121.39) ; C2705.1 30.08,8.61 C2704.2 29.77,7.82 C2709.2 29.16,6.99 29.98,6.17 v1(30.2,6.17) ; v1(73.08,137.01) 71.98,135.91 ED1703.1 71.8,135.79 PR4514.2 ; v1(30.15,122.84) 30.08,122.84 29.49,123.42 Q4304.E ; C5813.2 57.35,114.02 R5804.2 58.18,113.95 ; R7432.2 28.98,115.8 28.56,116.22 v1(28.33,116.22) ; FC8919.2 59.69,121.69 59.69,121.26 v1(59.77,121.18) ; v1(18.04,111.25) 17.83,111.46 R7330.1 ; 3.35,117.63 JUSB1.13 2.04,117.62 3,116.66 ; PC5122.2 116.14,31.37 116.14,30.58 116.5,30.22 PR5104.2 116.8,29.66 v1(116.8,29.18) ; C3602.2 26.16,50.7 25.61,51.25 v1(25.35,51.25) 25.35,51.26 R3604.1 24.74,50.49 R3603.1 ; v1(115.57,47.41) 115.58,47.4 EC8914.2 ; R501.2 111.41,89.73 v1(111.62,89.94) ; v1(147.32,132.31) 147.3,132.28 146.89,132.28 C5528.2 ; 58.18,113.95 v1(58.19,113.97) ; 58.18,113.95 58.18,113.72 57.49,113.03 FC8917.2 ; RJ1.12 4.22,68.25 ; PC1057.2 PC1043.2 v1(71.43,114.78) ; R4302.2 20.86,96.9 v1(20.96,97) 21.42,97 21.88,96.54 ; v1(11.72,119.27) 11.81,119.19 ED7315.3 ; R809.2 104.06,101.15 v1(104.86,100.35) ; Q5504.2 150.08,126.58 149.31,126.58 149.31,126.57 147.53,126.57 Q5505.2 146.59,126.81 v1(146.54,126.86) ; JUSB1.15 7.72,119.23 7.24,118.75 ; v1(64.37,41.48) 64.14,41.25 FC8903.2 64.13,39.61 FC8912.2 62.71,40.23 C4011.2 62.38,40.24 C4002.2 61.28,40.24 60.53,39.49 v1(60.53,37.84) ; C6304.2 21.52,21.63 v1(21.85,21.31) 21.59,21.06 R2735.2 ; C6304.2 v1(20.86,22.3) FC8911.2 ; C6304.2 20.86,20.91 EC2702.2 EC2701.2 ; PC4431.2 195.68,43.99 PC4433.2 ; 98.33,151.8 H14.1 104.99,151.8 ; v1(154.97,33.88) 154.51,33.42 EC4307.2 ; PR4497.1 9.66,123.94 9.15,123.44 9.15,122.82 v1(9.07,122.73) ; R7434.2 66.58,135.92 v1(66.32,135.92) ; C6508.2 87.94,36.68 v1(87.94,35.49) ; C2736.2 C2740.2 C2720.2 30.69,19.03 C2723.2 ; PR4474.1 147.5,143.26 147.58,143.18 v1(147.58,143.08) ; v1(210.4,53.42) 210.53,53.29 R2436.2 ; R7415.2 31.98,110.12 R7431.2 31.37,111.3 v1(31.88,111.81) ; PR4447.2 195.58,47.07 195.58,47.65 195.46,47.78 v3(195.38,47.78) ; C5503.2 216.55,48.29 216.91,47.92 v1(216.91,47.88) ; v1(77.71,106.18) 78.32,105.57 R808.2 ; FC8913.2 21.58,92.87 v1(21.92,93.22) Q5701.S ; v1(136.36,124.82) 136.6,125.06 FC8921.2 ; ED3202.3 ED3202.8 ; C4302.2 25.28,123.8 v1(25.28,125.07) ; C7209.2 v1(46.21,110.29)
  TOP w0.406: v1(102.99,91.9) 102.99,91.28 PC1079.2 ; v1(17.94,101.22) 17.99,101.17 C7165.1
  TOP w0.508: v1(37.36,116.49) U4302.3 ; v1(41.13,117.6) R4377.2 41.81,116.95 C4344.2 ; v1(118.98,142.47) 119.26,142.75 PR5203.2 ; R7007.1 139.95,77.14 v1(139.96,77.14) ; v1(134.42,132.87) 134.24,133.05 PC4606.2 ; C7120.2 33.88,122.21 33.9,122.23 33.9,122.24 34.16,122.5 v1(34.16,122.52) ; v1(18.34,98.55) 18.34,97.81 C4005.2 ; 7.84,23.15 USB2.10 ; v1(31.35,121.4) 31.32,121.38 R7129.1 ; D4302.1 v1(25.46,91.46) ; R5810.1 42.9,119 42.83,119.18 v1(42.83,119.41) R7418.2 ; C2722.2 25.17,20.19 v1(25.17,20.58) ; R6804.2 15.47,43.41 v1(15.46,43.4) ; R1212.2 v1(76.97,41.63) ; PC4406.2 v1(151.37,40.26)
  TOP w0.635: 12.24,61.16 USB1.13 12.24,62.94 ; 2.04,130.61 JUSB1.22 3.37,129.77 ; JUSB1.21 7.24,129.77 ; JUSB1.21 5.91,130.61 ; JUSB1.21 4.57,129.77 ; USB2.12 12.24,25.49 ; USB2.12 13.68,24.6 ; USB2.12 12.24,23.71 ; 7.18,63.5 USB1.11 5.44,64.39 ; 5.44,39.74 USB2.11 7.18,38.85 ; 4.08,85.05 RJ1.11 2.75,85.89 ; 10.91,95.35 HDMI1.2 ; HDMI1.2 12.19,95.35 ; HDMI1.2 11.55,94.77 ; RJ1.9 11.88,85.05 ; RJ1.9 10.55,85.89 ; RJ1.9 9.22,85.05 ; 5.44,46.91 USB1.10 7.18,47.8 ; JUSB1.20 9.33,128.18 ; JUSB1.20 7.15,128.18 ; JUSB1.20 8.24,128.96 ; 10.91,98.35 HDMI1.8 12.19,98.35 ; 4.57,117.63 JUSB1.14 ; JUSB1.14 7.24,117.63 ; JUSB1.14 5.91,116.79 ; 11.7,105.61 HDMI1.21 ; HDMI1.21 11.7,107.59 ; HDMI1.21 10.37,106.6 ; 11.7,91.11 HDMI1.20 ; HDMI1.20 11.7,93.09 ; HDMI1.20 10.37,92.1 ; HDMI1.20 13.03,92.1 ; 11.88,68.25 RJ1.10 9.22,68.25 ; 4.83,108.5 HDMI1.23 3.5,109.49 ; 13.14,26.66 USB2.4 ; USB2.4 13.14,28.34 ; USB2.4 13.98,27.5 ; 3.5,89.21 HDMI1.22 4.83,90.2 ; 12.24,38.29 USB2.13 12.24,36.51
  L2SGND w0.305: 10.12,102.85 10.26,102.85 10.65,102.46 ; 10.12,102.85 HDMI1.17 ; 10.12,102.85 10.65,103.38 ; 10.65,100.36 10.14,99.85 ; 10.14,99.85 HDMI1.11 ; 10.14,99.85 10.16,99.85 10.65,99.37
  L2SGND w0.381: 99.46,151.8 H14.1 104.29,151.8 ; 65.15,147.25 H13.1 63.7,143.65 ; 1.25,84.75 RJ1.11 ; HDMI1.5 10.77,96.85 ; RJ1.12 3.23,68.25 4.17,67.31 ; JUSB1.B1 6.71,127.64 6.38,127.97
  L2SGND w0.508: 11.99,30.02 11.64,30.38 USB2.7 11.64,31.58 12.04,31.98 ; JUSB1.B12 6.71,119.35 ; 11.97,54.66 11.64,54.99 USB1.7 11.64,56.27 12.02,56.64 ; USB2.10 7.79,23.15 ; JUSB1.13 3.36,117.63
  L2SGND w0.635: 129.01,106.09 H22.1 ; H22.1 129.01,110.45 ; H22.1 131.2,108.27 ; H22.1 126.83,108.27 ; USB2.13 13.68,37.4 ; USB2.13 12.24,38.29 ; USB2.13 12.24,36.51 ; 11.55,94.77 HDMI1.2 ; HDMI1.2 12.19,95.35 ; HDMI1.2 10.91,95.35 ; 12.24,23.71 USB2.12 ; USB2.12 13.68,24.6 ; USB2.12 12.24,25.49 ; HDMI1.21 13.03,106.6 ; HDMI1.21 10.37,106.6 ; HDMI1.21 11.7,107.59 ; HDMI1.21 11.7,105.61 ; 5.91,116.79 JUSB1.14 ; JUSB1.14 7.24,117.63 ; JUSB1.14 4.57,117.63 ; HS3.1 42.02,131.05 ; HS3.1 40.2,129.23 ; HS3.1 40.2,132.87 ; HS3.1 38.38,131.05 ; 7.15,128.18 JUSB1.20 ; JUSB1.20 9.33,128.18 ; JUSB1.20 8.24,128.96 ; 9.22,68.25 RJ1.10 ; RJ1.10 10.55,67.41 ; RJ1.10 11.88,68.25 ; 12.24,61.16 USB1.13 ; USB1.13 13.68,62.05 ; USB1.13 12.24,62.94 ; USB1.12 13.68,49.25 ; USB1.12 12.24,48.36 ; USB1.12 12.24,50.14 ; JUSB1.21 7.24,129.77 ; JUSB1.21 5.91,130.61 ; JUSB1.21 4.57,129.77 ; 5.44,64.39 USB1.11 7.18,63.5 ; 5.44,39.74 USB2.11 7.18,38.85 ; 13.98,52.15 USB1.4 13.14,52.99 ; 2.04,130.61 JUSB1.22 3.37,129.77 ; 5.44,46.91 USB1.10 7.18,47.8 ; 126.83,83.97 H21.1 ; H21.1 131.2,83.97 ; H21.1 129.01,81.79 ; H21.1 129.01,86.16 ; RJ1.9 11.88,85.05 ; RJ1.9 9.22,85.05 ; RJ1.9 10.55,85.89 ; 7.15,119.23 JUSB1.15 ; JUSB1.15 8.24,118.44 ; JUSB1.15 9.33,119.23 ; 11.7,91.11 HDMI1.20 ; HDMI1.20 10.37,92.1 ; HDMI1.20 13.03,92.1 ; HDMI1.20 11.7,93.09 ; 3.5,89.21 HDMI1.22 4.83,90.2 ; 4.08,85.05 RJ1.11 2.75,85.89 ; 3.5,109.49 HDMI1.23 4.83,108.5 ; 10.91,98.35 HDMI1.8 12.19,98.35 ; USB2.4 13.14,28.34 ; USB2.4 13.98,27.5 ; USB2.4 13.14,26.66
  L3 w0.127: 121.63,82.33 119.92,82.33 119.74,82.16 115.55,82.16 114.23,83.47 v1(114.08,83.47) 111.86,83.47 111.34,83.99 110.42,83.99 109.06,85.35 v1(109.06,85.66) 109.06,85.76 109.32,86.02 109.32,87.53 v1(109.82,88.03)
  L3 w0.152: v1(110.75,86.54) 110.75,86.5 v1(111.53,85.71) 112.78,84.46 115.29,84.46 116.62,83.14 v1(116.64,83.14) 119.41,83.14 119.63,83.35 119.63,83.4 v1(119.69,83.47) ; v1(121.73,83.34) 121.73,83.35 121.84,83.46 v1(122.63,83.46) 122.97,83.79 123.96,83.79 124.49,83.26 125.08,83.26 125.16,83.19 127.7,80.66 133.32,80.66 133.91,80.06 v1(134.15,80.06) 134.15,79.82 134.47,79.5 134.47,79.17 135.68,77.96 135.68,77.92 135.68,77.92 135.68,77.49 135.68,77.48 135.68,77.36 135.1,76.79 135.04,76.79 134.95,76.69 134.1,76.69 134.01,76.79 133.94,76.79 132.4,78.33 132.4,78.69 131.98,79.11 127.05,79.11 126.96,79.2 126.95,79.2 125.91,80.24 124.85,80.24 v1(124.85,80.24) 124.85,81.09 124.13,81.8 124.13,82.13 123.88,82.39 123.5,82.39 123.05,81.94 122.03,81.94 121.63,82.33
  L3 w0.381: v1(198.94,39.43) 199.08,39.57 200.03,39.57 v1(201.9,41.44) ; 6.53,119.23 6.53,119.71 6.71,119.89 JUSB1.B12 ; 65.82,145.8 H13.1 63.7,143.77 ; RJ1.12 4.25,68.25 ; 99.04,151.8 H14.1 104.29,151.8 ; USB2.10 8.32,23.15 ; 6.51,128.09 6.51,127.1 JUSB1.B1 ; RJ1.11 1.27,84.74 ; JUSB1.13 3.5,117.63
  L3 w0.635: HDMI1.21 13.03,106.6 ; HDMI1.21 11.7,107.59 ; HDMI1.21 10.37,106.6 ; HDMI1.21 11.7,105.61 ; 3.37,129.77 JUSB1.22 2.04,130.61 ; 8.24,128.96 JUSB1.20 7.15,128.18 ; 11.7,91.11 HDMI1.20 ; HDMI1.20 11.7,93.09 ; HDMI1.20 13.03,92.1 ; HDMI1.20 10.37,92.1 ; 7.18,47.8 USB1.10 5.44,46.91 ; 4.57,117.63 JUSB1.14 ; JUSB1.14 5.91,116.79 ; JUSB1.14 7.24,117.63 ; 8.24,118.44 JUSB1.15 7.15,119.23 ; 3.5,89.21 HDMI1.22 4.83,90.2 ; 12.24,62.94 USB1.13 12.24,61.16 ; RJ1.9 11.88,85.05 ; RJ1.9 10.55,85.89 ; RJ1.9 9.22,85.05 ; 3.5,109.49 HDMI1.23 4.83,108.5 ; JUSB1.21 5.91,130.61 ; JUSB1.21 7.24,129.77 ; JUSB1.21 4.57,129.77 ; USB2.4 13.98,27.5 ; USB2.4 13.14,26.66 ; USB2.4 13.14,28.34 ; 5.44,39.74 USB2.11 7.18,38.85 ; 12.24,50.14 USB1.12 12.24,48.36 ; 5.44,64.39 USB1.11 7.18,63.5 ; 4.08,85.05 RJ1.11 2.75,85.89 ; 9.22,68.25 RJ1.10 ; RJ1.10 10.55,67.41 ; RJ1.10 11.88,68.25 ; USB2.12 12.24,25.49 ; USB2.12 12.24,23.71 ; USB2.12 13.68,24.6 ; 12.24,38.29 USB2.13 12.24,36.51
  L4 w0.381: 3.64,117.83 2.25,117.83 JUSB1.13 2.04,117.62 2.97,116.69 ; 98.81,151.8 H14.1 104.11,151.8 ; USB2.13 12.24,37.99 11.66,38.57 ; 11.47,47.77 12.24,48.54 USB1.12 ; RJ1.12 4.25,68.25 ; 12.03,30.01 11.64,30.4 USB2.7 ; USB2.10 8.1,23.15 ; RJ1.11 1.32,84.75 ; 7.65,121.16 7.36,121.16 JUSB1.B12 6.48,120.28 6.48,119.23 ; 63.7,143.57 H13.1 65.99,145.8 ; 6.53,128.37 6.53,127.07 JUSB1.B1
  L4 w0.635: 3.5,109.49 HDMI1.23 4.83,108.5 ; 10.37,106.6 HDMI1.21 11.7,105.61 ; 8.24,128.96 JUSB1.20 7.15,128.18 ; 3.37,129.77 JUSB1.22 2.04,130.61 ; 4.57,117.63 JUSB1.14 ; JUSB1.14 7.24,117.63 ; JUSB1.14 5.91,116.79 ; 9.22,68.25 RJ1.10 ; RJ1.10 10.55,67.41 ; RJ1.10 11.88,68.25 ; 7.18,38.85 USB2.11 5.44,39.74 ; USB2.12 12.24,25.49 ; USB2.12 12.24,23.71 ; USB2.12 13.68,24.6 ; RJ1.9 10.55,85.89 ; RJ1.9 9.22,85.05 ; RJ1.9 11.88,85.05 ; 7.18,63.5 USB1.11 5.44,64.39 ; 11.7,91.11 HDMI1.20 ; HDMI1.20 10.37,92.1 ; HDMI1.20 13.03,92.1 ; HDMI1.20 11.7,93.09 ; 4.57,129.77 JUSB1.21 7.24,129.77 ; 12.24,61.16 USB1.13 12.24,62.94 ; 7.15,119.23 JUSB1.15 ; JUSB1.15 9.33,119.23 ; JUSB1.15 8.24,118.44 ; 4.83,90.2 HDMI1.22 3.5,89.21 ; USB2.4 13.98,27.5 ; USB2.4 13.14,28.34 ; USB2.4 13.14,26.66 ; 5.44,46.91 USB1.10 7.18,47.8 ; 2.75,85.89 RJ1.11 4.08,85.05
  L5SGND w0.381: 99.63,151.8 H14.1 103.91,151.8 ; 3.89,22.53 4.51,23.15 USB2.10 8.07,23.15 ; RJ1.11 1.24,84.69 ; RJ1.12 4.09,68.25 ; 65.79,145.8 H13.1 63.7,143.48 ; 2.91,116.74 2.04,117.62 JUSB1.13 2.35,117.93 3.74,117.93
  L5SGND w0.635: USB1.12 12.24,50.14 ; USB1.12 13.68,49.25 ; USB1.12 12.24,48.36 ; 68.01,106.09 H19.1 ; H19.1 65.83,108.27 ; H19.1 70.19,108.27 ; H19.1 68.01,110.45 ; 9.22,68.25 RJ1.10 ; RJ1.10 11.88,68.25 ; RJ1.10 10.55,67.41 ; HDMI1.21 13.03,106.6 ; HDMI1.21 11.7,105.61 ; HDMI1.21 10.37,106.6 ; HDMI1.21 11.7,107.59 ; USB2.13 12.24,38.29 ; USB2.13 13.68,37.4 ; USB2.13 12.24,36.51 ; 9.22,85.05 RJ1.9 ; RJ1.9 11.88,85.05 ; RJ1.9 10.55,85.89 ; 4.08,85.05 RJ1.11 2.75,85.89 ; 129.01,106.09 H22.1 ; H22.1 126.83,108.27 ; H22.1 129.01,110.45 ; H22.1 131.2,108.27 ; 13.98,52.15 USB1.4 13.14,52.99 ; USB2.12 13.68,24.6 ; USB2.12 12.24,23.71 ; USB2.12 12.24,25.49 ; HDMI1.20 13.03,92.1 ; HDMI1.20 10.37,92.1 ; HDMI1.20 11.7,91.11 ; HDMI1.20 11.7,93.09 ; HS3.1 42.02,131.05 ; HS3.1 40.2,132.87 ; HS3.1 40.2,129.23 ; HS3.1 38.38,131.05 ; JUSB1.21 7.24,129.77 ; JUSB1.21 5.91,130.61 ; JUSB1.21 4.57,129.77 ; 6.71,125.93 JUSB1.B1 6.71,127.94 ; 12.24,61.16 USB1.13 ; USB1.13 12.24,62.94 ; USB1.13 13.68,62.05 ; 6.71,119.46 JUSB1.B12 6.71,121.47 ; H21.1 129.01,86.16 ; H21.1 131.2,83.97 ; H21.1 129.01,81.79 ; H21.1 126.83,83.97 ; USB2.4 13.98,27.5 ; USB2.4 13.14,26.66 ; USB2.4 13.14,28.34 ; 5.44,46.91 USB1.10 7.18,47.8 ; 8.24,118.44 JUSB1.15 ; JUSB1.15 7.15,119.23 ; JUSB1.15 9.33,119.23 ; 2.04,130.61 JUSB1.22 3.37,129.77 ; 4.83,108.5 HDMI1.23 3.5,109.49 ; 11.55,94.77 HDMI1.2 ; HDMI1.2 12.19,95.35 ; HDMI1.2 10.91,95.35 ; JUSB1.20 9.33,128.18 ; JUSB1.20 8.24,128.96 ; JUSB1.20 7.15,128.18 ; 7.18,38.85 USB2.11 5.44,39.74 ; 10.91,98.35 HDMI1.8 12.19,98.35 ; 4.83,90.2 HDMI1.22 3.5,89.21 ; 5.44,64.39 USB1.11 7.18,63.5 ; JUSB1.14 7.24,117.63 ; JUSB1.14 4.57,117.63 ; JUSB1.14 5.91,116.79
  BOTTOM w0.076: CPU1.CP19 122.69,95.28 122.89,95.26 122.89,95.26 124.31,95.26 v1(124.32,95.24) ; 77.08,88.99 v1(77.07,88.98) ; v1(116.64,83.14) 116.61,83.16 CPU1.CE36 ; CPU1.CP15 122.62,97.79 124.02,97.79 v1(124.25,98.02)
  BOTTOM w0.089: v1(99.62,79.94) 99.62,79.95 100.3,80.64 100.3,80.9 ; v1(75.44,86.67) 76.05,87.27 76.48,87.27 76.91,87.71 78.24,87.71 CPU1.B31 ; 102.82,82.02 102.82,82.54 102.82,82.55 102.8,83.12 102.8,83.82 102.79,84.29 CPU1.BB36
  BOTTOM w0.09: CPU1.B29 77.08,88.99
  BOTTOM w0.102: CPU1.BD36 104.03,84.09 v1(104.04,83.38) ; CPU1.V33 87.82,86.11 88.04,86.11 arc(88.21,86.22) 88.4,86.26 CPU1.Y33 ; CPU1.CP13 v1(123.18,99.07) ; CPU1.AB36 90.16,84.29 90.16,82.27 v1(90.16,82.27) ; v1(103.56,79.01) 103.05,79.51 103.05,80.45 102.82,82.02 ; CPU1.AP36 97.74,83.85 97.83,83.73 98,83.25 98.02,83.2 98.02,82.43 97.95,81.55 97.95,80.26 v1(97.34,79.48) ; v1(77.15,90.45) 77.35,90.25 CPU1.B27 ; 100.3,80.9 100.32,83.21 100.32,83.42 CPU1.AV36 ; CPU1.BF36 105.29,81.9 105.58,81.61 v1(105.58,81.59) ; CPU1.CP21 123.11,94.05 ; v1(92.49,82.35) 92.68,82.88 92.68,84.04 92.7,84.06 CPU1.AF36 ; CPU1.E29 CPU1.E31
  BOTTOM w0.127: v1(114.91,107.24) 114.9,107.23 CPU1.CB2 CPU1.CB3 ; JUSB1.A1 8.08,120.95 JUSB1.16 ; v1(114.08,83.47) 114.08,84.19 114.07,84.2 114.07,84.38 CPU1.BY36 CPU1.BY35 ; CPU1.C21 CPU1.B21 78.01,94.37 v1(77.52,94.37) ; ED5701.8 ED5701.3 v1(15.66,95.66) ; v1(82.38,83.07) 82.38,83.23 82.6,83.46 82.6,84.28 CPU1.J36 ; v1(123.2,94.02) 123.19,94.04 123.11,94.05 ; JUSB1.17 9.04,122.7 v1(9.07,122.73) ; JUSB1.A12 8.29,126.45 8.53,126.69 JUSB1.19 8.53,127.88 JUSB1.20 ; CPU1.AB33 CPU1.AD33 ; v1(119.46,107.27) 119.46,107.45 121.12,109.11 v1(121.83,109.11) ; CPU1.BP36 110.32,83.63 v1(110.42,83.53) ; v1(116.61,85.66) CPU1.CE35 CPU1.CE36 ; v1(77.42,86.95) 77.54,87.07 CPU1.A32
  BOTTOM w0.15: v1(120.55,87.63) 120.5,87.62 120.29,87.23 120.29,87.02 120.32,86.72 CPU1.CM33
  BOTTOM w0.152: CPU1.CK7 119.4,102.87 v1(119.17,102.87) ; v1(123.59,107.05) 123.08,106.6 CPU1.CR2 CPU1.CP2 ; CPU1.P36 85.15,83.22 ; v1(121.88,107.33) 122.37,107.82 123.31,107.82 v1(123.89,108.4) v1(124.93,109.44) v1(125.87,110.38) 125.87,110.45 127.52,112.1 130.37,112.1 133.13,114.87 133.13,115.63 C1807.1 v1(134.01,116.51) 134.35,116.84 v1(134.35,118.85) 133.93,119.26 v1(131.47,119.26) 130.62,118.41 v1(130.62,116.94) 130.18,116.94 129.44,116.21 C1808.1 129.37,115.88 R1803.2 129.37,114.76 128.5,113.89 126.68,113.89 v1(123.84,111.06) 123.78,111.06 v1(122.53,109.81) v1(121.83,109.11) ; v1(121.88,107.33) CPU1.CP1 ; v1(121.88,107.33) CPU1.CN1 121.43,106.26 CPU1.CN2 ; CPU1.CL2 CPU1.CM1 120.86,106.61 121.23,106.99 v1(121.23,107.27) ; v1(87.38,82.6) 87.38,82.91 87.65,83.19 87.65,84.29 CPU1.V36 ; v1(117.64,107.43) 117.34,107.13 CPU1.CF2 CPU1.CF3 CPU1.CF4 ; CPU1.CJ4 CPU1.CJ3 CPU1.CJ2 ; PR5114.2 163.05,106.64 159.63,103.23 159.63,103.15 159.57,103.09 159.57,96.72 C2525.2 ; v1(105.27,88.67) 104.88,88.28 CPU1.BE30 CPU1.BE31 ; v1(123.07,103.61) 123.04,103.61 123.03,103.63 122.75,103.63 CPU1.CR6 ; CPU1.CN5 121.14,103.99 121.13,103.99 v1(121.12,103.99) 120.92,103.99 120.65,104.04 CPU1.CM5 CPU1.CM4 CPU1.CK4 ; v1(20.63,71.79) 22.23,71.79 22.53,71.48 22.91,71.48 23.22,71.79 23.27,71.79 23.39,71.92 C2428.2 ; v1(123.12,101.75) CPU1.CP9 CPU1.CN9 CPU1.CM9 ; CPU1.CE7 v1(116.42,102.85) ; CPU1.AM10 96.56,101.51 97.03,101.98 v1(97.03,102.2)
  BOTTOM w0.178: CPU1.AM33 96.94,86.26 96.95,86.27 97.22,86.27 97.23,86.26 CPU1.AP33 ; CPU1.AJ28 v1(94.33,89.3) ; CPU1.BF33 105.29,86.27 105.8,86.27 105.8,86.27 106.07,86.27 106.09,86.25 106.53,86.25 CPU1.BH33 ; CPU1.AF33 92.73,86.29 93.94,86.29 CPU1.AH33 ; CPU1.E33 80.26,86.56 80.26,86.84 80.27,86.85 80.27,87.68 CPU1.E31
  BOTTOM w0.18: CPU1.B23 76.91,92.78 76.75,92.85 76.55,92.85 v1(76.36,93.04) ; CPU1.AK36 95.23,83.89 95.31,82.76 95.32,82.75 v1(95.32,82.72) ; v1(107.47,107.31) 107.58,107.21 CPU1.BK2 CPU1.BK3 ; v1(123.28,89.93) 123.02,89.93 122.73,90.22 122.28,90.22 CPU1.CP27 ; v1(123.9,100.41) 123.85,100.35 122.72,100.35 CPU1.CP11
  BOTTOM w0.2: v1(116.61,85.66) CPU1.CE33 ; 122.63,83.48 122.63,84.38 CPU1.CR36 ; CPU1.BH28 v1(107.09,89.3) ; CPU1.AV28 v1(100.71,89.3) ; CPU1.CM37 CPU1.CN37 ; CPU1.AH28 v1(94.33,89.3) ; CPU1.BE28 v1(105.27,89.3) CPU1.BG28 ; CPU1.C29 CPU1.B29 ; CPU1.AW29 v1(101.62,88.67) ; v1(103.44,88.67) 102.99,88.93 CPU1.BC29 ; v1(94.33,88.67) 94.27,88.73 94.23,88.73 CPU1.AH29 ; CPU1.AR28 98.84,89.33 v1(98.88,89.34) ; CPU1.AL28 v1(96.15,89.3) ; v1(93.96,85.66) CPU1.AH33 ; CPU1.BE29 v1(105.27,88.67) ; CPU1.BK4 CPU1.BK3 ; CPU1.K28 v1(82.48,89.3) ; CPU1.AU28 v1(99.8,89.3) ; CPU1.BN30 v1(109.82,88.03) ; CPU1.AU29 v1(99.8,88.67) ; CPU1.AM28 v1(97.06,89.3) ; v1(97.97,88.67) CPU1.AN29 ; CPU1.AB3 CPU1.AB4 ; CPU1.AL29 v1(96.15,88.67) ; CPU1.BH29 v1(107.09,88.67) ; v1(104.35,89.3) CPU1.BD28
  BOTTOM w0.203: CPU1.L36 CPU1.L35 ; DM2.2 106.78,41.97 107.04,41.71 107.65,41.71 107.78,41.84 DM2.6 107.78,45.57 107.47,45.88 107.47,47.01 v1(107.33,47.15) ; U4001.11 v1(58.8,127.95) ; CPU1.BA10 v1(102.09,100.3) ; CPU1.AP3 v1(98,105.1) 98.01,105.07 CPU1.AP4 ; CPU1.CP21 CPU1.CN21 CPU1.CM21 ; DM2.40 116.28,42.05 116.02,41.8 115.44,41.8 115.28,41.96 DM2.36 ; 119.21,27.46 119.21,27.5 118.06,28.64 PU5102.32 ; 113.48,41.68 113.15,41.68 112.78,42.05 DM2.26 ; 113.48,41.68 113.78,41.97 DM2.30 ; 113.48,41.68 113.48,41.26 v1(113.59,41.15) ; CPU1.AN7 97.93,102.25 v1(97.98,102.25) 97.97,102.21 CPU1.AN8 ; CPU1.C29 v1(79.63,88.99) CPU1.E29 ; CPU1.BU16 111.71,97.44 v1(111.65,97.45) ; CPU1.BK7 v1(107.18,102.85) CPU1.BJ7 ; CPU1.CD20 v1(116.22,94.11) CPU1.CC20 CPU1.CB20 ; R6335.2 140.74,108.45 140.74,109.35 v1(140.8,109.4) ; v1(120.34,107.19) 120.34,107.16 120.18,107 120.18,106.95 119.89,106.67 119.86,106.67 CPU1.CK1 ; CPU1.AF3 92.93,105.12 CPU1.AF4 CPU1.AG5 v1(94.21,104.29) ; CPU1.AV3 v1(100.06,105.13) CPU1.AV4 ; 85.15,83.22 v1(85.08,83.15) ; CPU1.CF23 CPU1.CD24 CPU1.CC24 CPU1.CB24 v1(114.94,91.57) ; CPU1.CP35 122.09,85.26 CPU1.CR34 122.57,85.74 v1(123.06,85.26) ; WLAN1.45 41.95,98.41 41.82,98.54 40.59,98.54 40.45,98.4 WLAN1.39 40.45,96.44 v1(40.33,96.32) ; DM2.35 115.03,52.08 115.15,52.2 115.25,52.2 115.25,52.21 115.8,52.21 115.8,52.2 115.9,52.2 116.03,52.08 DM2.39 ; v1(107.02,86.65) 106.63,86.26 CPU1.BH33 ; v1(107.02,86.65) 106.69,86.98 CPU1.BH32 ; v1(107.02,86.65) 107.41,86.26 CPU1.BK33 ; CPU1.CG7 v1(118.29,102.92) ; PU5102.4 116.1,27.49 116.13,27.46 ; ED3201.8 39.42,84.41 C3203.2 ; CPU1.J33 82.63,86.68 CPU1.K32 82.93,86.98 82.93,87.63 CPU1.K31 ; CPU1.BE10 v1(104.86,100.35) ; CPU1.W7 v1(87.78,102.85) CPU1.U7 ; CPU1.AC10 v1(91.01,100.39) ; CPU1.BT14 CPU1.BT15 v1(111.65,97.45) ; R9324.1 155.1,144.16 v1(154.76,144.5) 154.46,144.5 154.06,144.09 R9323.1 ; CPU1.F4 80.73,105.08 CPU1.F3 CPU1.F2 80.7,106.33 v1(80.7,106.94) ; CPU1.AG10 v1(93.67,100.35) ; CPU1.BG25 v1(105.72,91.87) ; WLAN1.57 44.95,98.4 44.82,98.52 44.7,98.52 44.7,98.53 43.7,98.53 43.7,98.52 43.65,98.52 43.45,98.32 WLAN1.51 43.45,96.41 v1(43.59,96.26) ; v1(124.31,47.03) 124.31,47.02 123.28,45.98 DM2.68 ; CPU1.CN25 CPU1.CM25 v1(119.59,91.93) ; 109.03,102.16 CPU1.BN7 ; 109.03,102.16 CPU1.BM9 ; 109.03,102.16 CPU1.BL7 108.33,102.62 v1(108.11,102.85) ; ED3503.8 ED3503.3 15.88,43.82 v1(15.46,43.4) ; CPU1.BV3 112.3,105.47 112.3,104.79 CPU1.BV4 112.29,104.63 v1(111.8,104.14) 111.58,103.92 CPU1.BT5 110.97,104.28 110.34,104.28 110.02,104.61 CPU1.BP4 CPU1.BP3 ; v1(112.42,86.54) 112.42,86.54 112.7,86.26 CPU1.BV33 ; DM2.48 118.28,41.92 118.15,41.8 117.41,41.8 117.28,41.93 DM2.44 ; FP1.8 223.45,62.06 223.37,61.98 222.13,61.98 221.95,62.15 FP1.5 ; CPU1.BY25 114.02,91.07 114.5,91.07 CPU1.CA25 v1(114.94,91.57) ; CPU1.D6 79.89,103.44 CPU1.D5 79.44,104.08 v1(79.37,104.02) 79.32,104.02 79.12,104.22 CPU1.C4 78.77,104.17 CPU1.B5 ; CPU1.AF7 v1(92.4,102.85) CPU1.AE7 ; R9327.1 R9328.1 R9329.1 161.88,141.48 162.46,142.06 v1(162.46,142.19) ; v1(98.98,104.39) CPU1.AU4 ; v1(98.98,104.39) CPU1.AR4 ; v1(98.98,104.39) CPU1.AT4 ; CPU1.AM5 96.83,104.19 96.99,104.19 v1(97,104.18) ; CPU1.A4 CPU1.A3 77.72,105.91 77.72,106.17 v1(77.71,106.18) 78.37,106.18 CPU1.B2 78.45,106.21 CPU1.C1 CPU1.D1 ; v1(114.94,91.57) CPU1.CB25 CPU1.CC25 CPU1.CD25 ; CPU1.T7 v1(85.93,102.85) CPU1.P7 ; v1(80.34,102.85) 79.88,102.39 CPU1.D8 ; v1(110.86,101.65) 110.81,102.25 CPU1.BP7 ; v1(119.98,76.23) 118.88,76.23 117.17,77.93 EC1801.2 ; v1(157.05,141.72) 157.51,141.25 R9326.1 157.84,141.26 R9325.1 158.69,141.26 159.09,141.65 159.09,141.79 159.37,142.08 159.44,142.08 159.77,142.41 PMBD1.11 ; v1(111.65,97.45) CPU1.BT16 ; CPU1.K4 CPU1.K3 ; EC2501.2 153.06,95.74 EC2503.2 153.44,96.67 v1(153.54,96.77) ; R1717.2 128.51,102.55 128.55,102.59 v1(128.55,102.63) ; DM2.10 108.78,45.74 108.29,46.22 108.29,47.68 v1(108.4,47.79) 108.47,47.72 109.03,47.72 109.28,47.48 109.28,47.17 109.35,47.1 109.35,46.89 109.53,46.71 109.53,46.54 109.75,46.32 109.75,44.34 ; C5863.2 53.63,113.34 R5816.1 52.64,113.34 51.98,114 v1(51.2,114) ; CPU1.CN37 121.46,83.83 121.72,83.56 121.72,83.35 v1(121.73,83.34) ; CPU1.CB7 v1(115.54,102.32) ; v1(118.9,98.05) 118.9,98.21 CPU1.CJ14 ; v1(116.8,29.18) 117.06,29.44 PU5102.30 ; CPU1.CB3 CPU1.CB4 114.9,104.5 114.63,104.23 v1(114.57,104.23) 114.55,104.2 114.4,104.2 CPU1.BY5 ; v1(24.9,36.36) 25.15,36.12 25.15,33.83 25.45,33.53 SSD1.45 ; CPU1.AV25 v1(100.25,91.9) ; CPU1.CF19 v1(117.02,95.03) ; CPU1.AB7 89.77,102.86 89.66,102.85 v1(89.63,102.87) 89.58,102.84 89.54,102.85 CPU1.Y7 ; CPU1.J5 v1(83.14,103.56) CPU1.J6 ; CPU1.B7 v1(77.72,102.87) ; v1(100.32,107.49) 100.42,107.47 100.93,106.72 CPU1.AW1 ; CPU1.L6 v1(84.08,103.5) CPU1.N6 85.17,104.22 CPU1.P4 85.35,104.89 85.35,105.37 CPU1.P3 ; CPU1.CF14 v1(116.91,98.34) CPU1.CD14 116.48,98.65 115.95,98.65 CPU1.CC14 ; v1(153.94,84.96) 153,84.02 EC2502.2 ; RN1703.1 146.45,82.88 ; 146.45,82.88 146.53,82.8 146.53,82.14 RN1703.2 ; 146.45,82.88 Q1702.1 146.45,84.08 v1(146.81,84.43) ; v1(88.7,104.15) 88.52,104.15 CPU1.V4 CPU1.V3 ; CPU1.BK10 v1(107.64,100.3) ; CPU1.BC25 v1(102.99,91.9) ; C2409.2 24.06,64.44 R2448.2 24.21,64.49 C2429.2 24.03,65.3 C2418.2 24.43,65.89 v1(24.84,65.48) ; U5502.11 U5502.15 ; CPU1.CJ19 v1(119.56,95.02) ; v1(60.53,37.84) U4004.11 ; CPU1.E33 80.21,86.15 80.31,86.05 80.31,85.88 v1(80.45,85.74) 80.75,86.04 CPU1.F33 ; v1(109.06,83.34) 109.06,81.05 108.68,80.66 R1715.2 ; DM1.214 85.58,44.46 85.46,44.57 85.46,45.28 84.99,45.75 v1(84.97,45.75) 84.48,45.26 84.48,44.12 84.58,44.03 DM1.210 ; CPU1.CP13 CPU1.CN13 CPU1.CM13 ; v1(116.42,102.85) CPU1.CC7 ; ED3501.8 ED3501.3 16.56,53.64 15.88,53.64 15.86,53.67 v1(15.82,53.7) ; JUSB1.B12 7.15,120.95 JUSB1.A1 ; CPU1.AU10 v1(99.32,100.31) ; CPU1.BD6 CPU1.BD7
  BOTTOM w0.254: 119.06,86.29 CPU1.CJ33 ; 119.06,86.29 118.77,86.29 118.62,86.43 118.04,86.43 CPU1.CG33 ; 119.06,86.29 119.06,86.66 118.9,86.82 118.9,87.21 CPU1.CH31 118.66,87.81 118.79,87.81 v1(118.93,87.95) ; CPU1.R28 v1(85.21,89.3) ; VGABD1.6 201.95,58.08 201.58,57.71 200.64,57.71 v1(200.58,57.66) 200.45,57.79 VGABD1.9 ; v1(142.57,109.55) 143.21,109.55 143.34,109.68 Q2505.S ; v1(78.26,98.25) 78.26,98.13 CPU1.B15 ; v1(122.63,83.46) 122.63,83.48 122.13,83.99 CPU1.CP37 ; 165.65,38.85 165.65,39.76 165.56,39.85 v1(165.56,39.95) ; CPU1.Y30 v1(89.76,88.65) CPU1.AB30 v1(90.68,88.03) CPU1.AC30 CPU1.AE30 v1(92.51,88.03) CPU1.AF30 CPU1.AH30 ; CPU1.T33 v1(86.41,85.66) CPU1.T35 CPU1.T36 86.63,84.18 86.63,83.62 v1(86.63,83.61) ; v1(111.1,119.13) 110.98,119 108.18,119 ED301.3 ; CPU1.U24 CPU1.U26 87.04,90.69 ; PC4432.2 203.2,43.33 v1(203.2,42.88) ; CPU1.H27 v1(82.48,89.94) CPU1.K27 CPU1.L27 ; v1(152.81,146.84) 152.78,146.81 C9104.2 ; v1(111.62,89.94) 111.54,89.94 CPU1.BT28 ; v1(120.55,87.63) 120.55,87.64 120.68,87.77 CPU1.CM31 ; CPU1.Y26 88.86,90.69 CPU1.Y27 v1(88.86,89.94) 88.7,89.94 CPU1.W27 ; CPU1.G27 v1(80.64,89.92) CPU1.E27 ; CPU1.G36 CPU1.G35 v1(81.43,85.75) CPU1.G33 ; CPU1.B37 CPU1.C37 79.05,84.44 CPU1.C36 CPU1.B36 ; CPU1.K24 v1(82.81,91.64) ; v1(82.81,91.64) CPU1.J24 ; v1(82.81,91.64) CPU1.K25 ; CPU1.E35 80.46,85.35 80.46,85.73 v1(80.45,85.74) ; v1(51.57,96.85) 51.57,96.85 51.67,96.95 51.67,97.87 51.23,98.3 WLAN1.77 50.57,98.28 50.57,96.85 50.26,96.54 49.74,96.54 49.45,96.82 WLAN1.75 49.45,98.53 49.28,98.7 48.12,98.7 47.95,98.53 ; 47.95,98.53 47.75,98.72 46.71,98.72 46.45,98.46 WLAN1.63 46.45,96.74 46.21,96.5 45.25,96.5 v1(45.12,96.37) ; 47.95,98.53 WLAN1.69 ; CPU1.BA6 102.3,103.27 v1(102.59,103.56) ; CPU1.AH31 93.78,87.72 93.78,88.19 CPU1.AH30 ; EC2506.2 153.2,101.33 152.5,102.02 152.5,103.31 152.03,103.79 v1(152,103.79) ; CPU1.V26 87.95,90.69 CPU1.V27 ; R1714.2 102.57,111.2 v1(102.64,111.12) ; Q1702.4 145.15,84.75 145.42,84.48 146.75,84.48 v1(146.81,84.43) ; CPU1.AN28 v1(97.97,89.3) ; CPU1.BD36 CPU1.BD35 v1(104.03,85.66) CPU1.BD33 CPU1.BC32 103.1,86.52 CPU1.BB33 ; CPU1.AK33 v1(95.89,86.45) 95.88,86.45 CPU1.AL32 ; v1(100.72,102.2) 100.68,102.2 100.45,101.97 CPU1.AV8 ; CPU1.BU23 v1(112.31,92.41) CPU1.BU24 v1(111.66,91.58) ; CPU1.AV33 CPU1.AU32 CPU1.AT33 v1(98.99,85.66) CPU1.AT35 CPU1.AT36 ; CPU1.AH30 v1(94.33,88.67) ; CPU1.AB4 90.49,104.44 CPU1.AC5 v1(91.48,104.14) ; CPU1.R27 v1(85.21,89.94) CPU1.N27 CPU1.N25 ; WLAN1.18 35.2,104.13 34.6,103.54 v1(34.24,103.54) ; v1(140.43,87.76) 141.03,88.36 C2224.2 141.18,88.5 142.88,90.2 143.41,90.2 U2502.2 ; CPU1.BK28 v1(108,89.3) 108.28,89.58 CPU1.BL28 ; CPU1.BE3 CPU1.BD4 CPU1.BC4 102.82,105.12 v1(102.81,105.12) ; CPU1.BE3 CPU1.BE4 ; CPU1.BE3 104.82,105.32 v1(105.02,105.12) ; ED1707.1 103.84,117.34 C1711.2 103.84,115.01 v1(103.94,114.91) 103.86,114.83 R1719.2 ; v1(88.57,100.33) 88.57,100.38 88.24,100.71 CPU1.W10 ; CPU1.BU7 CPU1.BW7 113.31,102.62 v1(113.66,102.96) ; v1(126.57,90.93) 126.92,90.58 C2204.2 C2205.2 C2203.2 128.93,90.4 C2207.2 130.13,90.4 C2202.2 ; CPU1.BT25 v1(111.66,91.58) ; v1(111.66,91.58) CPU1.BU25 ; CPU1.CJ35 119.13,85.02 119.26,84.89 119.26,84.58 119.13,84.45 CPU1.CJ36 119.31,84.4 119.63,84.09 CPU1.CK37 119.63,83.53 v1(119.69,83.47) ; v1(102.81,105.12) 102.81,105.06 CPU1.BB4 ; v1(102.81,105.12) 102.81,105.12 CPU1.BA3 CPU1.BA4 CPU1.AY4 CPU1.AW4 CPU1.AW3 ; v1(102.81,105.12) 102.81,105.18 CPU1.BB3 ; CPU1.BP25 v1(110.36,91.58) CPU1.BR25 ; WLAN1.13 v1(33.95,96.37) ; CPU1.AN31 v1(97.97,88.03) CPU1.AN30 ; 87.04,90.69 CPU1.V27 ; 87.04,90.69 CPU1.T27 v1(87.04,89.94) CPU1.V27 ; CPU1.C21 CPU1.D21 CPU1.F21 CPU1.G21 CPU1.H21 CPU1.J21 ; CPU1.D9 79.77,101.59 79.81,101.63 80.21,101.63 80.33,101.51 CPU1.E9 80.45,101.51 v1(80.86,101.09) 81.28,101.51 CPU1.G9 81.42,101.51 v1(81.76,101.18) 82.09,101.51 CPU1.H9 82.4,101.51 v1(82.81,101.09) 83.16,101.44 CPU1.K9 ; CPU1.B34 CPU1.C33 CPU1.E33 ; v1(105.02,105.12) 105.34,105.12 CPU1.BG4 ; v1(105.02,105.12) 105.13,105 CPU1.BF4 ; v1(105.02,105.12) 105.13,105.24 CPU1.BF3 ; VGABD1.20 194.95,60.16 v1(195.86,61.07) ; VGABD1.12 198.95,57.93 v1(199.18,57.7) ; CPU1.CJ11 119.45,100.37 119.56,100.26 v1(119.56,100.15) ; v1(78.26,101.09) 78.36,101.19 CPU1.B9 ; LCD1.17 219.61,49.05 220.02,49.46 v1(220.02,49.51) ; CPU1.CF28 117.89,89.9 v1(118.03,89.9) ; CPU1.C9 79.01,101.19 v1(78.91,101.09) ; CPU1.J15 82.49,97.86 82.15,98.19 v1(82.15,98.26) ; CPU1.AE27 CPU1.AC27 v1(90.68,89.94) CPU1.AB27 ; v1(80.22,97.33) 80.22,97.48 CPU1.F15 ; CPU1.R31 85.35,87.31 v1(85.26,87.31) 85.15,87.2 CPU1.P33 ; v1(77.17,84.91) 77.63,84.44 CPU1.A36 ; CPU1.AV6 100.45,103.27 100.68,103.49 v1(100.71,103.49) ; SSD1.51 23.95,31.77 23.7,31.52 22.69,31.52 22.45,31.76 SSD1.57 22.45,33.6 22.66,33.81 22.66,33.82 22.66,33.82 22.66,34.68 23.07,35.08 v1(23.12,35.08) ; v1(110.75,86.54) 110.74,86.57 110.37,86.93 CPU1.BP32 ; v1(110.75,86.54) 110.99,86.6 CPU1.BT33 111.53,86.21 v1(111.53,85.71) 111.53,85.68 111.58,85.63 CPU1.BT35 CPU1.BT36 ; v1(110.75,86.54) 110.53,86.28 CPU1.BP33 ; CPU1.CJ28 119.66,89.42 v1(120.16,89.42) 120.18,89.42 120.61,89 CPU1.CM29 CPU1.CN29 ; CPU1.AF33 92.7,86.27 92.31,86.27 92.24,86.34 91.52,86.34 CPU1.AD33 91.44,85.7 v1(91.42,85.68) 91.44,85.65 CPU1.AD35 ; VGABD1.15 197.45,60.69 197.79,61.03 v1(197.79,61.08) ; DM2.56 120.28,41.92 120.09,41.74 119.4,41.74 119.28,41.86 DM2.52 119.28,45.68 119.12,45.83 119.12,47.95 119.45,48.28 119.51,48.28 v1(119.57,48.33) ; PC4629.1 128.98,137.82 PR4644.2 128.53,137.11 128.48,137.06 v1(128.37,137.06) 128.37,137.11 128.3,137.19 PC4601.2 ; CPU1.Y35 v1(88.93,85.66) CPU1.Y33 ; CPU1.K29 82.45,88.63 v1(82.45,88.6) CPU1.K30 CPU1.K31 ; 52.58,41.73 52.58,41.88 ; CPU1.E23 CPU1.F24 80.84,91.73 v1(80.84,91.71) 80.75,91.62 80.32,91.62 80.21,91.51 CPU1.D25 CPU1.C25 CPU1.B25 ; CPU1.AW30 v1(101.62,88.03) 101.59,88.04 101.17,87.66 CPU1.AW31 ; CPU1.BL29 v1(108.91,88.67) 108.52,88.28 CPU1.BL30 108.49,88.25 108.49,87.66 CPU1.BL31 108.6,87.49 108.6,87.13 CPU1.BL32 ; Q401.1 139.48,114.58 139.07,114.99 139.07,115.8 v1(139.07,115.8) 139.31,116.04 C4009.2 139.34,116.94 140.13,116.94 C2610.2 140.31,117.58 R4006.2 ; CPU1.P10 v1(85.87,100.65) ; v1(119.59,91.93) 119.59,91.97 119.59,91.97 119.59,92.13 CPU1.CJ23 ; CPU1.AK3 95.51,105.5 v1(95.51,105.13) 95.51,104.76 CPU1.AK4 ; PU4502.18 v1(41.18,36.07) ; CPU1.AM33 96.48,85.75 v1(96.57,85.65) 96.57,85.6 96.48,85.5 CPU1.AM35 ; CPU1.CB33 115.35,87.24 CPU1.CC31 116.19,87.4 v1(116.21,87.35) ; CPU1.BD7 103.94,102.61 103.94,102.59 103.91,102.57 103.91,102.52 103.74,102.34 103.69,102.34 103.66,102.31 103.58,102.31 v1(103.48,102.21) 103.46,102.21 103.21,101.97 CPU1.BC8 ; CPU1.AN25 v1(97.52,91.89) ; CPU1.L33 v1(83.89,85.66) CPU1.L35 ; CPU1.BY35 114.1,85.47 v1(114.2,85.57) 114.2,85.7 114.1,85.81 CPU1.BY33 ; CPU1.J5 82.7,103.96 82.71,103.97 82.71,104.16 CPU1.K4 ; PU4501.18 v1(68.46,136.07) ; CPU1.BH33 v1(106.55,85.66) CPU1.BH35 ; CPU1.BL25 v1(108.46,91.85) ; CPU1.BR22 110.7,93.67 111.01,93.36 v1(111.01,93.24) ; 101.51,85.66 101.51,85.77 ; 101.51,85.66 v1(101.57,85.71) 101.51,85.77 ; 101.51,85.66 CPU1.AY35 ; 101.51,85.77 CPU1.AY33 ; CPU1.AH35 v1(93.96,85.66) ; CPU1.BA28 v1(102.53,89.3) ; WLAN1.1 30.95,96.62 30.82,96.5 v1(30.51,96.5) ; WLAN1.19 v1(35.45,96.37) ; R1911.2 137.33,93.75 v1(137.35,93.78) ; ED1217.3 56.37,39.66 57.46,40.75 v1(57.46,41.28) ; CPU1.BM33 v1(109.06,85.66) CPU1.BM35 CPU1.BM36 109,84.34 109,83.41 v1(109.06,83.34) ; v1(136.6,134.34) 136.9,134.64 136.9,135.19 PR4661.2 136.64,135.69 PC4638.2 ; CPU1.AW28 v1(101.62,89.3) ; CPU1.R30 v1(85.22,88.66) CPU1.R29 CPU1.T30 86.85,88.09 87.3,88.09 CPU1.V30 v1(87.96,88.65) CPU1.W30 ; CPU1.BE28 v1(104.35,89.3) ; DM2.90 128.78,43.93 v1(129.18,44.34) ; CPU1.BY28 v1(114.38,89.3) ; WLAN1.7 v1(32.45,96.37) ; CPU1.BW24 v1(112.96,91.58) ; CPU1.CC28 v1(116.2,89.3)
  BOTTOM w0.279: DM1.218 86.58,44.1 86.52,44.15 86.52,44.84 86.4,44.96 86.4,45.49 v1(86.87,45.96) ; v1(131.78,44.44) 132.27,44.44 132.78,43.94 DM2.106 ; v1(131.78,44.44) 131.2,44.44 130.78,44.01 DM2.98 ; v1(131.78,44.44) DM2.102 ; v1(82.78,93.65) 83.14,94.01 CPU1.K21 ; v1(82.78,93.65) 83.14,93.3 CPU1.K22 ; v1(82.78,93.65) 82.49,93.95 CPU1.J21 ; v1(111.36,47.35) 111.36,47.31 111.73,46.94 111.73,44.67 111.78,44.62 DM2.22 ; DM1.193 80.33,49.04 v1(80.04,48.76) ; DM2.192 156.28,44.94 157.03,45.7 v1(157.23,45.7) ; v1(168.01,49.67) 168.01,50.38 168.03,50.39 DM2.239 ; v1(161.28,46.45) 161.29,46.43 161.47,46.43 162.7,45.2 162.7,45.12 162.71,44.16 162.78,44.1 DM2.218 ; v1(163.91,47.75) 163.61,47.75 162.53,48.83 DM2.217 ; DM1.26 36.59,42.92 36.59,44.65 36.29,44.95 36.24,44.95 36.12,45.07 v1(36.07,45.07) 35.97,45.07 35.55,44.65 35.55,44.22 35.58,44.19 DM1.22 ; 109.75,44.34 109.78,44.32 DM2.14 ; v1(39.86,47.86) 39.57,47.86 38.84,48.59 38.83,49.24 38.83,49.42 38.83,49.71 DM1.35 ; DM1.248 94.08,44.55 94.1,44.57 94.1,44.69 94.4,45 94.52,45 94.59,45.07 v1(94.62,45.07) ; DM2.69 123.53,50.04 123.48,49.99 123.48,48.47 v1(122.85,47.84) ; v1(41.57,48.38) 41.99,48.8 41.99,49.23 41.83,49.39 DM1.47 ; v1(87.76,47.73) 87,47.73 86.33,48.41 DM1.217 ; 52.58,41.88 DM1.90 ; DM1.235 90.83,48.42 91.73,47.52 v1(91.86,47.52) 91.95,47.52 92.83,48.4 DM1.243 ; v1(77.04,44.4) 77.08,44.36 DM1.180 ; DM1.27 36.83,50.06 36.78,50.02 36.78,49.33 37.11,49 v1(37.3,49) ; DM1.52 43.08,44.63 43.09,44.64 43.09,45.3 43.65,45.86 v1(44.29,45.86) 44.82,45.86 45.2,45.48 45.2,45.05 45.19,45.04 45.19,44.22 45.08,44.11 DM1.60 ; DM1.18 34.58,44.08 34.6,44.1 34.6,44.78 34.04,45.33 v1(34.01,45.33) 33.55,44.87 33.55,44.34 33.58,44.32 DM1.14 ; v1(129.97,46.31) 129.71,46.06 129.71,44.41 129.78,44.35 DM2.94 ; DM1.181 77.33,50.05 77.28,50 77.28,48.98 75.73,47.44 v1(75.54,47.29) ; v1(159.77,45.89) 159.67,45.89 158.78,44.99 DM2.202 ; DM2.222 163.78,44.22 163.79,44.23 v1(163.79,44.34) ; DM2.171 151.03,49.76 v1(150.8,49.54) ; v1(166.09,46.19) 166.31,46.19 167.03,45.47 167.03,44.32 166.87,44.17 166.87,44.16 166.78,44.07 DM2.234 ; v1(74.38,49.02) 74.38,49.46 74.83,49.91 DM1.171 ; DM2.223 164.03,50.5 164.02,50.49 164.02,49.82 163.96,49.76 v1(163.96,49.67) ; v1(116.03,48.98) 115.92,49.09 115.82,49.09 115.51,49.4 115.51,49.49 115.03,49.97 DM2.35 ; v1(155.28,44.57) 155.28,42.91 DM2.188 ; DM1.205 v1(83.33,49.64) ; v1(120.1,48.95) 120.16,49 120.16,49.03 120.53,49.4 DM2.57 ; DM1.226 88.58,45.09 87.71,45.96 v1(87.51,45.96) ; v1(153.24,44.4) 153.28,44.36 DM2.180 ; DM1.72 48.08,45.97 48.8,46.69 v1(49.36,46.69) ; v1(79.08,44.57) 79.08,42.91 DM1.188 ; v1(42.95,49.67) 42.84,50.04 42.84,50.79 42.83,50.81 DM1.51 ; DM1.197 81.33,48.28 80.5,47.45 80.24,47.35 v1(80.05,47.35) ; DM2.247 170.03,49.83 169.97,49.77 169.97,48.82 170.85,47.94 v1(170.87,47.94) ; DM1.227 88.83,48.96 89.61,48.17 v1(89.8,48.17) ; DM2.15 110.03,50.11 109.99,50.07 109.99,48.62 109.6,48.24 108.86,48.24 v1(108.84,48.26) ; DM1.9 32.33,49.5 v1(32.52,49.31) ; DM1.102 v1(55.58,44.44) ; v1(55.58,44.44) 55.96,44.44 56.58,43.82 DM1.106 ; v1(55.58,44.44) 55,44.44 54.58,44.01 DM1.98 ; v1(154.8,48.45) 154.91,48.56 154.93,48.56 155.24,48.86 155.24,48.88 155.53,49.17 DM2.189 ; v1(170.82,45.07) 170.72,45.07 170.28,44.63 DM2.248 ; DM1.77 49.33,49.91 49.27,49.86 49.27,48.15 50.9,46.52 v1(51.17,46.52) 51.27,46.52 51.79,46 51.79,44.18 51.58,43.96 DM1.86 ; DM1.252 95.08,44 95.17,44.1 95.17,46.1 v1(94.67,46.6) ; DM1.176 76.08,43.84 76.04,43.88 76.04,45.43 76.94,46.34 v1(77.09,46.34) ; DM1.36 39.08,43.97 38.82,44.22 38.82,46 38.36,46.46 v1(37.6,46.46) ; DM2.244 v1(169.28,44.35) ; DM1.209 84.33,48.84 85.04,48.12 v1(85.3,48.12) ; DM2.77 125.53,51.1 125.53,48.9 v1(125.84,48.59) ; DM1.234 90.58,45.4 89.89,46.08 v1(89.79,46.08) ; v1(81.08,44.34) DM1.196 ; DM1.31 37.84,51.08 37.84,48.12 37.38,47.66 v1(37.29,47.66) ; DM1.185 78.33,49.75 78.18,49.6 78.18,48.58 77.69,48.09 77.69,46.73 78.19,46.24 v1(78.41,46.24) ; DM2.214 161.78,44.71 161.39,45.09 v1(161.24,45.09) 160.73,44.58 160.73,43.9 160.78,43.85 DM2.210 ; v1(117.57,48.98) 117.6,49.01 117.65,49.01 118.05,49.4 118.05,50.28 118.03,50.3 DM2.47 ; v1(79.08,45.84) 78.93,45.84 78.08,44.99 DM1.184 ; DM1.192 80.08,44.88 80.9,45.7 v1(81.03,45.7) ; v1(154.74,47.08) 154.16,47.66 154.16,49.26 154.48,49.58 154.48,49.71 154.53,49.76 DM2.185 ; DM1.43 40.83,50.15 40.87,50.1 40.87,47.43 40.08,46.64 40.05,46.64 v1(40.01,46.59) ; DM1.6 31.58,44.73 31.29,45.02 31.16,45.02 v1(30.91,45.26) ; v1(122.85,47.84) 122.85,47 122.32,46.47 122.32,43.89 122.28,43.84 DM2.64 ; v1(122.85,47.84) 122.5,47.84 121.48,48.86 121.48,49.83 121.53,49.88 DM2.61 ; DM2.81 126.53,49.28 127.5,48.3 v1(128.95,48.3) ; v1(126.86,47.03) 126.87,47.02 126.87,46.21 125.78,45.11 DM2.78 ; v1(83.52,45.89) 83.39,45.89 82.51,45.02 82.51,44.2 82.58,44.14 DM1.202 ; DM2.231 166.03,49.6 166.07,49.55 v1(166.07,49.43) ; DM1.103 55.83,49.68 55.11,48.97 v1(54.82,48.97) ; DM1.61 45.33,49.83 45.32,49.77 45.27,49.72 45.27,48.06 45.8,47.53 v1(45.82,47.53) 45.9,47.53 47.32,48.95 47.32,49.17 47.33,49.17 DM1.69 ; DM1.23 35.83,49.68 35.84,49.67 35.84,49.25 35.42,48.83 v1(35.32,48.83) 35.22,48.83 34.8,49.25 34.8,49.68 34.83,49.7 DM1.19 ; DM2.23 112.03,50.19 111.97,50.13 111.97,49.25 111.52,48.8 v1(111.46,48.8) 111.37,48.8 110.93,49.25 110.93,49.68 111.03,49.78 DM2.19 ; v1(161.53,49.45) DM2.213 ; DM2.9 108.53,49.69 108.51,49.68 v1(108.51,49.61) ; DM2.206 159.78,44.59 v1(159.77,44.59) ; DM2.65 122.53,49.4 122.2,49.07 122.2,49.05 122.16,49.01 122.16,48.96 v1(122.15,48.96) ; DM2.31 114.03,49.27 113.65,48.89 v1(113.41,48.89) 113.33,48.89 112.91,49.31 112.91,49.74 113.03,49.86 DM2.27 ; v1(85.33,49.43) 85.33,49.44 DM1.213 ; DM2.209 160.53,49.87 160.51,49.86 160.51,48.76 161.13,48.15 v1(161.34,48.15) ; DM2.1 106.53,50.31 106.37,50.15 106.37,49.24 106.51,49.09 107.36,49.09 v1(107.41,49.15) 107.41,49.21 107.53,49.32 DM2.5 ; v1(45.85,48.87) 45.89,48.87 46.31,49.28 46.31,50.3 46.33,50.31 DM1.65 ; v1(150.78,46.23) 151.28,45.73 DM2.172 ; DM2.168 150.28,44.34 v1(150.22,44.4) ; v1(87.58,44.69) 87.58,44.69 DM1.222 ; DM1.93 53.33,49.99 53.71,49.61 v1(54.8,49.61) 54.83,49.63 DM1.99 ; v1(75.77,49.56) 75.77,49.69 75.83,49.74 DM1.175 ; v1(153.29,46.34) 153.14,46.34 152.24,45.43 152.24,43.98 152.28,43.94 DM2.176 ; DM1.244 93.08,44.2 92.97,44.31 v1(92.97,44.34) ; DM2.85 127.53,51.1 127.53,49.98 128.07,49.44 128.63,49.44 v1(128.63,49.44) 128.64,49.44 128.64,49.86 128.53,49.97 DM2.89 ; v1(169.27,46.28) 169.17,46.18 168.4,46.18 167.93,45.71 167.93,43.95 167.78,43.8 DM2.238 ; v1(46.97,46.25) 46.85,46.25 46.1,45.5 46.1,43.86 46.08,43.83 DM1.64 ; v1(74.24,47.74) 73.44,48.54 73.44,49.85 73.83,50.24 DM1.167 ; v1(116.55,48.07) 116.61,48.13 116.61,48.19 116.99,48.56 116.99,48.66 117,48.68 117,51.08 DM2.43 ; v1(170.95,49.29) 171.03,49.37 DM2.251 ; v1(166.1,48.11) 165.69,48.29 165.03,48.96 DM2.227 ; v1(56.58,48.21) 56.58,48.56 56.83,48.81 DM1.107 ; DM2.181 153.53,49.9 153.25,49.63 153.25,49.34 153.22,49.3 153.22,49.2 v1(153.22,49.17) ; DM2.243 169.03,48.6 168.25,47.83 v1(168.1,47.83) 168.08,47.81 167.9,47.81 167.07,48.64 167.07,49.24 167.07,49.25 167.07,50.05 167.01,50.12 DM2.235 ; DM2.103 132.03,49.66 131.34,48.97 v1(130.99,48.97) ; DM2.197 157.53,49.27 156.65,48.4 v1(156.6,48.4) ; DM1.206 83.58,43.7 83.54,43.73 83.54,44.57 v1(83.49,44.61) ; DM2.201 158.53,48.72 158.87,48.37 v1(159.52,48.37) ; v1(130.99,48.34) 131.51,48.34 133.03,49.85 DM2.107 ; v1(32.55,47.05) 32.77,47.05 33.83,48.1 DM1.15 ; DM1.189 79.33,49.39 79.08,49.15 79.08,48.06 78.97,47.95 78.97,47.9 78.66,47.59 78.61,47.59 78.56,47.55 78.35,47.55 78.32,47.51 v1(78.23,47.51) ; DM1.2 30.58,43.97 30.38,44.16 30.38,46.28 30.91,46.81 v1(30.98,46.81) 31.2,46.81 32.58,45.43 DM1.10 ; DM2.72 124.28,44.46 124.48,44.67 124.48,45.73 125.44,46.69 v1(125.45,46.69) ; DM1.172 75.08,44.8 74.65,45.22 v1(74.49,45.22) 74.38,45.22 73.97,44.8 73.97,44.24 74.08,44.13 74.08,42.9 DM1.168 ; v1(110.38,47.26) 110.4,47.25 110.4,46.9 110.8,46.5 110.8,44.1 110.78,44.08 DM2.18 ; v1(94.87,47.96) 94.76,47.96 93.83,48.9 DM1.247 ; DM2.93 129.53,49.84 129.76,49.61 v1(131,49.61) 131.03,49.63 DM2.99 ; DM1.238 91.58,42.91 91.58,45.36 92.57,46.34 v1(93.09,46.34) ; DM1.68 47.08,43.48 47.07,43.49 v1(47.07,44.86) ; v1(91.8,49.44) 91.83,49.46 DM1.239 ; v1(150.8,47.63) 150.69,47.63 149.82,48.5 149.82,50.06 150.03,50.26 DM2.167 ; v1(51.17,45.25) 51.12,45.25 50.58,44.7 DM1.82 ; DM2.230 165.78,44.46 166.07,44.76 v1(166.07,44.88) ; DM2.40 116.28,46.56 115.65,47.19 115.65,47.33 v1(115.57,47.41) ; v1(30.93,49.01) 30.93,49.05 31.33,49.45 DM1.5 ; DM2.86 127.83,42.95 127.83,43.99 129.06,45.22 129.06,46.17 128.75,46.49 v1(128.1,46.49) 127.93,46.49 127.77,46.33 127.77,45.82 127.68,45.73 127.68,45.72 126.78,44.82 DM2.82 ; DM1.48 42.08,44.44 42.1,44.47 42.1,44.97 42.19,45.06 42.19,45.8 v1(42.08,45.91) 41.44,45.91 41.08,45.54 DM1.44 ; v1(163.81,45.61) 163.87,45.54 164.2,45.54 164.78,44.97 DM2.226 ; DM1.81 50.33,48.54 51.07,47.79 v1(51.19,47.79) 51.38,47.79 52.33,48.74 DM1.89 ; v1(155.28,45.84) 155.1,45.84 154.28,45.01 DM2.184 ; DM1.40 40.08,44.7 39.57,45.2 v1(39.52,45.2) ; DM1.231 v1(89.83,49.46) ; v1(152.83,47.33) 152.67,47.33 151.91,48.1 151.91,49.03 151.93,49.05 151.93,50.07 152.03,50.16 DM2.175 ; v1(44.21,44.81) 44.21,44.62 44.08,44.48 DM1.56 ; v1(83.32,48.37) 83.06,48.37 82.33,49.11 DM1.201 ; v1(49.58,44.76) 49.58,44.74 DM1.78 ; DM1.223 87.83,49.83 87.63,49.64 v1(87.63,49.64) ; DM1.251 v1(94.83,49.28) ; DM2.51 119.03,49.45 119,49.42 119,48.99 119.06,48.93 119.06,48.62 118.49,48.05 118.21,48.05 v1(118.11,47.96) 118.01,48.06 117.3,48.06 117.01,47.77 117.01,47.37 117.23,47.15 117.23,42.95 DM2.44 ; DM2.205 v1(159.53,49.64) ; v1(51.6,48.96) 51.33,49.24 51.33,51.1 DM1.85 ; DM1.57 44.33,48.57 43.42,47.67 v1(43.09,47.67) ; v1(157.28,44.35) DM2.196 ; DM2.193 v1(156.53,49.66) ; DM1.230 89.58,44.81 v1(89.58,44.81) ; v1(170.87,46.6) 171.4,46.07 171.4,44.13 171.28,44 DM2.252
  BOTTOM w0.305: v1(31.47,33.53) 31.45,33.51 SSD1.21 ; DM2.60 121.28,46.43 120.87,46.84 v1(120.87,47.53) ; v1(201.9,43) 201.9,43.04 201.58,43.36 PC4440.1 ; CPU1.BW15 113.61,97.45 v1(113.61,97.44) 113.61,97.45 CPU1.BY15 CPU1.CA15 ; PQ4416.1 206.65,47.02 206.49,46.87 v1(206.46,46.87) ; C802.2 67.47,98.91 C4007.2 67.47,100.08 67.92,100.53 v1(68.1,100.53) ; PU4801.28 94.16,138.68 93.88,138.41 v1(93.88,138.25) ; v1(37.58,44.34) DM1.30 ; C1701.2 153.99,140 U9103.16 ; ED7314.1 12.22,119.76 v1(11.72,119.27) ; v1(48.26,48.68) 48.29,48.7 48.29,50.26 48.33,50.3 48.33,51.1 DM1.73 ; v1(78.28,100.14) 78.28,99.99 CPU1.B12 ; C2525.2 159.82,96.35 160.15,96.35 161.45,95.05 ; v1(193,37.7) 192.7,37.4 191.39,37.4 ; TP1.5 106.2,36.15 106.61,36.56 v1(106.61,36.7) ; PQ4415.4 203.75,43.14 PC4432.2 ; 219.89,57.05 219.89,56.37 v1(219.87,56.35) ; 219.89,57.05 LCD1.1 ; 219.89,57.05 218.99,57.95 LCD1.41 ; 191.39,37.4 190.99,37.8 190.99,38.41 190.4,38.99 ; 191.39,37.4 190.79,36.8 ODD1.10 188.17,36.8 187.67,37.3 ODD1.9 ; v1(200.42,37.6) 200.3,37.72 IOBD1.7 ; RN1602.3 136.69,107.74 FC8904.2 ; PR5109.2 163.05,107.42 PR5114.2 ; 59.13,69.06 DBG1.3 ; 59.13,69.06 60.22,67.97 DBG1.16 ; 59.13,69.06 57.29,69.06 57.11,69.06 v1(57.05,69.11) 55.91,67.97 DBG1.15 ; v1(90.27,35.4) 90.79,34.88 PU5301.1 ; EC1707.2 137.85,83.08 v1(138.03,82.91) ; v1(32.21,34.52) 32.24,34.49 32.24,34.37 32.95,33.65 SSD1.15 ; C4043.2 133.77,79.16 v1(133.77,78.4) ; R2009.2 127.54,98.15 v1(127.54,97.69) ; v3(195.38,47.78) 195.43,47.78 196.14,47.07 PC4424.1 196.27,47.02 PC4439.1 ; v1(9.58,116.84) 9.84,116.84 10.48,116.19 ED7301.8 ED7301.3 ; PC5215.2 117.71,143.26 PR5204.2 118.98,142.55 v1(118.98,142.47) 118.9,142.39 PU5201.4 ; v1(27.53,109.21) 27.35,109.21 27.19,109.06 Q7404.1 ; v1(159.18,110.67) 159.75,110.67 159.88,110.54 EC2504.2 159.98,110.63 160.53,110.63 161.06,110.1 161.06,109.68 161.02,109.63 PC5127.2 ; v1(126.97,132.95) 126.88,133.05 PC4631.2 ; CPU1.BP15 110.36,97.49 v1(110.35,97.44) CPU1.BR16 ; v1(80.22,100.14) 80.22,100.14 80.22,99.99 CPU1.F12 ; v1(29.64,33.69) 29.64,33.68 29.95,33.38 SSD1.27 ; v1(96.14,103.58) 96.14,103.13 CPU1.AL7 CPU1.AJ7 ; PC4633.2 142.98,136.7 v1(143.21,136.48) ; Q7404.4 25.62,111.71 v1(25.76,111.85) ; CPU1.BR19 v1(110.36,94.93) CPU1.BP19 ; IOBD1.4 201.8,38.06 201.38,37.64 v1(201.15,37.64) ; DM2.73 124.53,51.1 124.53,50.3 124.49,50.26 124.49,49.61 v1(124.46,49.59) ; EC2505.2 155.86,111.18 v1(156.49,111.81) ; ED3502.2 19.37,47.04 19.73,46.68 19.78,46.68 19.9,46.56 19.94,46.56 19.99,46.51 20.04,46.51 20.09,46.46 20.23,46.46 v1(20.3,46.39) ; v1(131.07,146.23) 130.78,145.94 PR4628.2 PR4629.2 131.56,145.64 PC4607.2 ; v1(114.27,94.93) CPU1.BY19 CPU1.BY18 ; ED7312.1 v1(12.61,122.4) 12.61,121.92 ED7313.1 ; v1(82.17,100.16) 82.17,100.16 82.17,99.99 CPU1.J12 ; v1(112.31,94.09) CPU1.BU20 ; 161.45,95.05 161.88,95.05 162.44,94.49 164.11,94.49 164.13,94.46 v1(164.75,94.46) ; 161.45,95.05 161.22,94.82 D2601.A ; v1(214.63,59.78) 215.45,59.78 215.63,59.78 PWR1.8 ; LCD1.7 219.66,54.05 v1(219.87,54.26) ; R5544.1 136.71,117.45 v1(136.38,117.45) ; v1(162.61,39.96) 162.65,39.92 HDD2.7 ; 190.4,38.99 190.21,38.8 ODD1.6 ; 190.4,38.99 190.4,39.96 190.06,40.3 ODD1.3 ; U4007.3 88.51,40.83 v1(88.03,41.31) ; PU5201.19 116.34,139.03 116.1,138.79 v1(116,138.79) ; v1(150.71,141) 149.95,141 149.47,140.52 U9103.23 ; v1(120.13,96.02) 120.14,96.09 CPU1.CM17 CPU1.CN17 ; R2610.2 57.54,90.28 v1(56.77,90.28) 56.76,90.29 C2613.2 ; FC8904.2 136.86,107.32 136.63,107.09 RN1602.4 ; FC8904.2 139.02,107.32 v1(139.18,107.15) ; CPU1.CB19 115.55,95.7 v1(115.55,95.76) 115.55,95.83 CPU1.CB18 ; v1(131.26,143.24) 131.23,143.24 130.18,144.3 130.18,144.39 129.66,144.91 129.12,144.91 128.12,143.91 PC4603.1 ; v1(63.48,126.67) EC8947.2 62.44,126.02 PC4525.2 ; SSD1.33 v1(28.45,33.69) ; v1(202.7,55.1) 202.66,55.1 202.59,55.17 PC4417.1 201.64,55.36 EC6405.2 ; v1(21.04,60.45) 21.78,60.45 ED1702.1 22.91,60.8 22.91,60.66 C6405.2 ; C7304.2 C7302.2 11.33,125.5 10.96,125.87 10.44,125.87 10.43,125.88 v1(10.26,125.88) 10.06,125.68 9.9,125.68 9.9,125.68 9.01,124.79 8.62,124.79 JUSB1.18 ; v1(39.87,49.13) 39.87,49.43 39.83,49.47 DM1.39 ; WLAN1.33 v1(38.29,97.53) ; SSD1.39 26.95,33.43 v1(26.67,33.71) ; C6506.2 101.27,34.88 100.82,34.42 100.82,33.35 101.52,32.65 TP1.10 102.29,31.53 v1(102.29,30.28) ; C4001.2 v1(55.23,127.99) C4017.2 ; v1(78.27,95.44) 78.27,95.59 CPU1.B18 ; CPU1.CC16 115.57,97.35 v1(115.57,97.44) ; C6320.2 150.97,111.36 150.97,111.36 150.52,111.81 150.52,112.83 150.69,113 R6337.2 ; v1(155.83,93.73) 155.93,93.83 156.47,93.83 156.82,94.18 156.82,94.34 C2502.2 156.92,94.84 157.84,95.76 C2501.2 ; CPU1.CA22 v1(114.25,94.08) CPU1.BY22 ; v1(109.7,99.14) CPU1.BP12 ; CPU1.BV31 v1(113.47,87.27) ; DM1.1 30.33,50.31 29.26,49.25 v1(29.26,48.44) ; LCD1.4 v1(219.87,55.55) ; v1(132.33,129.16) 131.95,129.16 131.78,129.33 PC4644.2 ; v1(15.5,47.19) 15.4,47.09 14.32,47.09 MESW1.5 ; v1(138.37,112.58) 138.37,113.25 Q401.4 137.41,113.28 R403.1 ; ED1302.3 128.78,41.11 DM2.90 ; R2504.2 160.39,79.96 161.08,79.27 R2517.2 Q2510.S 163.45,80.03 164.47,81.05 164.47,82.93 164.06,83.34 C2517.2 163.76,83.34 FAN1.6 ; WLAN1.76 29.85,96.72 30.2,96.37 30.39,96.37 v1(30.51,96.5) ; PWR1.7 209.91,59.64 C6401.2 209.91,56.46 209.91,55.71 209.63,55.42 ED9202.2 ; CPU1.F18 80.21,95.58 v1(80.21,95.44) ; PR4659.1 132.18,134.98 v1(131.88,134.67) 131.88,133.35 PC4637.2 ; v1(82.15,95.44) 82.15,95.52 82.49,95.85 CPU1.J18 ; CPU1.K24 83.35,92.33 83.35,93.03 CPU1.K22 ; PU4802.28 v1(85.04,138.63) ; PC5305.2 93.58,40.31 93.58,41.04 93.11,41.51 91.59,41.51 v1(91.51,41.59) ; v1(160.96,88.27) 160.4,87.7 FAN1.2 158.25,87.7 158.09,87.86 158.09,87.87 157.77,88.19 157.77,89.43 C2605.2 C2603.2 ; v1(219.81,51.66) 219.43,52.05 LCD1.11 ; CPU1.B37 CPU1.A36 ; Q7405.4 27.04,104.42 R7429.2 ; v1(202.71,37.22) 202.71,37.38 203.3,37.98 IOBD1.1 ; PQ4415.1 207.64,44.44 207.69,44.49 v1(207.72,44.49) 207.74,44.5 207.9,44.5 207.92,44.53 208.06,44.53 208.37,44.83 208.37,45.28 208.43,45.35 PQ4416.4 ; v1(9.86,44.53) 9.91,44.53 10.26,44.88 10.26,46.2 10.39,46.33 11.45,46.33 MESW1.4 ; ED5502.2 216.81,47.84 216.85,47.88 v1(216.91,47.88) ; v1(164.15,39.95) 164.15,39.87 164.15,39.87 HDD2.4 HDD1.17 ; ED4306.1 124.19,40.13 v1(124.93,40.87) ; PWR1.5 213.45,57.12 213.31,57.25 213.31,57.28 213.21,57.38 v1(213.21,57.51) ; v1(202.88,61.09) 202.88,62.1 203.54,62.75 VGABD1.22 ; v1(220.12,60.15) LCD1.43 ; v1(39.63,40.2) 38.9,40.2 PR4551.2 38.74,40.18 PC4531.2 37.96,40.11 PR4513.2 ; v1(223.98,62.23) 223.98,62.23 223.59,62.62 FP1.8 ; PU5001.4 112.74,142.47 112.61,142.34 v1(112.4,142.34) ; v1(156.14,139.32) C2614.2 ; v1(34.14,34.14) 34.45,33.82 SSD1.9 34.45,31.27 ; R1521.2 136.15,81.56 135.59,82.12 v1(135.59,82.68) ; ED7302.3 ED7302.8 v1(10.17,127.31) ; v1(141.05,143.92) 141.05,143.85 140.72,143.52 PC4622.2 140.69,142.34 PR4639.2 139.83,142.34 v1(139.25,141.76) ; IOBD1.10 198.8,39.29 198.94,39.42 v1(198.94,39.43) ; C9113.2 v1(147.68,137.52) ; 163.9,91.65 v1(165.74,93.49) ; CPU1.BE8 CPU1.BE10
  BOTTOM w0.356: PC4520.2 41.26,40.97 v1(40.52,40.97) ; v1(147.33,112.77) 146.98,112.42 R6336.2 ; C3203.2 37.19,84.71 v1(37.16,84.74)
  BOTTOM w0.381: R3102.2 43.01,86.67 43.26,86.41 v1(43.74,86.41) ; v1(134.42,132.87) 134.46,132.83 134.46,131.73 PC4640.2 ; v1(134.42,132.87) 134.27,132.72 PC4641.2 ; v1(134.42,132.87) 134.39,132.89 PC4639.2 ; ODD1.17 188,44.03 187.35,44.68 v3(186.54,44.68) ; C7306.2 10.23,112.8 9.74,113.29 5.79,113.29 H18.1 ; PC4524.2 42.58,40.84 PC4520.2 ; v1(73.19,131.94) 72.73,132.4 PC4507.2 ; v1(216.53,41.63) 216.53,42.22 215.4,43.36 215.36,43.36 215.22,43.5 214.79,43.5 214.76,43.52 214.67,43.52 FC8974.2 ; PC5124.2 166.55,107.9 v1(166.55,107.18) ; v1(52.16,105.74) 52.24,105.74 52.5,105.49 U6101.2 ; C1702.2 138.79,129.77 139.7,129.77 v1(139.73,129.74) ; PC5302.2 100.07,37.26 v1(100.07,37.18) 100.21,37.03 PC5121.2 ; 6.44,119.08 6.44,120.23 JUSB1.B12 ; ED6401.3 211.36,53.29 U5501.2 ; 110.8,144.4 111.32,144.92 FC8954.2 111.35,144.92 FC8955.2 FC8956.2 ; 110.8,144.4 v1(110.8,144.27) ; 110.8,144.4 110.8,144.41 110.29,144.92 FC8953.2 ; 66.58,145.8 H13.1 63.7,143.61 ; R1817.2 135.49,118.04 C1809.2 136.25,117.58 v1(136.38,117.45) ; SPR3.1 24.71,45.59 v1(23.23,45.59) ; C4034.2 C4031.2 121.77,127.74 v1(121.85,127.66) ; R7430.2 26.55,112.65 v1(25.76,111.85) ; U4002.5 121.43,114.57 122.43,113.57 v1(122.43,113.19) 122.95,113.19 124.21,114.45 C4033.2 ; v1(72.09,139.09) 72.32,138.86 PR4508.2 72.29,138.41 PC4508.2 PC4532.2 72.93,136.86 v1(73.08,137.01) ; v1(114.82,124.37) U4006.5 113.43,125.01 C4012.2 ; C1135.2 C1134.2 112.25,114.89 v1(113.11,115.75) ; v1(137.66,132.07) 137.54,132.19 PR4655.1 ; 8.02,23.15 USB2.10 ; v1(15.52,114.1) 15.3,113.87 R5782.2 13.77,113.87 C7305.2 ; v1(28.93,102.9) 28.91,102.87 27.36,102.87 26.9,103.33 R7429.2 ; PC4416.1 208.03,51.41 PC4419.2 PC4422.2 208.41,49.84 v1(208.96,49.84) ; R1518.2 59.9,103.54 R1517.2 59.47,104.74 v1(59.47,104.88) ; PC4421.2 198.32,51.77 197.21,51.77 196.96,51.53 PC4402.2 196.94,51.56 196.84,51.66 v1(195.71,51.66) ; MESW1.7 14.21,38.88 v1(14.3,38.79) ; PC5120.2 v1(165.71,107.57) ; v1(142.95,80.57) 143.46,80.06 ED1705.1 ; ED7311.1 12.41,123.73 v1(12.45,123.69) ; PC4601.2 128.35,137.8 PC4624.2 ; v1(126.05,93.18) 126.05,92.91 126.38,92.59 R2116.2 ; PC5305.2 93.57,40.27 94.6,40.27 C1227.2 ; v1(28.33,116.22) 28.28,116.28 R7422.2 ; 104.19,151.8 H14.1 99.07,151.8 ; ED1701.1 154.23,140.73 v1(154.16,140.81) ; v1(142.83,145.42) 142.27,144.86 141.86,144.86 PR4621.1 141.84,144.45 PC4615.1 ; v1(18.34,98.55) 18.19,98.55 18.04,98.71 ED5702.3 ED5702.8 ; C4032.2 126.32,117.04 126.6,117.32 EC2201.2 126.62,117.98 127.16,118.52 v1(127.21,118.52) ; C1703.2 61.95,127.3 v1(61.98,127.27) 62.13,127.27 62.46,127.61 PC4512.2 ; Q501.S v1(104.22,38.48) ; 2.77,116.77 2.77,116.89 JUSB1.13 2.45,118.04 3.53,118.04 ; v1(100.08,110.67) 99.52,110.11 R708.2 ; v1(201.9,41.44) 201.84,41.44 201.41,41 ED6601.2 ; RJ1.12 4.17,68.25 ; RJ1.11 1.2,84.7
  BOTTOM w0.406: U5702.1 15.64,100.99 15.12,101.51 v1(15.12,101.52)
  BOTTOM w0.508: v1(154.16,140.81) 154.03,140.68 C1701.2 ; v1(52.4,130.46) 52.78,130.08 C4004.2 ; v1(152.41,104.66) 152.71,104.66 BIOS2.4 ; v1(210.54,60.07) 210.54,59.99 210.35,59.8 PWR1.7 ; BIOS1.4 151.16,86.12 151.17,86.11 151.17,85.24 150.9,84.97 v1(150.9,84.84) ; 163.9,91.65 162.93,91.65 C2604.2 162.7,91.43 FAN1.5 ; v1(206.76,63.68) 206.85,63.59 VGABD1.21 ; C6320.2 C6323.2 151.82,111.29 151.83,111.29 152.47,110.65 152.47,110.44 v1(152.47,110.43) ; PC4812.2 87.66,145.44 v1(87.48,145.62) ; R2518.2 159.9,84.18 v1(160.86,84.18) 161.09,84.4 FAN1.6 162.99,84.7 162.99,89.7 FAN1.5 ; ED6401.3 211.46,53.44 210.56,53.44 210.54,53.42 v1(210.4,53.42) ; PC4604.1 139.47,145.54 PR4608.1 PR4614.2 138.69,146 138.64,146.05 138.64,146.18 v1(138.54,146.28) ; C3518.2 18.11,39.27 17.61,39.78 U3502.2 16.34,39.78 15.85,40.26 15.85,40.97 v1(15.86,40.98) ; R2112.2 132.31,93.42 v1(132.34,93.45) 133.12,93.45 C1113.2 C1123.2 ; EC6402.2 v1(9.47,130.02) ; v1(70.27,127.48) 70.27,126.48 69.52,125.73 PC4513.2 69.52,124.39 PC4511.2 PC4510.2 ; DM1.261 29.9,57.45 31.17,56.18 31.4,56.18 31.49,56.1 v1(31.52,56.1) ; PC5001.2 114.35,141.51 114.71,141.88 PC5202.2 116.28,141.88 v1(116.49,142.09) ; v1(197.29,43.48) 197.26,43.48 197.17,43.38 PC4426.1 ; FAN1.5 161.4,88.7 161.39,88.7 v1(160.96,88.27) ; v1(163.24,108.14) 163.21,108.14 PR5109.2 ; 225.56,69.68 225.56,68.4 ; PR4654.2 74.64,140.46 74.76,140.59 v1(74.96,140.59) ; v1(97.01,41.15) 97.66,41.15 98.32,40.5 C1223.2 ; DM2.262 173.07,59 v1(171.56,60.51) ; C2503.2 155.71,81.56 v1(156.29,82.14) ; v1(146.98,34) BATT1.11
  BOTTOM w0.635: 7.15,119.23 JUSB1.15 8.24,118.44 ; 3.5,109.49 HDMI1.23 4.83,108.5 ; HDMI1.20 13.03,92.1 ; HDMI1.20 11.7,91.11 ; HDMI1.20 11.7,93.09 ; HDMI1.20 10.37,92.1 ; 3.5,89.21 HDMI1.22 4.83,90.2 ; 12.24,23.71 USB2.12 ; USB2.12 12.24,25.49 ; USB2.12 13.68,24.6 ; 4.57,117.63 JUSB1.14 ; JUSB1.14 5.91,116.79 ; JUSB1.14 7.24,117.63 ; 10.37,106.6 HDMI1.21 11.7,107.59 ; 5.44,39.74 USB2.11 7.18,38.85 ; RJ1.9 10.55,85.89 ; RJ1.9 9.22,85.05 ; RJ1.9 11.88,85.05 ; 12.24,36.51 USB2.13 12.24,38.29 ; 7.18,63.5 USB1.11 5.44,64.39 ; 4.57,129.77 JUSB1.21 ; JUSB1.21 5.91,130.61 ; JUSB1.21 7.24,129.77 ; 37.01,131.05 HS3.1 ; HS3.1 40.2,134.24 ; HS3.1 43.39,131.05 ; 5.44,46.91 USB1.10 7.18,47.8 ; 4.08,85.05 RJ1.11 2.75,85.89 ; 3.37,129.77 JUSB1.22 2.04,130.61 ; RJ1.10 11.88,68.25 ; RJ1.10 9.22,68.25 ; RJ1.10 10.55,67.41 ; 12.24,62.94 USB1.13 12.24,61.16 ; 8.24,128.96 JUSB1.20 7.15,128.18
  vias: v1(1.81,7.11) v1(1.92,134.76) v1(1.92,4.96) v1(2.59,1.12) v1(3.3,130.77) v1(3.43,87.66) v1(3.41,66.47) v1(3.36,65.08) v1(3.88,116.87) v1(4.19,130.6) v1(4.26,136.78) v1(5.01,67.25) v1(5.16,1.09) v1(5.29,5.49) v1(5.33,2.15) v1(5.64,66.02) v1(5.66,86.69) v1(5.8,108.21) v1(5.76,88.69) v1(5.89,90.28) v1(6.46,109.34) v1(6.59,3.77) v1(7.18,108.36) v1(7.39,65.61) v1(7.43,46.65) v1(7.57,89.45) v1(7.82,116.87) v1(7.93,66.98) v1(8.1,39.53) v1(8.32,129.98) v1(8.28,2.12) v1(8.45,109.59) v1(8.67,108.33) v1(8.69,63.88) v1(8.8,47.63) v1(9.08,86.57) v1(9.23,90.6) v1(9.23,88.69) v1(9.62,114.86) v1(9.6,22.76) v1(9.85,1.27) v1(10.18,107.95) v1(10.17,105.18) v1(10.24,93.58) v1(11.09,131.51) v1(11.91,88.85) v1(12.15,86.71) v1(12.28,130.7) v1(12.83,99.11) v1(12.85,22.91) v1(13.14,68.78) v1(13.33,93.05) v1(13.59,97.33) v1(13.9,69.6) v1(13.93,25.97) v1(14.1,84.66) v1(14.13,71.02) v1(14.18,130.25) v1(14.41,93.06) v1(14.42,90.99) v1(14.36,88.88) v1(14.35,86.81) v1(14.57,83.97) v1(14.86,117.55) v1(15.4,127.51) v1(15.52,116.12) v1(15.87,33) v1(15.93,24.79) v1(15.9,24.13) v1(15.9,23.42) v1(16.1,124.57) v1(16.44,121.24) v1(16.74,123.24) v1(17.19,22.68) v1(17.28,0.84) v1(17.35,130.72) v1(19.11,130.69) v1(20.3,90.15) v1(20.53,4.42) v1(20.65,130.72) v1(21.14,105.79) v1(21.13,83.89) v1(21.31,4.9) v1(21.74,84.31) v1(21.74,83.62) v1(21.95,58.24) v1(22,107.27) v1(22,106.53) v1(22,105.79) v1(22,105.06) v1(22,104.37) v1(21.97,1.09) v1(22.11,130.69) v1(22.58,57.08) v1(22.81,105.79) v1(23.09,36.12) v1(23.49,43.68) v1(23.77,41.69) v1(23.87,58.22) v1(24.01,54.99) v1(24.06,130.72) v1(24.16,56.39) v1(24.95,3.94) v1(24.96,117.78) v1(25.52,13.76) v1(25.55,116.13) v1(25.72,130.7) v1(25.91,41.75) v1(26.22,13.77) v1(26.6,39.93) v1(26.93,116.97) v1(26.93,15.26) v1(26.93,14.53) v1(26.93,13.77) v1(27.55,133.56) v1(27.56,132.49) v1(27.62,13.76) v1(27.74,40.29) v1(27.82,38.35) v1(28.27,13.76) v1(28.5,134.68) v1(28.71,113.95) v1(28.79,108.92) v1(29.19,134.65) v1(29.47,106.12) v1(29.52,104.67) v1(29.82,134.65) v1(29.78,94.89) v1(30.51,3.28) v1(30.89,38.15) v1(30.99,134.55) v1(31.84,94.89) v1(32.29,1.17) v1(32.77,134.67) v1(33.04,118.39) v1(32.97,3.1) v1(33.31,94.99) v1(33.4,134.67) v1(34.04,134.67) v1(34.32,1.27) v1(34.65,14.33) v1(34.8,134.67) v1(34.94,94.69) v1(35.44,4.45) v1(35.49,3.35) v1(35.56,134.67) v1(36.2,134.67) v1(36.22,112.46) v1(36.27,1.55) v1(36.43,93.45) v1(36.35,12.23) v1(36.42,10.54) v1(36.43,7.85) v1(36.83,134.67) v1(37.25,22.01) v1(37.47,134.67) v1(37.95,108.27) v1(38.31,95.33) v1(38.35,23.71) v1(39.38,24.77) v1(40.58,110.41) v1(40.62,25.69) v1(42.26,26.55) v1(42.64,106.31) v1(42.57,85.78) v1(42.73,84.25) v1(42.72,82.88) v1(43.25,134.63) v1(44.48,99.36) v1(45.11,94.41) v1(45.41,83.53) v1(45.6,134.66) v1(45.85,26.8) v1(46.1,84.32) v1(46.09,83.54) v1(46.09,82.78) v1(46.79,83.54) v1(47.36,109.25) v1(47.5,26.77) v1(47.6,96.19) v1(47.58,94.22) v1(47.76,117.88) v1(47.89,121.59) v1(47.96,134.69) v1(48.11,124.59) v1(48.18,123.14) v1(48.85,109.2) v1(49.28,26.77) v1(49.71,123.67) v1(49.71,121.69) v1(50.17,130.46) v1(50.7,119) v1(50.68,26.8) v1(50.9,130.46) v1(50.85,109.7) v1(50.99,108.72) v1(51.26,134.69) v1(51.46,85.19) v1(51.72,87.08) v1(52.05,35.38) v1(53.19,117.88) v1(53.32,26.8) v1(53.7,34.85) v1(53.8,130.66) v1(53.97,41.59) v1(54.23,134.82) v1(55.15,141.58) v1(55.22,136.98) v1(55.32,139.14) v1(55.58,143.45) v1(55.92,26.79) v1(57.12,143.52) v1(57.98,26.9) v1(58.55,143.66) v1(58.66,131.72) v1(58.75,128.88) v1(60.05,93.4) v1(60.21,95.19) v1(60.17,27.02) v1(60.4,142.06) v1(60.63,143.41) v1(60.84,97.03) v1(62.04,142.33) v1(62.66,26.96) v1(63.6,95.1) v1(65.18,26.88) v1(65.41,150.93) v1(65.54,151.97) v1(66.78,148.36) v1(67.39,146.85) v1(67.84,26.93) v1(67.86,152.13) v1(68.03,149.19) v1(68.18,148.08) v1(68.71,150.05) v1(69.04,148.41) v1(69.12,151.96) v1(69.53,150.99) v1(69.91,96.72) v1(70.01,149.41) v1(70.25,152.12) v1(70.76,26.91) v1(70.86,150.29) v1(70.92,89.74) v1(71.64,97.41) v1(71.59,93.07) v1(71.9,151.27) v1(72.05,45.72) v1(72.73,91.38) v1(72.88,152.16) v1(73.03,96.09) v1(72.98,93.01) v1(72.98,89.87) v1(73.84,87.76) v1(74.1,91.41) v1(74.29,92.99) v1(74.26,26.92) v1(74.48,138.33) v1(74.53,89.06) v1(74.53,34.47) v1(74.88,94.36) v1(75.06,96.04) v1(75.24,84.77) v1(75.59,152.16) v1(76.2,136.83) v1(76.64,139.49) v1(77.09,138.23) v1(77.07,137.54) v1(77.07,136.86) v1(77.17,79.81) v1(77.22,77.9) v1(77.55,144.5) v1(77.57,143.87) v1(77.8,138.23) v1(77.78,137.54) v1(77.78,136.86) v1(77.8,26.8) v1(77.96,152.16) v1(78.51,138.23) v1(78.5,137.56) v1(78.51,136.86) v1(78.95,77.19) v1(78.95,75.9) v1(78.97,80.27) v1(78.97,78.46) v1(79.2,138.2) v1(79.2,137.54) v1(79.23,136.86) v1(80.46,152.16) v1(80.5,77.7) v1(80.62,80.93) v1(80.67,75.72) v1(81.82,78.63) v1(81.81,26.83) v1(82.07,76.78) v1(83.04,152.16) v1(83.91,32.1) v1(83.96,78.05) v1(84.84,32.11) v1(85.12,26.85) v1(85.72,152.19) v1(85.83,32.11) v1(86.87,136.91) v1(87.31,139.56) v1(87.73,137.62) v1(87.73,136.93) v1(87.76,138.3) v1(88.12,152.16) v1(88.45,137.62) v1(88.45,136.93) v1(88.47,138.3) v1(88.54,26.83) v1(89.18,138.3) v1(89.17,137.64) v1(89.18,136.93) v1(89.87,138.28) v1(89.87,137.62) v1(89.89,136.93) v1(90.89,152.21) v1(91.47,26.82) v1(91.75,136.09) v1(92.05,91.89) v1(92.28,92.48) v1(92.41,136.07) v1(92.38,32.01) v1(93.2,152.16) v1(93.87,91.85) v1(95.55,152.21) v1(95.58,136.96) v1(96.02,139.61) v1(96.7,138.25) v1(96.68,137.62) v1(96.68,136.98) v1(97.34,138.3) v1(97.31,137.62) v1(97.31,136.98) v1(97.31,77.57) v1(97.41,143.66) v1(97.77,152.19) v1(98,138.28) v1(97.98,137.61) v1(97.97,136.96) v1(98.63,138.25) v1(98.63,137.59) v1(98.63,136.96) v1(99.55,78.59) v1(100.16,59.67) v1(101.03,109.69) v1(101.48,80.34) v1(101.54,78.36) v1(101.63,58.29) v1(102.66,109.22) v1(103.66,75.34) v1(103.9,80.81) v1(105.01,112.75) v1(105.16,110.72) v1(105.21,108.69) v1(105.68,152.16) v1(106.02,77.78) v1(106.25,102.85) v1(107.14,81.72) v1(107.54,112.91) v1(107.52,109.01) v1(107.52,78.27) v1(107.56,80.3) v1(107.74,110.97) v1(108.18,93.32) v1(108.89,152.22) v1(108.86,139.29) v1(109.86,40.65) v1(110.04,123.83) v1(110.2,111.81) v1(110.26,113.72) v1(111.13,139.88) v1(111.15,140.59) v1(111.48,111.94) v1(111.61,142.34) v1(111.64,123.82) v1(112.32,99.97) v1(112.7,27.03) v1(113.4,47.74) v1(113.48,113.73) v1(113.52,111.81) v1(113.61,99.97) v1(113.98,152.21) v1(114.61,49.61) v1(114.91,113.84) v1(114.86,111.86) v1(114.88,109.75) v1(116.46,100.94) v1(116.71,110.17) v1(116.79,114.1) v1(116.79,112.14) v1(118.53,110.43) v1(118.82,114.25) v1(118.78,112.32) v1(118.98,152.22) v1(119.87,111.71) v1(120.48,137.87) v1(120.5,113.38) v1(120.96,30.7) v1(121.36,26.77) v1(122.08,121.72) v1(123.7,121.21) v1(123.69,120.05) v1(123.94,122.67) v1(124.68,130.16) v1(125.32,130.12) v1(125.64,119.69) v1(125.95,130.12) v1(127.79,122.86) v1(127.76,121.68) v1(128.57,122.87) v1(129.34,152.22) v1(129.8,34.85) v1(130.2,132.74) v1(131,30.63) v1(132.72,152.21) v1(132.85,140.01) v1(133.13,119.75) v1(133.25,34.4) v1(133.48,140.01) v1(133.81,119.74) v1(133.88,30.69) v1(134.21,141.43) v1(134.21,140.75) v1(134.21,140.03) v1(134.24,139.24) v1(134.24,138.61) v1(135,140.01) v1(135.64,140.01) v1(136.42,30.64) v1(136.76,152.2) v1(138.96,30.69) v1(140.24,152.22) v1(141.42,82.51) v1(144.17,44.38) v1(144.53,152.22) v1(144.88,146.13) v1(147.81,75.16) v1(149.2,152.23) v1(149.23,141.76) v1(149.99,141.76) v1(150.73,143.17) v1(150.72,142.47) v1(150.72,141.75) v1(150.72,140.31) v1(151.03,146.28) v1(151.48,141.74) v1(152.02,40.24) v1(152.15,141.73) v1(152.59,152.24) v1(152.76,70.26) v1(153.34,110.31) v1(154.78,145.82) v1(155.57,67.64) v1(155.73,40.19) v1(156.53,152.21) v1(156.71,40.14) v1(157.28,145.93) v1(157.47,40.17) v1(158.56,116.12) v1(159.31,117.25) v1(159.34,59.51) v1(159.7,152.19) v1(160.61,102.49) v1(160.63,64.47) v1(161.51,33.73) v1(162.59,121.82) v1(163.13,137.3) v1(163.15,135.24) v1(163.17,132.04) v1(163.15,131.3) v1(163.51,105.12) v1(163.58,152.19) v1(163.82,33.7) v1(164.72,95.51) v1(164.71,32.49) v1(165.1,57.94) v1(165.52,105.2) v1(166.37,152.2) v1(166.69,32.46) v1(167.26,116.94) v1(167.26,116.31) v1(167.82,105.3) v1(168.07,55.02) v1(168.29,95.01) v1(168.53,149.53) v1(168.55,106.51) v1(168.61,147.26) v1(168.58,144.83) v1(168.61,141.92) v1(168.61,138.8) v1(168.62,135.83) v1(168.61,132.98) v1(168.59,130.61) v1(168.59,128.01) v1(168.58,125.78) v1(168.63,112.04) v1(168.61,110.71) v1(168.59,109.06) v1(168.56,107.81) v1(169.45,53.67) v1(170.92,80.7) v1(172.85,46.47) v1(181.16,71.81) v1(183.26,30.79) v1(183.85,70.28) v1(183.93,30.79) v1(184.58,30.79) v1(188.95,52.83) v1(189.64,52.81) v1(192.32,32.46) v1(193.42,35.1) v1(193.38,33.91) v1(193.7,61.07) v1(194.24,37.2) v1(195.31,35.51) v1(195.31,33.86) v1(198.53,30.58) v1(199.93,30.58) v1(201.65,30.58) v1(202.5,49.93) v1(202.5,49.04) v1(202.5,48.15) v1(203.13,30.59) v1(203.24,49.93) v1(203.24,49.04) v1(203.24,48.15) v1(204.13,49.93) v1(204.13,49.04) v1(204.12,48.27) v1(204.65,30.59) v1(204.9,54.99) v1(205.57,32.92) v1(208.84,68.2) v1(211.97,45.27) v1(211.99,44.5) v1(213.13,60.61) v1(213.52,55.04) v1(213.59,54.37) v1(213.57,53.65) v1(213.67,52.99) v1(213.66,52.21) v1(215.15,66.35) v1(217.46,66.35) v1(219.93,35.87) v1(223.5,69.72) v1(224.41,45.7) v1(224.44,44.98) v1(224.49,34.82) v1(226.14,67.74) v1(226.11,37.44) v1(226.22,61.42) v1(226.21,59.24) v1(226.22,56.64) v1(226.2,53.55) v1(226.22,47.37) v2(49.94,51.69) v2(58.64,86.36) v2(78.83,90.91) v2(82.52,65.29) v2(92.36,50.86) v2(117.78,74.8) v2(139.58,40.77) v2(167.95,51.83) v3(36.57,36.32) v3(37.24,37.59) v3(37.33,36.68) v3(37.37,35) v3(37.7,35.85) v3(38.12,37.56) v3(38.17,36.65) v3(38.21,34.98) v3(38.54,35.82) v3(69.04,139.36) v3(69.02,138.52) v3(69.71,140.06) v3(69.9,139.24) v3(69.85,138.41) v3(71.51,102.41) v3(77.65,143.07) v3(81.33,136.5) v3(81.36,137.47) v3(83.72,128.55) v3(83.7,127.26) v3(84.03,133.66) v3(84.03,132.77) v3(84.05,134.67) v3(84.05,131.85) v3(84.08,131.01) v3(84.18,130.18) v3(84.18,129.34) v3(84.28,127.89) v3(84.84,137.57) v3(84.92,136.6) v3(84.92,134.67) v3(84.94,133.68) v3(84.89,132.77) v3(84.92,130.96) v3(84.97,135.56) v3(84.97,131.8) v3(85.04,130.07) v3(85.04,129.19) v3(85.02,128.32) v3(85.02,127.28) v3(85.1,97.7) v3(85.94,97.7) v3(86.78,97.7) v3(87.62,97.7) v3(88.46,97.7) v3(90.97,97.7) v3(91.53,135.28) v3(91.54,134.39) v3(91.57,133.53) v3(91.83,95.99) v3(91.83,95.15) v3(91.83,94.31) v3(91.83,93.47) v3(92.37,135.28) v3(92.38,134.39) v3(92.41,133.53) v3(92.67,142.95) v3(93.22,136.27) v3(93.42,142.57) v3(93.41,141.73) v3(97.57,142.93) v3(98.15,98.2) v3(98.15,97.36) v3(98.15,96.52) v3(98.15,95.68) v3(98.15,94.84) v3(98.15,94.01) v3(98.15,93.17) v3(100.33,138.08) v3(100.33,137.19) v3(100.33,136.3) v3(101.17,138.1) v3(101.17,137.21) v3(101.17,136.32) v3(101.6,132.23) v3(101.64,131.17) v3(101.6,130.22) v3(101.74,129.3) v3(101.73,127.52) v3(101.76,128.39) v3(102.06,138.1) v3(102.06,137.21) v3(102.06,136.32) v3(102.43,132.35) v3(102.44,130.25) v3(102.46,131.48) v3(102.7,129.27) v3(102.7,128.36) v3(102.72,127.52) v3(103.35,130.12) v3(103.65,129.28) v3(103.65,128.39) v3(103.58,127.55) v3(104.19,130.15) v3(104.34,98.3) v3(104.34,97.46) v3(104.34,96.62) v3(104.34,95.78) v3(104.34,94.95) v3(104.34,94.11) v3(104.34,93.27) v3(108.03,98.43) v3(107.98,96.39) v3(109.52,139.86) v3(109.58,140.72) v3(110.42,140.72) v3(110.39,139.85) v3(111.26,31.55) v3(112.3,33.2) v3(112.42,31.55) v3(112.68,32.45) v3(113.07,30.98) v3(113.24,31.8) v3(113.74,32.49) v3(121.23,136.89) v3(122.09,136.87) v3(122.93,136.86) v3(124.91,131.77) v3(124.89,130.92) v3(125.74,130.86) v3(125.75,131.77) v3(134.14,40.51) v3(134.98,40.51) v3(135.82,40.51) v3(136.66,40.51) v3(180.04,44.58) v3(180.09,46.49) v3(180.09,45.47) v3(180.83,45.95) v3(180.81,44.93) v3(181.54,46.41) v3(181.54,45.51) v3(181.61,44.67) v3(189.49,46.28) v3(190.4,46.28) v3(191.28,46.28) v3(191.76,47.02) v3(192.61,47.04) v3(193.14,46.28) v3(193.45,47.09) v3(194.3,47.02) v4(121.11,37.38) v4(121.85,37.38) v4(124.56,138.16) v4(124.56,137.47) v4(124.79,139.78) v4(124.79,127.64) v4(125,141.83) v4(125.01,141.15) v4(125.01,140.45) v4(151.44,119.79) v4(152.12,119.79) v4(153.88,119.94) v4(154.69,119.94) v4(155.4,119.89)
