# Allegro board 17938-1.1228WZS1107.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SSD_PCIE_RX_N15: length 159.3
  L4 w0.114: v1(106.26,104.13) 106.41,104.13 106.53,104.26 106.53,107.75 106.38,107.91 106.38,111.71 106.09,111.99 106.09,114.56 103.81,116.84 74.78,116.84 74.05,116.1 68.8,116.1 62.06,109.36 62.06,100.69 58.17,96.81 58.17,85.88 50.8,78.51 50.21,78.51 45.09,73.39 45.09,72.85 42.07,69.83 41.81,69.83 39.75,67.77 39.6,67.77 39.49,67.77 38.31,66.58 34.66,66.58 31.39,63.32 31.39,59.81 27.87,56.3 27.87,54.33 25.83,52.28 25.73,52.28 24.82,51.37 24.82,42.47 25.11,42.18 25.11,41.54 25.85,40.79 26.15,40.79 26.34,40.99 v1(26.34,41.27)
  BOTTOM w0.127: v1(106.26,104.13) 106.26,104.21 106.08,104.39 105.94,104.39 105.8,104.25 CPU1.BG5 ; v1(26.34,41.27) 26.34,41.13 26.46,41.01 26.72,41.01 26.93,40.81 27.19,40.81 27.36,40.97 28.21,40.97 28.51,40.67 28.51,34.61 29.19,33.93 29.19,33.38 29.25,33.33 29.35,33.33 29.45,33.23 SSD1.29
SSD_PCIE_RX_N16: length 158.7
  L4 w0.114: v1(105.34,104.15) 105.34,104.32 106,104.99 106,107.36 105.69,107.67 105.69,111.51 105.48,111.72 105.48,114.31 103.56,116.23 75.03,116.23 74.22,115.42 68.98,115.42 62.66,109.1 62.66,100.44 58.78,96.55 58.78,85.63 51.06,77.9 50.46,77.9 47.02,74.46 47.02,73.34 46.63,72.95 46.06,72.95 42.88,69.78 42.88,68.89 42.49,68.5 42.19,68.5 41.74,68.05 41.74,67.83 41.08,67.16 39.85,67.16 37.94,65.25 34.19,65.25 32.08,63.14 32.08,59.62 29.09,56.63 29.09,54.66 28.77,54.34 28.77,53.53 28.2,52.96 27.55,52.96 26.13,51.54 26.13,49.45 25.43,48.75 25.43,44.84 27.8,42.47 27.8,41.1 27.28,40.58 27.28,37.93 27.02,37.66 26.58,37.66 25.88,38.36 v1(25.31,38.36)
  BOTTOM w0.127: v1(25.31,38.36) 25.68,38.4 25.82,38.29 25.84,38.11 25.71,37.98 25.71,34.08 25.95,33.84 SSD1.43 ; v1(105.34,104.15) 105.11,104.23 104.95,104.15 CPU1.BE5
SSD_PCIE_RX_P13: length 193.7
  L4 w0.114: v1(34.06,39.02) 34,39.02 33.61,38.63 33.61,36.83 32.75,35.96 32.75,33.87 30.91,32.03 25.71,32.03 24.78,31.09 22.07,31.09 20.76,32.41 20.76,37.59 21.19,38.02 21.19,39.61 21.06,39.74 20.82,39.98 20.82,40.74 21.42,41.33 21.42,49.08 21.97,49.63 21.97,51.99 24.7,54.72 24.7,55.83 25.44,56.56 25.44,57.39 27.49,59.44 27.49,65.32 29.63,67.46 30.99,67.46 33.92,70.4 35.32,70.4 35.87,70.94 39.26,70.94 40.59,72.27 40.88,72.27 42.3,73.69 42.3,74.05 49.42,81.18 49.91,81.18 54.29,85.56 54.29,92.06 54.87,92.64 54.87,96.98 59.03,101.14 59.03,106.63 59.4,107 59.4,107 59.4,110.38 67.57,118.56 73.05,118.56 73.77,119.28 105.9,119.28 109.53,115.65 109.53,109.93 108.66,109.07 108.66,104.17 108.43,103.93 108.33,103.93 v1(108.1,104.17)
  BOTTOM w0.127: v1(34.06,39.02) 33.66,38.62 33.66,38.11 34.28,37.5 34.28,34.66 35.09,33.84 35.09,33.44 34.95,33.3 SSD1.7 ; CPU1.BK5 107.71,104.15 107.87,104.24 v1(108.1,104.17)
SSD_PCIE_RX_P14: length 193.9
  L4 w0.114: v1(33.85,40.28) 33.84,40.28 33.66,40.46 33.27,40.46 33.13,40.32 33.13,40.1 33.47,39.76 33.47,39.58 33,39.11 33,37.19 30.81,34.99 30.81,33.09 30.36,32.64 25.46,32.64 24.6,31.78 22.38,31.78 21.36,32.79 21.36,37.22 21.93,37.78 21.93,39.12 22.1,39.3 22.1,48.85 22.58,49.33 22.58,51.73 25.31,54.46 25.31,55.58 26.05,56.31 26.05,57.14 28.17,59.27 28.17,65.04 29.2,66.07 30.46,66.07 33.99,69.6 38.2,69.6 38.91,70.31 39.49,70.31 40.84,71.66 41.19,71.66 43,73.47 43,73.89 49.65,80.54 50.19,80.54 54.9,85.26 54.9,91.01 56.34,92.45 56.34,97.56 60.23,101.45 60.23,110.28 67.89,117.95 73.3,117.95 74.02,118.67 105.64,118.67 108.91,115.4 108.91,110.2 107.99,109.28 107.99,104.97 107.36,104.34 107.36,104.33 v1(107.18,104.15)
  BOTTOM w0.127: CPU1.BJ5 106.72,104.16 106.85,104.29 107.04,104.29 v1(107.18,104.15) ; SSD1.19 31.95,33.16 32.2,33.41 32.2,33.53 31.37,34.37 31.37,39.29 31.79,39.71 32.28,39.71 32.49,39.93 33.66,39.93 33.85,40.13 v1(33.85,40.28)
SSD_PCIE_RX_P15: length 159.4
  L4 w0.114: v1(106.26,103.49) 106.76,103.99 106.76,107.85 106.61,108 106.61,111.8 106.32,112.09 106.32,114.65 103.91,117.07 74.69,117.07 73.95,116.33 68.7,116.33 61.83,109.46 61.83,100.79 57.94,96.9 57.94,85.97 50.71,78.74 50.11,78.74 44.86,73.49 44.86,72.94 41.98,70.06 41.72,70.06 39.65,68 39.5,68 39.5,68 39.4,68 38.21,66.81 34.56,66.81 31.16,63.41 31.16,59.91 27.65,56.39 27.65,54.42 25.73,52.51 25.64,52.51 24.59,51.46 24.59,42.38 24.88,42.09 24.88,41.44 25.76,40.57 v1(26.54,40.57)
  BOTTOM w0.127: v1(26.54,40.57) 27.29,40.57 27.46,40.73 28.11,40.73 28.27,40.57 28.27,34.51 28.95,33.83 SSD1.31 ; CPU1.BG6 v1(106.26,103.49)
SSD_PCIE_RX_P16: length 158.8
  L4 w0.114: v1(105.34,103.51) 105.76,103.93 105.76,104.42 106.23,104.89 106.23,107.45 105.92,107.77 105.92,111.6 105.71,111.81 105.71,114.4 103.65,116.46 74.94,116.46 74.13,115.65 68.89,115.65 62.44,109.2 62.44,100.53 58.55,96.65 58.55,85.72 50.96,78.13 50.36,78.13 46.79,74.56 46.79,73.44 46.53,73.18 45.96,73.18 42.66,69.88 42.66,68.98 42.4,68.73 42.09,68.73 41.51,68.15 41.51,67.92 40.98,67.39 39.75,67.39 37.85,65.48 34.1,65.48 31.85,63.23 31.85,59.71 28.86,56.72 28.86,54.76 28.54,54.44 28.54,53.63 28.1,53.19 27.45,53.19 25.9,51.63 25.9,49.55 25.2,48.85 25.2,44.75 27.57,42.38 27.57,41.19 27.05,40.68 27.05,38.02 26.93,37.89 26.67,37.89 26.55,38.02 v1(26.55,38.48)
  BOTTOM w0.127: CPU1.BE6 v1(105.34,103.51) ; SSD1.41 26.45,33.07 26.19,33.33 26.19,33.94 25.95,34.18 25.95,37.88 26.09,38.02 26.07,38.22 26.06,38.31 26.17,38.45 v1(26.55,38.48)
SSD_PCIE_TX_CON_N13: length 4.6
  BOTTOM w0.127: SSD1.11 33.95,33.26 33.69,33.52 33.69,34.04 33.28,34.45 33.28,36.43 33.28,36.43 33.28,36.67 C6316.1
SSD_PCIE_TX_CON_N14: length 4.7
  BOTTOM w0.127: SSD1.23 30.95,33.27 30.79,33.43 30.79,33.76 30.17,34.38 30.17,36.64 C6314.1
SSD_PCIE_TX_CON_N15: length 4.7
  BOTTOM w0.127: SSD1.35 27.95,33.37 27.69,33.63 27.69,33.92 27.17,34.44 27.17,36.52 27.16,36.52 27.16,36.67 C6312.1
SSD_PCIE_TX_CON_P13: length 4.6
  BOTTOM w0.127: SSD1.13 33.45,33.94 33.04,34.35 33.04,36.33 C6315.1
SSD_PCIE_TX_CON_P14: length 4.8
  BOTTOM w0.127: C6313.1 29.93,36.42 29.93,34.28 30.55,33.66 30.55,33.49 30.45,33.4 SSD1.25
SSD_PCIE_TX_CON_P15: length 4.7
  BOTTOM w0.127: SSD1.37 27.45,33.82 26.93,34.34 26.93,36.42 C6311.1
SSD_PCIE_TX_N13: length 177.7
  L4 w0.114: v1(107.8,111.61) 108.52,112.33 108.52,115.25 105.48,118.29 74.18,118.29 73.46,117.57 68.05,117.57 60.61,110.13 60.61,101.29 56.72,97.41 56.72,92.28 55.28,90.84 55.28,85.1 50.27,80.09 49.73,80.09 43.43,73.78 43.43,73.34 41.37,71.28 41.1,71.28 39.04,69.22 34.15,69.22 30.62,65.69 29.49,65.69 28.68,64.87 28.68,59.24 26.43,56.98 26.43,56.15 25.69,55.42 25.69,54.31 22.96,51.58 22.96,48.18 22.51,47.72 22.51,39.16 22.39,39.04 22.39,37.68 21.75,37.03 21.75,33.05 22.57,32.23 24.52,32.23 25.3,33.02 30.2,33.02 30.43,33.24 30.43,35.26 32.25,37.08 32.25,38 v1(32.47,38.23)
  BOTTOM w0.076: CPU1.BM4 108.54,105.3 108.54,105.86 108.73,106.05 108.73,109.2 108.69,109.23 108.69,109.25
  BOTTOM w0.127: C6316.2 33.11,37.94 33.11,38.2 32.96,38.34 32.58,38.34 v1(32.47,38.23) ; 108.69,109.25 108.69,111.03 108.12,111.61 v1(107.8,111.61)
SSD_PCIE_TX_N14: length 170.2
  L4 w0.114: v1(107.67,110.31) 107.65,110.29 107.41,110.29 107.29,110.4 107.29,112 107.01,112.28 107.01,114.83 104.16,117.68 74.43,117.68 73.7,116.94 68.34,116.94 61.22,109.82 61.22,101.04 57.33,97.15 57.33,86.26 50.42,79.35 49.86,79.35 44.25,73.74 44.25,73.25 41.67,70.67 41.46,70.67 39.4,68.61 34.43,68.61 30.85,65.03 29.8,65.03 29.37,64.59 29.37,59.06 27.04,56.73 27.04,54.68 26.47,54.12 26.37,54.12 23.96,51.71 23.96,42.15 24.21,41.89 24.21,38.53 22.36,36.67 22.36,33.43 22.87,32.92 24.23,32.92 25.46,34.15 27.29,34.15 30.43,37.3 30.43,38.46 v1(30.84,38.86)
  BOTTOM w0.076: CPU1.BL2 108.23,106.21 108.54,106.51 108.54,107.87 108.18,108.23 108.18,108.51 108.22,108.54 108.22,108.56
  BOTTOM w0.127: v1(30.84,38.86) 30.68,38.7 30.58,38.7 30.17,38.29 30.17,37.86 C6314.2 ; v1(107.67,110.31) 107.67,110.26 108.22,109.72 108.22,108.56
SSD_PCIE_TX_N15: length 145.5
  L4 w0.114: v1(105.02,111.41) 104.57,111.85 103.81,111.85 102.43,113.23 76.58,113.23 76.07,113.75 68.21,113.75 63.27,108.82 63.27,100.19 59.52,96.43 59.52,85.5 51.31,77.29 50.71,77.29 48.69,75.27 48.69,75.02 48.69,75.01 48.69,74.46 48.69,74.46 48.69,73.16 47.95,72.42 46.95,72.42 46.53,72 46.05,72 43.49,69.44 43.49,68.64 43.06,68.2 43.06,67.75 42.67,67.36 42.13,67.36 41.33,66.55 40.82,66.55 40.82,66.55 40.28,66.55 38.62,64.89 38.62,64.49 38.1,63.98 35.76,63.98 33.81,62.03 33.81,60.79 32.72,59.7 32.72,59.4 30.09,56.76 30.09,53.71 28.72,52.34 28.04,52.34 26.82,51.12 26.82,49.23 26.29,48.7 26.29,44.85 28.41,42.73 28.41,39.68 27.93,39.2 27.93,39.18 v1(27.76,39.01)
  BOTTOM w0.076: 107.47,107.92 107.48,107.92 107.52,107.92 107.99,107.44 107.99,107.06 107.8,106.87 107.8,106.48 107.81,106.45 107.83,106.4 107.83,106.18 107.8,106.1 107.8,105.8 107.82,105.79 107.98,105.42 107.98,105.17 108.23,104.91 CPU1.BL4
  BOTTOM w0.127: C6312.2 27.3,38.55 v1(27.76,39.01) ; v1(105.02,111.41) 105.36,111.75 105.56,111.75 106.68,110.64 106.68,108.72 107.47,107.92
SSD_PCIE_TX_N16: length 147.9
  L4 w0.114: v1(105.24,110) 104.87,110 102.09,112.78 76.37,112.78 75.83,113.32 68.31,113.32 63.7,108.71 63.7,99.18 61.17,96.64 61.17,93.84 60.72,93.39 60.72,90.46 60.02,89.77 60.02,85.47 51.47,76.91 50.87,76.91 49.07,75.11 49.07,74.3 49.07,74.3 49.07,72.98 45.04,68.95 45.04,68.55 44.79,68.3 44.15,68.3 42.83,66.97 42.39,66.97 38.1,62.69 35.12,62.69 34.27,61.84 34.27,59.95 33.33,59.02 32.94,59.02 30.48,56.56 30.48,53.56 28.88,51.96 28.2,51.96 27.2,50.97 27.2,49 26.79,48.58 26.79,44.93 28.88,42.84 28.88,39.45 28.26,38.83 28.26,38.06 26.02,35.82 24.67,35.82 24.29,36.19 v1(24.29,36.51)
  BOTTOM w0.076: CPU1.BJ4 107.17,105.16 107.17,105.42 107.35,105.82 107.35,106.1 107.32,106.18 107.32,106.4 107.34,106.45 107.35,106.48 107.35,106.87 106.96,107.26 106.96,107.77 106.45,108.28 106.45,108.32 106.43,108.34
  BOTTOM w0.127: C6303.2 v1(24.29,36.51) ; v1(105.24,110) 105.51,109.72 105.65,109.72 106.06,109.31 106.06,108.71 106.43,108.34
SSD_PCIE_TX_P13: length 177.7
  L4 w0.114: v1(32.46,38.88) 32.02,38.44 32.02,37.17 30.2,35.35 30.2,33.34 30.11,33.25 25.21,33.25 24.42,32.46 22.66,32.46 21.97,33.15 21.97,36.94 22.62,37.58 22.62,38.95 22.74,39.07 22.74,47.63 23.19,48.08 23.19,51.48 25.92,54.21 25.92,55.32 26.66,56.06 26.66,56.89 28.91,59.14 28.91,64.78 29.59,65.46 30.71,65.46 34.24,68.99 39.14,68.99 41.2,71.05 41.47,71.05 43.66,73.24 43.66,73.69 49.83,79.86 50.36,79.86 55.51,85 55.51,90.75 56.95,92.19 56.95,97.31 60.84,101.2 60.84,110.03 68.14,117.34 73.55,117.34 74.28,118.06 105.39,118.06 108.29,115.16 108.29,112.42 108.01,112.14 107.83,112.14 v1(107.7,112.27)
  BOTTOM w0.076: 108.94,109.25 108.94,109.23 108.9,109.2 108.9,105.75 CPU1.BM3
  BOTTOM w0.127: v1(32.46,38.88) 32.02,38.44 32.02,37.79 32.13,37.67 C6315.2 ; v1(107.7,112.27) 108.03,112.6 108.21,112.6 108.35,112.46 108.35,111.72 108.94,111.13 108.94,109.25
SSD_PCIE_TX_P14: length 170.2
  L4 w0.114: v1(107.62,109.65) 107.57,109.65 107.06,110.16 107.06,111.9 106.78,112.19 106.78,114.74 104.06,117.45 74.53,117.45 73.79,116.71 68.44,116.71 61.45,109.72 61.45,100.94 57.56,97.06 57.56,86.16 50.52,79.12 49.95,79.12 44.48,73.65 44.48,73.16 41.76,70.44 41.56,70.44 39.5,68.38 34.52,68.38 30.94,64.8 29.89,64.8 29.59,64.5 29.59,58.97 27.26,56.64 27.26,54.59 26.57,53.89 26.46,53.89 24.18,51.61 24.18,42.24 24.44,41.99 24.44,38.43 22.58,36.58 22.58,33.53 22.96,33.15 24.13,33.15 25.37,34.38 27.19,34.38 30.2,37.39 30.2,39.24 30.49,39.52 v1(30.77,39.52)
  BOTTOM w0.076: CPU1.BL1 108.36,106.69 108.36,107.8 108.01,108.15 108.01,108.51 107.97,108.54 107.97,108.56
  BOTTOM w0.127: C6313.2 29.93,38.07 29.93,38.39 30.28,38.74 30.28,39.65 30.4,39.78 30.64,39.78 30.77,39.65 v1(30.77,39.52) ; v1(107.62,109.65) 107.63,109.66 107.81,109.66 107.97,109.49 107.97,108.56
SSD_PCIE_TX_P15: length 145.6
  L4 w0.114: v1(104.99,112.08) 103.91,112.08 102.52,113.46 76.68,113.46 76.16,113.98 68.11,113.98 63.05,108.91 63.05,100.28 59.29,96.52 59.29,85.59 51.21,77.52 50.62,77.52 48.46,75.36 48.46,74.92 48.46,74.92 48.46,74.55 48.46,74.55 48.46,73.25 47.85,72.64 46.85,72.64 46.44,72.23 45.96,72.23 45.82,72.1 45.82,72.09 43.27,69.54 43.27,68.73 42.83,68.3 42.83,67.84 42.58,67.58 42.04,67.58 41.23,66.78 40.92,66.78 40.18,66.78 38.39,64.98 38.39,64.59 38.01,64.21 35.67,64.21 33.58,62.12 33.58,60.88 32.49,59.8 32.49,59.49 29.86,56.86 29.86,53.8 28.62,52.57 27.94,52.57 26.59,51.22 26.59,49.33 26.06,48.8 26.06,44.76 28.18,42.64 28.18,39.77 28.05,39.64 v1(27.75,39.64)
  BOTTOM w0.076: 107.64,108.1 107.72,108.02 107.72,107.96 108.17,107.52 108.17,106.99 107.98,106.8 107.98,106.51 108.01,106.43 108.01,106.15 107.98,106.07 107.98,105.86 107.98,105.86 108.13,105.51 CPU1.BL3
  BOTTOM w0.127: 107.64,108.1 106.92,108.82 106.92,110.74 105.66,111.99 105.3,111.99 105.22,112.08 v1(104.99,112.08) ; v1(27.75,39.64) 27.31,39.2 27.31,38.89 27.06,38.65 27.06,38.24 C6311.2
SSD_PCIE_TX_P16: length 148
  L4 w0.114: v1(105.21,109.33) 101.99,112.55 76.28,112.55 75.74,113.09 68.41,113.09 63.93,108.61 63.93,99.08 61.39,96.55 61.39,93.75 60.95,93.3 60.95,90.37 60.25,89.67 60.25,85.37 51.56,76.68 50.97,76.68 49.3,75.02 49.3,74.21 49.3,74.2 49.3,72.89 45.27,68.86 45.27,68.46 44.88,68.07 44.25,68.07 42.92,66.75 42.48,66.75 38.2,62.46 35.21,62.46 34.5,61.74 34.5,59.86 33.43,58.79 33.03,58.79 30.71,56.47 30.71,53.47 28.97,51.73 28.29,51.73 27.43,50.87 27.43,48.9 27.02,48.49 27.02,45.02 29.11,42.93 29.11,39.36 28.49,38.74 28.49,37.96 26.11,35.59 24.57,35.59 24.15,36.01 23.72,36.01 23.6,36.13 v1(23.6,36.53)
  BOTTOM w0.076: CPU1.BJ3 107.01,105.5 107.17,105.86 107.17,106.07 107.14,106.15 107.14,106.43 107.17,106.51 107.17,106.8 106.78,107.19 106.78,107.69 106.32,108.15 106.28,108.15 106.26,108.17
  BOTTOM w0.127: v1(23.6,36.53) 24.06,36.07 24.06,35.89 C6302.2 ; v1(105.21,109.33) 105.37,109.48 105.55,109.48 105.82,109.21 105.82,108.61 106.26,108.17
SSD_SATA_TX_CON_N16: length 2.6
  BOTTOM w0.127: SSD1.47 24.95,33.27 24.4,33.82 24.4,34.53 C6303.1
SSD_SATA_TX_CON_P16: length 2.5
  BOTTOM w0.127: SSD1.49 24.45,33.43 24.16,33.72 24.16,34.47 C6302.1
SSD_SCP#: length 73.8
  TOP w0.102: U2401.21 23.08,64.49 22.82,64.24 22.45,64.24 22.14,64.55 21.78,64.55 21.53,64.29 20.89,64.29 20.73,64.45 20.73,65.1 19.64,66.19 v2(19.64,66.44) 19.36,66.72 18.57,66.72 18.51,66.66 17.41,66.66 v1(16.97,67.1)
  L3 w0.102: v1(16.97,67.1) 16.97,67.1 16.97,67.1 16.7,66.83 16.7,66.17 15.14,64.62 15.14,64.39 14.92,64.17 14.92,63.34 14.62,63.04 14.62,59.99 14.85,59.76 14.85,58.4 15.89,57.35 16.11,57.35 16.46,57 16.46,52.78 15.81,52.12 15.81,50.45 14.83,49.47 14.83,43.26 16.7,41.4 16.7,40.47 17.21,39.96 17.21,30.98 17.21,30.31 20.63,26.9 20.63,23.95 21.31,23.28 22.35,23.28 v1(22.86,22.76)
  BOTTOM w0.102: v1(22.86,22.76) 28.37,22.76 28.86,22.28 33.35,22.28 34.7,23.62 SSD1.8
SSEQ0_A0: length 2.3
  TOP w0.102: U7101.11 24.59,104.39 v1(24.67,104.32)
  BOTTOM w0.102: R7146.1 24.56,104.5 24.67,104.4 v1(24.67,104.32) 24.67,104.09 R7145.2
SSEQ1: length 3.7
  TOP w0.102: R7152.2 20.63,101.17 21.09,101.63 v1(21.09,101.91) 21.09,102.03 21.4,102.35 U7101.3
  BOTTOM w0.102: v1(21.09,101.91) 21.61,101.91 22.02,102.32 R7144.1
ST_GPIO: length 2.8
  BOTTOM w0.102: TP9103.1 152.02,146.56 152.02,145.19 151.47,144.63 U9103.6
ST_PP: length 1.4
  BOTTOM w0.102: U9103.7 151.97,144.55 TP9101.1
SUS_CLK: length 296.7
  TOP w0.14: v1(21.44,30.61) 21.98,30.61 v2(22.05,30.67) ; v1(14.98,70.99) 15.32,70.99 17.63,73.31 17.63,73.46 19.05,74.88 19.05,75.41 22.5,78.86 22.5,79.61 23.03,80.14 24.46,80.14 EC1803.2 24.79,79.81 R6117.1 24.79,78.25 R2461.1
  L4 w0.127: v1(111.63,87.23) 111.63,86.46 113.75,84.34 114.76,84.34 116.45,82.65 119.76,82.65 119.98,82.42 121.1,82.42 121.72,81.8 121.72,81.04 145.85,56.9 150.58,56.9 157.72,49.76 157.72,44.17 156.77,43.22 132.97,43.22 132.81,43.38 125.64,43.38 122.96,46.06 108.01,46.06 107.01,45.06 104.12,45.06 103.15,46.02 99.47,46.02 97.01,43.57 95.34,43.57 95.08,43.31 93.53,43.31 93.43,43.22 92.52,43.22 92.25,43.46 81.78,43.46 81.37,43.05 79.49,43.05 79.46,43.02 63.39,43.02 63.38,43.02 36.5,43.02 35.24,41.77 35.24,40.54 35.81,39.97 35.81,39.28 35.88,39.2 35.88,38.27 35.8,38.19 35.8,37.89 35.08,37.17 35.08,34.38 31.42,30.72 31.42,29.27 31.02,28.87 29.65,28.87 28.55,29.96 26.49,29.96 26.41,29.88 22.17,29.88 v1(21.44,30.61) ; v1(15.13,28.5) 14.85,28.5 13.99,29.36 13.99,34.85 13.72,35.12 13.72,37.75 10.87,40.59 v1(9.27,40.59) ; v1(12.97,50.73) 14.04,51.79 14.04,62.55 14.63,63.14 14.63,66.3 15.6,67.26 15.6,70.38 v1(14.98,70.99)
  BOTTOM w0.14: v1(21.44,30.61) 21.31,30.48 20.34,30.48 18.44,28.58 15.92,28.58 15.84,28.5 v1(15.13,28.5) ; CPU1.BT32 111.43,87.21 111.59,87.21 111.61,87.23 v1(111.63,87.23) ; v1(12.97,50.73) 12.97,50.37 13.69,49.65 13.69,48.85 13.14,48.3 11.53,48.3 11.24,48.04 11.14,47.94 10.74,47.59 10.66,47.5 9.55,47.5 8.56,46.51 8.56,45.87 8.85,45.59 8.85,41.02 v1(9.27,40.59)
SUSACK#_R: length 2.4
  TOP w0.14: v2(113.57,86.69) v1(114.38,86.69) 114.46,86.69 R1708.2
  BOTTOM w0.14: CPU1.BY32 114.21,86.69 v1(114.38,86.69)
SUSCLK_WLAN: length 48.4
  TOP w0.14: v1(23.7,79.66) 23.93,79.43 R6117.2
  L4 w0.127: v1(43.18,103.53) 42.66,103.01 42.66,95.57 42.27,95.18 42.27,92.83 41.61,92.16 41.61,81.76 v1(41.58,81.74)
  BOTTOM w0.14: v1(41.58,81.74) 41.18,81.74 40.71,81.27 v2(40.71,79.78) 40.71,79.52 39.82,78.63 39.82,78.63 39.56,78.37 39.56,78.37 37.87,76.68 28.36,76.68 27.91,77.12 27.91,78.7 27.58,79.03 27.58,79.03 26.57,80.04 25.97,80.04 25.82,80.19 24.25,80.19 23.79,79.72 23.76,79.72 v1(23.7,79.66) ; v1(43.18,103.53) 43.2,103.55 WLAN1.50
SVID_ALERT#_CPU: length 140.9
  TOP w0.14: PR4605.2 R704.2 135.03,146.23 v1(134.9,146.36)
  L4 w0.254: v1(53.72,102.16) 53.72,102.8 53.39,103.13 53.39,105.94 54.69,107.24 54.69,107.66 54.69,107.66 54.69,113.86 55.2,114.37 55.2,115.22 54.78,115.63 54.78,118.62 53.98,119.42 53.98,123.54 55.49,125.05 59.3,125.05 60.49,126.24 62.23,126.24 63.34,125.13 70.47,125.13 71.38,126.03 71.38,128.34 71.81,128.77 71.81,131.18 72.17,131.55 72.17,134.42 71.86,134.73 71.86,137.38 73.26,138.78 73.26,141.41 73,141.67 73,143.82 75.92,146.74 93.19,146.74 95.26,144.68 105.55,144.68 107.75,146.88 119.27,146.88 121.34,144.81 128.06,144.81 130.52,147.27 133.99,147.27 v1(134.9,146.36)
  BOTTOM w0.14: v1(134.9,146.36) 134.88,146.33 PR4623.1
  BOTTOM w0.254: R703.1 59.33,108.54 v2(57.72,106.92) 56.9,106.1 56.9,103.86 56.46,103.42 56.03,103.42 55.98,103.37 54.33,103.37 53.72,102.77 v1(53.72,102.16)
SVID_ALERT#_CPU_R: length 35.9
  BOTTOM w0.076: CPU1.AA3 90.09,105.58 90.09,106.14 89.92,106.31 89.73,106.31 89.56,106.48 89.56,106.76 89.82,107.02 89.82,107.77
  BOTTOM w0.14: R703.2 60.87,108.54 v2(61.68,109.35) 64.77,112.44 70.49,112.44 72.75,110.18 87.41,110.18 89.82,107.77
SVID_ALERT#_VR: length 2.4
  BOTTOM w0.14: PR4623.2 134.88,143.71 134.41,143.25 PU4601.36
SVID_CLK_CPU: length 143.2
  TOP w0.14: PR4606.2 R705.2 135.77,146.31 v1(135.77,146.42)
  L4 w0.254: v1(135.77,146.42) 134.41,147.78 130.31,147.78 127.85,145.32 121.55,145.32 119.41,147.45 107.6,147.45 105.34,145.19 95.47,145.19 93.4,147.25 75.71,147.25 72.49,144.03 72.49,141.46 72.75,141.2 72.75,138.99 71.35,137.59 71.35,134.52 71.67,134.2 71.67,131.76 71.3,131.4 71.3,128.98 70.87,128.55 70.87,126.24 70.38,125.75 63.43,125.75 62.44,126.75 60.28,126.75 59.08,125.55 55.7,125.55 55.7,125.56 55.28,125.56 53.47,123.75 53.47,119.23 53.46,119.21 54.28,118.39 54.28,115.42 54.69,115.01 54.69,114.58 54.18,114.07 54.18,107.45 52.89,106.16 52.89,103.04 v1(52.72,102.87)
  BOTTOM w0.14: v1(135.77,146.42) 135.64,146.29 PR4624.1
  BOTTOM w0.254: R702.2 59.19,109.3 v2(58.45,108.56) 56.39,106.5 56.39,104.07 56.25,103.93 53.86,103.93 52.79,102.87 v1(52.72,102.87)
SVID_CLK_CPU_R: length 34.6
  BOTTOM w0.14: R702.1 60.55,109.3 v2(61.94,110.68) 64.09,112.83 70.69,112.83 72.95,110.57 87.57,110.57 90.05,108.1 90.05,107.87 90.05,107.86 90.05,107.67 90.05,107.67 90.05,106.83 CPU1.AA1
SVID_CLK_VR: length 2.6
  BOTTOM w0.14: PR4624.2 135.64,144.43 135.41,144.2 v2(135.41,143.71) 135.41,143.61 134.81,143.02 PU4601.37
SVID_DATA_CPU: length 138.8
  TOP w0.14: PR4604.2 134.29,143.87 133.81,144.35 133.81,145.21 PR4622.1 R706.2 134.27,146.25 134.14,146.38 134.04,146.38 134.04,146.38 v1(133.99,146.38)
  L4 w0.254: v1(133.99,146.38) 133.63,146.74 130.7,146.74 128.27,144.3 121.13,144.3 119.06,146.37 107.96,146.37 105.76,144.17 95.05,144.17 92.98,146.24 76.13,146.24 73.51,143.61 73.51,141.88 73.76,141.62 73.76,138.57 72.37,137.17 72.37,134.94 72.68,134.63 72.68,131.34 72.32,130.97 72.32,128.56 71.89,128.13 71.89,125.82 70.68,124.61 63.13,124.61 62.02,125.73 60.7,125.73 59.51,124.54 55.7,124.54 54.49,123.33 54.49,119.63 55.29,118.83 55.29,115.84 55.71,115.43 55.71,114.16 55.2,113.65 55.2,107.87 55.2,107.03 53.9,105.73 53.9,103.34 v1(54.51,102.73)
  BOTTOM w0.14: v1(133.99,146.38) 134.12,146.25 PR4622.1
  BOTTOM w0.254: R701.2 57.41,105.59 57.41,103.63 56.69,102.92 56.24,102.92 56.06,102.73 v2(55.91,102.73) v1(54.51,102.73)
SVID_DATA_CPU_R: length 34.4
  BOTTOM w0.076: 89.5,107.47 89.5,106.96 89.38,106.85 89.38,106.41 CPU1.AA2
  BOTTOM w0.14: 89.5,107.47 87.18,109.79 72.49,109.79 70.23,112.05 65.46,112.05 v2(61.52,108.11) 61.19,107.78 R701.1
SVID_DATA_VR: length 2.3
  BOTTOM w0.14: PU4601.35 134.01,143.23 134.12,143.33 v2(134.12,143.66) PR4622.2
SW_PIN: length 2.3
  TOP w0.102: v1(54.06,114.68) 53.7,115.03 U5802.18
  BOTTOM w0.102: v2(54.61,114.48) 54.25,114.48 v1(54.06,114.68) 54.05,114.68 R5820.2
SYS_LED_MASK#: length 85.6
  TOP w0.102: U2401.55 33.95,59.71 33.98,59.73 33.98,63.88 31.08,66.78 v1(30.15,66.78) ; v1(42.24,65) 42.24,64.91 Q6402.G ; R2465.1 26.47,78.75 26.19,79.03 26.18,79.03 v1(26.17,79.05) ; Q3201.G 16.79,58.19 15.95,58.19 15.14,59 15.14,60.12 14.6,60.66 14.6,61.51 11.78,64.34 9.63,64.34 8.31,65.66 8.31,66.17 8.94,66.8 12.3,66.8 12.98,67.49 13.67,67.49 15.57,69.39 v1(16.41,69.39) 16.44,69.42 16.44,69.88 16.34,69.98 v2(16.34,70.23) 16.84,70.23 R2497.1
  L4 w0.102: v1(16.41,69.39) 16.13,69.67 16.13,71.25 17.17,72.28 17.17,73.18 17.28,73.28 22.37,78.38 25.52,78.38 26.11,78.97 26.11,78.98 26.17,79.03 v1(26.17,79.05)
  BOTTOM w0.102: v1(42.24,65) 41.3,65 39.02,62.71 37.69,62.71 37.69,62.72 35.98,62.72 34.02,64.68 32.44,64.68 30.34,66.78 v1(30.15,66.78) 29.88,67.05 28.8,67.05 28.59,67.26 25.85,67.26 25.25,67.86 23.27,67.86 22.81,68.31 22.45,68.31 22.16,68.02 21.33,68.02 20.74,67.44 18.49,67.44 18.21,67.71 18.21,68.07 16.89,69.39 v1(16.41,69.39) ; 26.17,78 v1(26.17,79.05) ; 26.17,78 Q6406.5 ; 26.17,78 Q6406.2
SYS_PRES1#: length 8.1
  TOP w0.089: R4301.2 135.65,34.81 136.2,34.81 136.66,34.34 AFTP4315.1 137.93,34.34 138.56,34.98 v1(138.56,35.23)
  BOTTOM w0.089: v1(138.56,35.23) 138.56,36.98 137.82,37.72 BATT1.7
SYS_PWROK: length 226.1
  TOP w0.102: v1(25.43,63.73) 25.67,63.49 25.67,61.77 25.42,61.51 25.06,61.51 25.06,61.51 24.84,61.51 v1(24.79,61.47) 24.57,61.69 U2401.28
  L3 w0.102: v1(165.29,66.47) 165.29,67.35 160.99,71.65 160.99,72.24 152.86,80.37 152.86,82.78 151.74,83.9 151.74,84.91 149.22,87.43 149.06,87.43 148.67,87.43 137.85,98.25 136.96,98.25 133.57,101.64 128.74,101.64 128.54,101.44 127.44,101.44 126.98,100.98 v1(126.98,100.84)
  BOTTOM w0.076: 123.59,101.36 123.54,101.36 123.36,101.18 122.95,101.18 122.87,101.1 CPU1.CR10
  BOTTOM w0.102: v2(24.95,60.69) 24.95,61.31 v1(24.79,61.47) 24.25,61.47 ED1702.2 ; v1(165.29,66.47) 165.29,67.01 165.26,67.04 165.26,67.08 165,67.34 164.65,67.34 164.39,67.08 164.39,66.44 160.42,62.47 157.92,62.47 154.09,58.63 150.79,58.63 150.14,57.98 147.15,57.98 146.56,58.57 111.7,58.57 108.23,62.04 95.43,62.04 90.51,57.12 57.29,57.12 55.33,55.17 42.56,55.17 42.37,54.99 37.35,54.99 36.59,54.22 31.42,54.22 29.55,56.08 27.94,56.08 27.52,56.5 27.52,61.8 26.4,62.93 25.87,63.46 25.86,63.46 25.59,63.73 v1(25.43,63.73) ; R1717.1 127.84,101.68 128.03,101.38 128.03,100.84 127.74,100.55 127.27,100.55 v1(126.98,100.84) 126.45,101.36 123.59,101.36
SYSPWR_PRES: length 9.8
  TOP w0.102: v2(22.33,76.11) 22.86,75.58 R2454.1 23.14,75.31 24.18,74.27 24.18,73.79 25.48,72.49 25.48,72.04 25.79,71.72 26.72,71.72 28.09,73.1 28.13,73.1 28.36,73.33 U2401.120
T_CRIT#: length 4.3
  TOP w0.102: R2601.1 135.11,127.56 v2(134.86,127.32) R2604.2 133.59,126.05 U2601.4
THERM_SYS_SHDN#: length 22.1
  TOP w0.14: v2(135.77,126.01) 135.77,126.32 v1(136.06,126.61) 136.33,126.89 R2601.2
  L4 w0.127: v1(143.31,118.42) 138.69,123.04 138.69,124.66 137.53,125.83 136.85,125.83 v1(136.06,126.61)
  BOTTOM w0.14: R2602.1 141.64,114.56 141.51,114.43 141.51,112.99 Q2602.S 143.09,114.39 143.09,115.64 143.06,116.57 143.05,116.58 143.05,117.7 143.06,117.71 143.06,118.16 v1(143.31,118.42)
THERMTRIP#_CPU: length 13.5
  BOTTOM w0.102: ED301.1 106.07,117.36 106.07,115.4 105.97,115.29 105.41,115.29 105.24,115.11 R308.2 105.1,114.72 104.97,114.72 104.55,114.3 104.55,112.45 v2(104.52,112.42) 104.55,112.4 104.55,110.67 104.78,110.44 104.78,108.52 105.26,108.03 105.59,108.03 106.92,106.7 CPU1.BJ1
TOP_MUX_N: length 27.3
  TOP w0.127: 26.93,117.83 27.68,117.83 27.8,117.96 27.8,118.15 27.93,118.27 EL7105.3 ; 26.93,117.83 26.82,117.83 26.24,117.25 26.24,117.18 26.14,117.08 25.94,117.08 25.74,117.28 25.73,117.28 v1(25.54,117.47) ; 26.93,117.83 v2(26.93,117.98) ; v1(13.64,121.58) 13.3,121.92 12.16,121.92 R7333.2
  L3 w0.114: v1(13.64,121.58) 13.85,121.37 14.55,121.37 15.49,120.43 17.7,120.43 18.43,119.7 22.36,119.7 25,117.06 25.13,117.06 v1(25.54,117.47)
  BOTTOM w0.127: v1(13.64,121.58) 13.43,121.79 13.43,122.56 12.86,123.14 11.59,123.14 10.99,123.73 ED7311.2 10.5,123.25 10.1,123.25 9.55,123.8 8.31,123.8 8.16,123.95 JUSB1.A7
TOP_MUX_N_L: length 2.6
  TOP w0.127: U7102.17 31.31,118.79 30.65,118.13 30.47,118.13 R7131.2 30.09,118.06 29.68,118.06 EL7105.4
TOP_MUX_P: length 26.4
  TOP w0.127: v1(12.98,121.46) 12.77,121.68 12.32,121.68 R7332.2 ; v1(25.55,116.84) 26.24,116.84 26.48,117.08 26.48,117.15 26.92,117.59 EL7105.2
  L3 w0.114: v1(25.55,116.84) 24.9,116.84 22.27,119.47 18.34,119.47 17.6,120.2 15.39,120.2 14.45,121.14 13.41,121.14 13.09,121.46 v1(12.98,121.46)
  BOTTOM w0.127: v1(12.98,121.46) 12.98,121.57 13.18,121.76 13.18,122.47 12.76,122.9 11.48,122.9 ED7312.2 10.36,123.01 10.14,123.01 ; v2(10.14,122.86) 10.14,123.01 ; 10.14,123.01 10,123.01 9.45,123.56 8.19,123.56 8.08,123.45 JUSB1.A6
TOP_MUX_P_L: length 3.3
  TOP w0.127: U7102.18 31.25,118.39 30.75,117.89 R7132.2 30.28,117.59 EL7105.1 v2(29.33,116.74)
TOUCH_I2C_DET#: length 139.1
  L2SGND w0.089: v1(132.57,89.88) 133.28,89.17 140.17,89.17 142.29,87.04 142.29,86.18 143.06,85.42 144.15,85.42 145.98,83.59 145.98,83.29 147.45,81.81 147.45,79.2 150.4,76.25 152.97,76.25 157.76,71.46 157.76,69.71 172.35,55.11 175.81,55.11 176.59,55.88 198.42,55.88 199.88,54.43 204.07,54.43 204.32,54.18 206.8,54.18 207.34,53.64 207.34,52.89 208.25,51.98 v1(209.02,51.98)
  L3 w0.089: v1(136.89,86.29) 136.89,86.41 135.58,87.72 127.45,87.72 127.39,87.66 121.77,87.66 120.78,88.65 119.81,88.65 119.14,89.32 116.85,89.32 v1(116.19,88.67)
  L4 w0.089: v1(132.57,89.88) 133.72,89.88 136.89,86.71 v1(136.89,86.29)
  BOTTOM w0.089: CPU1.CC29 116.01,88.67 116.19,88.67 v1(116.19,88.67) ; R2062.2 137.87,85.65 137.42,85.19 136.45,85.19 136.32,85.32 v2(136.32,85.37) 136.32,85.73 v1(136.89,86.29) ; LCD1.12 217.34,51.55 217.17,51.38 212.96,51.38 212.62,51.72 209.28,51.72 v1(209.02,51.98)
TOUCH_PAD_INTR#: length 6.4
  BOTTOM w0.076: CPU1.CB34 114.97,85.22 114.97,84.54 114.94,84.46 114.94,84.16 114.96,84.1 114.96,83.84 114.68,83.56 114.68,82.84
  BOTTOM w0.089: 114.68,82.84 114.68,82.75 115.29,82.14 115.29,80.38 R319.2
TOUCH_PANEL_INTR#: length 149.3
  TOP w0.089: v1(224.27,66.41) 224.77,65.91 R5533.1
  L3 w0.089: v1(216.83,66.38) 216.25,66.95 213.55,66.95 213.16,66.56 213.16,65.89 212.88,65.61 209.81,65.61 209.44,65.98 189.97,65.98 187.16,63.16 184.71,63.16 180.71,67.16 178.38,67.16 177.49,68.05 175.61,68.05 175.58,68.08 175.47,68.19 175.4,68.19 175.3,68.3 174.42,69.18 173.73,69.18 171.38,71.53 171.38,72.59 171.34,72.63 171.34,72.63 162.34,81.63 162.34,82.64 161.75,83.23 161.75,84.55 161.31,84.98 161.31,86.38 161,86.7 161,86.7 160.37,87.32 160.37,87.33 142.67,105.02 142.67,107.29 141.87,108.09 141.87,110.29 140.58,111.58 140.58,115.45 138.63,117.39 136.93,117.39 v1(136.35,116.82)
  L4 w0.089: v1(224.27,66.41) 222.04,68.63 220.17,68.63 218.41,66.87 217.32,66.87 v1(216.83,66.38)
  BOTTOM w0.089: CPU1.CN3 121.48,105.02 122.3,105.02 122.47,105.19 124.24,105.19 124.28,105.14 130.31,105.14 132.14,106.97 132.14,111.95 135.84,115.65 v2(135.84,116) 136.16,116.32 136.59,116.32 137.02,116.75 R5544.2 136.44,116.9 v1(136.35,116.82)
TOUCH_PANEL_PD#: length 167.5
  TOP w0.102: v1(205.87,37.26) 205.87,37.31 205.91,37.35 205.91,38.22 AFTP5503.1 205.81,38.32 205.81,39.07 205.47,39.41 205.47,40.93 204.14,42.26 204.14,42.58 202.52,44.2 202.19,44.2 202.16,44.23 199.48,44.23 199.06,43.82 198.71,43.82 198.25,44.27 v1(198.25,44.53)
  L2SGND w0.102: v1(198.25,44.53) 198.25,44.35 198.65,43.95 199.06,43.95 200.26,45.15 201.89,45.15 202.31,45.57 202.31,46.1 202.82,46.61 204.63,46.61 204.99,46.97 205.46,46.97 206.2,46.23 206.72,46.23 207.1,46.6 207.1,47.31 208.27,48.48 208.27,49.17 207.99,49.46 207.99,51.36 206.79,52.55 204.81,52.55 203.72,53.65 199.4,53.65 197.99,55.06 176.86,55.06 176.14,54.33 172.02,54.33 156.98,69.38 156.98,71.08 156.1,71.96 155.81,71.96 155.52,71.67 151.96,71.67 151.14,72.49 v1(150.65,72.49)
  L4 w0.102: v1(219.81,50.65) 220.3,50.65 220.63,50.32 220.63,49.46 219.15,47.98 219.15,44.07 217.4,42.31 216.32,42.31 213.84,39.83 213.63,39.83 211.77,37.98 209.28,37.98 208.06,36.76 206.37,36.76 v1(205.87,37.26)
  BOTTOM w0.102: LCD1.14 219.65,50.55 219.75,50.65 v1(219.81,50.65) ; CPU1.CC35 116.01,85.12 115.69,84.8 115.69,82.54 116.16,82.06 116.16,81.06 116.05,80.94 116.05,80.19 117.03,79.2 117.4,79.2 118.45,78.15 118.45,77.78 119.37,76.86 120.3,76.86 125.89,71.27 149.42,71.27 149.45,71.29 150.65,72.48 v1(150.65,72.49)
TOUCH_REPORT_SW: length 99.2
  TOP w0.102: v1(137.24,36.42) 136.79,35.97 AFTP5514.1
  L3 w0.102: v1(137.24,36.42) 137.75,36.93 146.03,36.93 149.98,32.98 155.63,32.98 160.74,38.08 164.97,38.08 165.62,37.43 167.6,37.43 168.23,38.06 171.78,38.06 172.37,37.47 182.14,37.47 183.51,36.1 186.19,36.1 189.49,39.41 193.09,39.41 193.32,39.18 196.52,39.18 196.71,38.99 200.49,38.99 200.63,39.13 200.64,39.13 201.4,39.89 206.92,39.89 207.09,40.06 209.77,40.06 211.72,42.01 214.09,42.01 215.84,43.76 216.05,43.76 216.67,44.38 v1(218.01,44.38)
  BOTTOM w0.102: v1(137.24,36.42) 137.24,36.66 136.64,37.26 133.35,37.26 131.35,39.26 D2402.A ; LCD1.26 218.18,44.55 v1(218.01,44.38)
TOUCH_USB20_N: length 142.5
  TOP w0.127: v2(210.54,46.38) v1(209.69,46.83)
  L3 w0.114: v1(209.69,46.83) 209.69,46.83 209.72,46.86 209.9,46.86 212.33,49.29 212.33,50.25 212.92,50.84 212.92,51.33 211.94,52.31 211.94,54.56 212.3,54.92 212.3,55.98 211.97,56.31 211.62,56.66 211.32,56.66 209.4,58.58 209.4,58.77 208.53,59.63 204.3,59.63 203.96,59.98 191.68,59.98 189.49,57.79 181.42,57.79 180.91,58.31 178.54,58.31 167.72,69.13 167.72,70.99 157.14,81.56 157.14,84.96 135.36,106.74 135.36,112.18 134.9,112.64 128.76,112.64 124.11,107.99 124.11,106.95 123.64,106.48 123.11,106.48 122.37,105.74 120.77,105.74 v1(119.18,104.15)
  BOTTOM w0.127: R5512.1 210.43,46.62 210.39,46.66 209.85,46.66 v1(209.69,46.83) ; CPU1.CH5 118.94,103.92 v1(119.18,104.15)
TOUCH_USB20_N_R: length 10.7
  BOTTOM w0.127: LCD1.28 218.3,43.55 218.21,43.65 217.78,43.65 217.23,44.19 217.23,44.91 216.21,45.92 216.21,46.74 215.83,47.12 215.55,47.12 ED5502.3 215.09,47.12 214.71,47.12 214.02,46.43 212.42,46.43 211.94,46.9 211.73,46.9 211.51,46.66 211.47,46.62 R5512.2
TOUCH_USB20_P: length 142.3
  TOP w0.127: v2(210.37,47.63) v1(209.69,47.48)
  L3 w0.114: v1(119.18,103.51) 119.33,103.35 119.51,103.35 119.64,103.48 119.64,104.29 120.86,105.51 122.46,105.51 123.2,106.25 123.73,106.25 124.34,106.85 124.34,107.89 128.86,112.41 134.81,112.41 135.13,112.09 135.13,106.64 156.91,84.86 156.91,81.47 167.49,70.89 167.49,69.03 178.44,58.08 180.81,58.08 181.33,57.56 189.59,57.56 191.77,59.75 203.86,59.75 204.2,59.41 208.44,59.41 209.17,58.67 209.17,58.48 211.23,56.43 211.53,56.43 211.88,56.08 212.07,55.88 212.07,55.01 211.71,54.65 211.71,52.22 212.69,51.24 212.69,50.93 212.1,50.34 212.1,49.38 210.11,47.39 209.98,47.39 209.94,47.43 209.76,47.43 209.71,47.48 v1(209.69,47.48)
  BOTTOM w0.127: v1(209.69,47.48) 209.71,47.48 209.84,47.35 210.39,47.35 210.45,47.4 R5511.1 ; CPU1.CH6 118.73,103.44 118.86,103.56 119.11,103.56 119.17,103.51 v1(119.18,103.51)
TOUCH_USB20_P_R: length 10.7
  BOTTOM w0.127: R5511.2 211.46,47.4 211.72,47.14 212.04,47.14 212.5,46.69 212.68,46.69 ED5502.4 213.1,46.67 213.92,46.67 214.61,47.36 215.93,47.36 216.45,46.84 216.45,46.02 217.47,45.01 217.47,44.29 217.88,43.89 218.14,43.89 218.31,44.05 LCD1.27
TP_EN#: length 160.8
  TOP w0.089: U2401.49 31.55,59.25 33.03,60.73 33.15,60.73 33.4,60.98 33.4,61.33 33.15,61.58 32.79,61.58 31.63,62.73 31.63,64.56 30.75,65.44 29.27,65.44 26.6,68.1 v1(26.15,68.1) ; R6504.1 98.35,33.02 v2(98.35,35.18) 98.35,36.87 100.26,38.79 100.55,38.79 101.14,39.37 102.37,39.37 102.7,39.71 v1(103.51,39.71) 103.64,39.58 103.64,38.1 103.2,37.67 103.2,35.69 102.9,35.38 101.15,35.38 100.28,34.51 RN2406.1
  L3 w0.089: v1(103.51,39.71) 103.54,39.68 103.54,38.6 102.76,37.82 101.88,37.82 101.85,37.82 100.27,36.24 99.73,36.24 99.73,36.24 93.14,36.24 93.02,36.12 78.13,36.12 74.57,32.56 64.89,32.56 63.97,31.64 63.19,31.64 62.8,31.25 41.79,31.25 40.96,30.42 36.59,30.42 35.79,31.22 33.26,31.22 32.4,30.36 30.44,30.36 30.11,30.03 25.53,30.03 23.85,31.7 23.85,35.33 23.5,35.68 23.37,35.68 22.81,35.68 22.67,35.83 22.67,37.1 23.95,38.38 23.95,39.81 24.03,39.88 24.03,40.76 22.2,42.59 22.2,43.83 20.99,45.04 20.99,49.82 21.87,50.7 21.87,51.99 21.28,52.59 21.28,56.05 21.12,56.2 21.12,57.56 20.85,57.83 20.85,59.64 21.59,60.38 21.59,61.01 23.98,63.4 23.98,65.93 v1(26.15,68.1)
TP_ON#_GATE: length 9.7
  TOP w0.102: v2(97.49,33.91) 97.49,33.02 R6504.2 97.5,33.01 97.5,32.03 97.49,32.02 97.49,32.01 96.9,31.42 C6503.2 96.9,28.59 v1(96.93,28.56)
  BOTTOM w0.102: Q6502.G 95.77,27.81 96.52,28.56 v1(96.93,28.56) 96.97,28.56 97.72,27.81 Q6503.G
TP_VDD: length 10.5
  BOTTOM w0.305: 102.84,34.69 103.2,35.05 TP1.8 103.2,36.68 R6511.2
  BOTTOM w0.381: 102.84,34.69 102.84,33.54 103.64,32.74 106.38,32.74 107.27,31.85 107.27,30.06 107.33,30.01 v1(107.33,29.94)
  vias: v1(97.67,28.96)
TP_WAKE_KBC#: length 298.3
  TOP w0.089: v1(16.13,59.95) 16.13,59.95 16.54,59.54 17.17,59.54 18.32,58.39 18.32,57.9 18.42,57.8 19.25,57.8 20.72,59.27 24.38,59.27 24.97,58.67 U2401.33 ; v1(105.91,36.69) 105.91,36.51 106.57,35.85 AFTP6525.1
  L3 w0.089: v1(105.91,36.69) 105.65,36.69 102.42,33.45 94.41,33.45 94.18,33.22 92.66,33.22 91.91,32.47 90.75,32.47 90.26,31.98 90.17,31.98 89.57,31.38 83.32,31.38 82.81,31.9 78.33,31.9 74.34,27.91 56.31,27.91 55.86,27.46 40.19,27.46 37.83,25.1 23.77,25.1 18.13,30.74 18.13,40.34 17.62,40.85 17.62,42.82 16.79,43.65 16.79,43.85 16.79,44.13 16.79,46.39 16.79,46.39 16.79,46.72 16.79,51.68 17.25,52.14 17.25,52.26 17.38,52.4 17.38,57.23 17.38,57.23 17.38,57.38 16.79,57.98 16.79,59.29 16.13,59.95 v1(16.13,59.95) ; v1(105.69,43.71) 106.02,43.71 106.05,43.74 107.02,43.74 108.32,45.04 121.55,45.04 123.72,42.87 127.47,42.87 130.56,39.78 149.47,39.78 151.55,41.87 168.56,41.87 169.27,41.16 169.96,41.16 v1(170.41,41.61)
  L4 w0.089: v1(170.41,41.61) 170.41,42.39 170.13,42.68 170.13,50.1 155.41,64.82 155.41,66.1 155.4,66.1 155.4,66.18 154.77,66.81 154.77,67.26 154.77,67.58 151.22,71.13 v1(151.22,71.74)
  BOTTOM w0.089: v1(105.91,36.69) 103.98,36.69 103.08,37.59 R6511.1 ; v1(105.91,36.69) 105.99,36.69 106.42,37.13 106.89,37.13 107.2,36.82 TP1.4 ; v1(105.91,36.69) 105.91,37.53 105.79,37.64 105.79,38.55 106.47,39.23 106.47,41.23 105.69,42.01 v1(105.69,43.71) ; R319.1 116.65,79.02 117.32,79.02 118.27,78.07 118.27,77.4 119.01,76.66 120.22,76.66 125.81,71.07 150.13,71.07 150.15,71.1 150.8,71.74 v1(151.22,71.74)
TPAN_VDD_EN_R: length 35.7
  TOP w0.102: v1(202.7,32.61) 202.7,32.82 v2(202.21,33.3) 201.77,33.74 R5563.2 201.23,33.74 R5564.1 ; R5562.2 210.9,47.83 210.9,45.61 210.35,45.06 v1(210.29,45.06) 210.85,44.5 210.85,43.1 210.64,42.89 210.64,40.19 210.86,39.97 211.51,39.32 213.97,39.32 214.99,38.3 214.99,36.42 v1(215.62,35.79)
  L3 w0.102: v1(215.62,35.79) 215.57,35.84 213.69,35.84 212.63,36.9 211.3,36.9 211.08,36.9 211.05,36.9 210.85,36.9 210.07,36.9 209.84,36.9 206.39,33.45 203.53,33.45 v1(202.7,32.61)
  BOTTOM w0.102: v1(210.29,45.06) 210.38,45.06 210.66,44.79 U5502.5
TPCLK_C: length 10.6
  TOP w0.114: v1(103.97,34.01) 103.89,34.09 AFTP6530.1 102.62,33.71 103.18,33.14 RN6502.4
  BOTTOM w0.14: v1(103.97,34.01) 104.11,33.87 105.71,33.87 105.93,34.09 109.55,34.09 110.18,34.72 110.18,34.95 110.2,34.97 TP1.1
TPDATA_C: length 9.8
  TOP w0.14: RN6502.3 105.18,32.64 AFTP6524.1 105.24,33.66 v1(104.38,34.51)
  BOTTOM w0.14: v1(104.38,34.51) 104.75,34.15 105.59,34.15 105.82,34.37 108.9,34.37 109.2,34.67 TP1.2
TPM_GPIO0: length 4.1
  BOTTOM w0.102: R9121.1 146.33,140.26 v2(146.61,140.54) 146.79,140.72 147.53,140.72 147.78,140.97 147.78,141.79 147.98,142 U9103.29
TPM_GPIO1: length 1.2
  BOTTOM w0.102: U9103.30 147.32,142.5 TP9102.1
TPM_GPIO4: length 2.3
  BOTTOM w0.102: R9118.1 154.36,141.73 v2(154.28,141.81) 153.97,141.5 U9103.13
TPM_ID: length 21.2
  BOTTOM w0.102: R1910.2 137.77,93.57 137.77,92.65 R1911.1 136.95,92.15 136.48,91.67 136.48,91.49 135.96,90.97 135.03,90.97 v2(134.43,90.37) 133.46,89.4 127.02,89.4 126.16,90.26 124.77,90.26 124.65,90.39 124.24,90.39 123.44,91.19 120.96,91.19 120.24,91.19 CPU1.CK25
TPM_SPI_IRQ#: length 26.2
  TOP w0.102: v1(133.96,86.86) 134.33,87.23 136.5,87.23 v2(136.81,86.92) 137.01,87.12 137.65,87.12 138.01,86.77 R9151.2
  L4 w0.089: v1(117.1,94.01) 117.1,94.09 117.38,94.37 117.99,94.37 118.16,94.19 118.16,93.49 118.57,93.09 118.57,92.56 118.73,92.4 120.11,92.4 121.76,90.75 123.81,90.75 124.28,90.27 124.61,90.27
  L4 w0.102: v1(133.96,86.86) 133.08,87.74 131.22,87.74 128.97,89.99 126.03,89.99 125.97,90.06 124.82,90.06 124.61,90.27
  BOTTOM w0.102: CPU1.CF20 117.37,94.35 117.1,94.09 v1(117.1,94.01)
TPS2544_FAULT#: length 2.9
  TOP w0.102: U3601.13 23.08,50.94 23.42,50.6 23.42,50.13 R3607.1 23.86,49.11 v2(23.55,48.79)
TPS70933_EN: length 3.9
  TOP w0.102: U7203.4 49.22,129.77 R7218.1 R7217.2 47.81,129.67 v2(46.94,129.67) 46.89,129.67 46.39,130.17 Q7201.D
TPS70933_EN_G: length 3.9
  TOP w0.102: R7216.2 44.28,133.1 45.16,132.21 45.75,132.21 46.36,132.82 C7215.2 46.49,132.81 Q7201.G
TS#_DIMM0_1: length 4.5
  TOP w0.102: v1(64.04,45.52) 63.98,45.58 R1215.2 63.33,46.31 v2(63.48,46.46)
  BOTTOM w0.102: v1(64.04,45.52) 63.96,45.52 63.58,45.13 DM1.134
TS#_DIMM1_1: length 4.4
  TOP w0.102: v2(138.71,46.08) 138.79,46.08 139.35,45.52 R1312.2 139.94,45.52 v1(140.19,45.26)
  BOTTOM w0.102: v1(140.19,45.26) 139.78,44.84 DM2.134
TS_INT#: length 27.7
  TOP w0.102: v1(220.22,51.16) 223.78,51.16 v1(224.41,50.52) ; R5533.2 225.66,65.03 225.21,65.47 225.21,66.89 225.58,67.26 v2(225.58,67.31) 225.58,67.49 v1(225.06,68.01)
  L3 w0.102: v1(225.06,68.01) 225.06,62.06 223.98,60.99 223.98,50.95 v1(224.41,50.52)
  BOTTOM w0.102: v1(220.22,51.16) 219.66,51.16 219.56,51.05 LCD1.13
TYPEC_DCIN1_EN#: length 84.7
  TOP w0.102: v1(29.69,71.73) 29.69,71.49 31.16,70.03 31.16,67.13 35.52,62.77 35.52,61.23 37.15,59.6 U2401.63 ; v1(33.28,102.33) 33.28,102.55 R7428.1 32.31,103.52 v2(32.31,103.95) 32.46,104.1 32.46,107.21 31.72,107.95 30.74,107.95 30.42,108.27 Q7406.2 30.42,109.54 30.5,109.63 R7431.1 30.05,111.18 Q7407.2
  L3 w0.102: v1(28.85,74.93) 29.45,74.33 35.37,74.33 36.43,75.39 38.26,75.39 40.35,77.48 40.35,92.38 38.14,94.59 35.59,94.59 35.26,94.26 29.75,94.26 28.86,95.15 28.57,95.15 28.54,95.18 28.35,95.18 28.1,95.43 28.1,97.14 v1(33.28,102.33)
  BOTTOM w0.102: v1(29.69,71.73) 29.69,71.64 29.56,71.52 28.58,71.52 27.88,71.52 27.72,71.68 27.72,73.7 28.85,74.83 v1(28.85,74.93)
TYPEC_DP_AUXN: length 42.2
  TOP w0.127: U5802.27 55.83,118.43 56.75,117.51 56.96,117.51 v1(57.25,117.81) ; v1(28.71,113.31) 28.12,113.31 R7104.1
  BOTTOM w0.127: 57.08,116.46 57.08,115.1 56.6,114.61 56.6,113.2 55.52,112.12 51.97,112.12 51.43,112.66 47.78,112.66 46.65,111.53 46.65,109.52 46.34,109.21 46.31,109.21 46.31,109.21 45.95,109.21 45.94,109.21 43.14,109.21 41.13,111.23 39.84,111.23 38.08,112.98 37.41,112.98 36.34,111.92 34.73,111.92 33.41,113.23 29.88,113.23 29.73,113.08 28.93,113.08 v1(28.71,113.31) ; 57.08,116.46 57.08,117.63 v1(57.25,117.81) ; 57.08,116.46 v2(56.95,116.46)
TYPEC_DP_AUXP: length 42.2
  TOP w0.127: v1(28.71,112.67) 28.19,112.67 R7103.1 ; v1(57.55,117.18) 57.46,117.27 56.65,117.27 55.89,118.03 U5802.26
  BOTTOM w0.127: 52.43,111.88 55.62,111.88 56.84,113.1 56.84,114.51 57.32,115 57.32,116.96 v1(57.55,117.18) ; 52.43,111.88 51.87,111.88 51.33,112.42 47.88,112.42 46.89,111.43 46.89,109.42 46.44,108.97 46.41,108.97 45.85,108.97 45.84,108.97 43.04,108.97 41.03,110.98 39.74,110.98 37.98,112.74 37.51,112.74 36.44,111.67 34.63,111.67 33.31,112.99 29.98,112.99 29.83,112.84 28.87,112.84 v1(28.71,112.67) ; 52.43,111.88 v2(52.43,111.74)
TYPEC_DP_N0: length 37.3
  TOP w0.127: C7113.1 28.41,103.76 28.46,103.81 28.48,103.81 v1(28.92,104.25) ; U5802.49 47.3,120.74 47.23,120.81 47.23,121.76 46.92,122.07 46.67,122.07 v1(46.47,122.28)
  L4 w0.114: v1(46.47,122.28) 45.76,122.28 45.04,121.57 40.04,121.57 39.41,120.93 38.32,120.93 37.59,121.67 34.88,121.67 34.21,121 34.21,112.26 32.79,110.84 32.79,107.63 32.54,107.38 32.54,106.14 30.54,104.14 29.03,104.14 v1(28.92,104.25)
TYPEC_DP_N0_C: length 0.7
  TOP w0.127: C7113.2 26.91,103.74 R7178.1
TYPEC_DP_N1: length 42.6
  TOP w0.127: U5802.46 48.5,120.76 48.58,120.84 48.58,122.07 48.07,122.58 47.86,122.58 47.63,122.81 v1(47.63,122.82) ; v1(28.6,105.59) 28.32,105.31 C7107.1
  L4 w0.114: v1(28.6,105.59) 30.07,105.59 30.69,106.21 30.69,115.68 30.02,116.36 30.02,121.27 30.66,121.91 30.66,122.75 31.43,123.52 36.3,123.52 36.96,122.86 40.04,122.86 40.62,123.45 42.73,123.45 43.36,122.81 45.07,122.81 45.93,123.67 46.69,123.67 47.16,123.2 47.16,122.82 47.29,122.7 47.52,122.7 v1(47.63,122.82)
TYPEC_DP_N1_C: length 0.7
  TOP w0.127: C7107.2 26.92,105.32 R7180.1
TYPEC_DP_N2: length 44.1
  TOP w0.127: 48.94,123.64 49.23,123.36 49.23,120.65 49.3,120.58 U5802.44 ; 48.94,123.64 48.63,123.95 47.85,123.95 v1(47.65,124.16) ; 48.94,123.64 v2(49.04,123.74) ; v1(28.9,107.11) 28.69,106.91 C7108.1
  L4 w0.114: v1(28.9,107.11) 29.05,106.96 29.63,106.96 30.08,107.4 30.08,114.35 29.41,115.02 29.41,120.72 29.16,120.97 29.16,123.2 30.08,124.13 36.96,124.13 37.62,123.47 39.79,123.47 40.37,124.05 42.68,124.05 43.44,124.82 46.46,124.82 47.26,124.01 47.5,124.01 v1(47.65,124.16)
TYPEC_DP_N2_C: length 0.7
  TOP w0.127: C7108.2 26.88,106.89 R7182.1
TYPEC_DP_N3: length 45.3
  TOP w0.127: C7110.1 27.72,108.25 27.95,108.25 v1(28.21,108.51) ; U5802.41 50.5,122.31 50,122.81 49.89,122.81 v1(49.7,123)
  L4 w0.114: v1(49.7,123) 49.48,122.78 49.29,122.78 48.85,123.23 48.85,123.42 48.75,123.52 48.75,124.2 48.8,124.25 48.8,124.97 48.26,125.5 43.27,125.5 42.43,124.66 40.12,124.66 39.53,124.08 38.1,124.08 37.44,124.74 29.83,124.74 28.47,123.38 28.47,120.69 28.8,120.36 28.8,114.7 29.42,114.08 29.42,108.91 28.99,108.48 28.24,108.48 v1(28.21,108.51)
TYPEC_DP_N3_C: length 0.7
  TOP w0.127: R7184.1 C7110.2
TYPEC_DP_P0: length 37.2
  TOP w0.127: v1(46.47,121.64) 46.66,121.83 46.82,121.83 46.99,121.66 46.99,120.84 46.9,120.75 U5802.50 ; C7112.1 27.99,103 28.56,103.57 v1(28.92,103.57)
  L4 w0.114: v1(28.92,103.57) 29.27,103.91 30.63,103.91 32.77,106.05 32.77,107.28 33.02,107.54 33.02,110.75 34.44,112.16 34.44,120.9 34.98,121.44 37.49,121.44 38.23,120.7 39.5,120.7 40.14,121.34 45.14,121.34 45.85,122.05 46.06,122.05 v1(46.47,121.64)
TYPEC_DP_P0_C: length 0.8
  TOP w0.127: R7177.1 26.41,103.13 26.79,103.13 C7112.2
TYPEC_DP_P1: length 42.5
  TOP w0.127: v1(28.6,104.96) 28.19,104.55 C7114.1 ; v1(47.63,122.18) 47.79,122.34 47.97,122.34 48.34,121.97 48.34,120.94 48.1,120.7 U5802.47
  L4 w0.114: v1(28.6,104.96) 29,105.36 30.17,105.36 30.92,106.11 30.92,115.78 30.25,116.45 30.25,121.18 30.89,121.82 30.89,122.65 31.53,123.29 36.21,123.29 36.87,122.63 40.14,122.63 40.72,123.22 42.63,123.22 43.27,122.58 45.16,122.58 46.03,123.45 46.59,123.45 46.93,123.1 46.93,122.73 47.2,122.47 47.36,122.47 47.63,122.2 v1(47.63,122.18)
TYPEC_DP_P1_C: length 0.8
  TOP w0.127: C7114.2 26.79,104.68 26.41,104.68 R7179.1
TYPEC_DP_P2: length 44.1
  TOP w0.127: v2(48.82,122.53) 48.99,122.53 ; 48.99,122.53 48.99,123.26 48.53,123.71 47.84,123.71 v1(47.65,123.52) ; 48.99,122.53 48.99,120.65 48.9,120.57 U5802.45 ; v1(28.9,106.48) 28.9,106.49 28.72,106.67 28.34,106.67 C7109.1
  L4 w0.114: v1(28.9,106.48) 29.15,106.73 29.73,106.73 30.31,107.31 30.31,114.44 29.64,115.11 29.64,120.81 29.38,121.06 29.38,123.11 30.18,123.9 36.87,123.9 37.53,123.24 39.88,123.24 40.47,123.83 42.78,123.83 43.54,124.59 46.37,124.59 47.17,123.79 47.38,123.79 v1(47.65,123.52)
TYPEC_DP_P2_C: length 0.8
  TOP w0.127: R7181.1 26.4,106.27 26.77,106.27 C7109.2
TYPEC_DP_P3: length 45.2
  TOP w0.127: v1(28.21,107.88) 28.07,108.01 27.65,108.01 27.51,107.87 C7111.1 ; v1(49.7,122.36) 49.83,122.49 49.98,122.49 50.26,122.21 50.26,120.81 50.1,120.65 U5802.42
  L4 w0.114: v1(28.21,107.88) 28.59,108.25 29.08,108.25 29.64,108.81 29.64,114.18 29.03,114.79 29.03,120.46 28.7,120.78 28.7,123.29 29.93,124.51 37.35,124.51 38.01,123.85 39.63,123.85 40.21,124.44 42.52,124.44 43.36,125.27 48.17,125.27 48.57,124.87 48.57,124.35 48.52,124.3 48.52,123.42 48.62,123.32 48.62,123.14 49.2,122.56 49.52,122.56 49.7,122.38 v1(49.7,122.36)
TYPEC_DP_P3_C: length 0.8
  TOP w0.127: R7183.1 26.09,107.82 26.44,107.82 C7111.2
TYPEC_SMBCLK: length 90.3
  TOP w0.114: v2(32.86,111.44) 32.79,111.44 32.66,111.57 32.66,113.48 33.39,114.21 33.39,114.6 RN2413.4
  TOP w0.14: v1(37.21,70.41) 37.62,70.83 38.03,70.83 38.36,70.49 U2401.91 ; v2(32.86,111.44) 33.21,111.44 33.37,111.61 Q2417.1 33.75,110.62 v1(33.8,110.57) ; U7102.3 33.04,116.65 34.04,115.65 RN2413.4
  L4 w0.114: 35.77,108.84 35.77,107.25 36.91,106.11 ; v1(33.8,110.57) 33.81,110.57 33.81,110.81 34.19,111.18 35.23,111.18 35.49,110.93 35.49,110.24
  L4 w0.127: 36.91,106.11 36.91,97.74 36.92,97.73 36.92,94.35 38.98,92.29 38.98,80.94 38.01,79.98 38.01,78.49 38.47,78.03 38.47,77.15 37.46,76.14 28.13,76.14 27.34,76.93 24.22,76.93 22.43,75.13 21.62,75.13 21.39,74.91 21.39,74.3 20.41,73.32 19.8,73.32 v1(19.67,73.32) ; 35.77,108.84 35.49,109.12 35.49,110.24
  BOTTOM w0.14: v1(19.67,73.32) 19.76,73.23 22.34,73.23 22.59,72.99 25.06,72.99 25.61,73.54 26.69,73.54 27.27,72.95 27.27,71.49 27.72,71.04 29.87,71.04 29.95,70.97 32.01,70.97 32.08,71.04 35.57,71.04 35.64,71.11 36.57,71.11 37.21,70.48 v1(37.21,70.41)
TYPEC_SMBDA: length 88.4
  TOP w0.114: Q2417.4 35.05,113.84 35.18,113.97 35.18,114.99 34.92,115.25 RN2413.3 34.71,115.67 34.58,115.8 ; 33.44,116.7 33.44,116.66 34.29,115.8
  TOP w0.127: Q2417.4 35.05,112.95 v1(35.49,112.51) ; 34.58,115.8 34.29,115.8 ; 33.44,116.7 U7102.4
  TOP w0.14: v1(19.41,72.74) 19.31,72.74 19.03,73.03 v2(18.88,73.03) ; v1(36.57,70.47) 36.57,70.37 37.25,69.69 U2401.89
  L4 w0.127: v1(35.49,112.51) 35.75,112.25 35.75,109.41 36.12,109.04 36.12,107.32 37.17,106.27 37.17,94.48 39.23,92.42 39.23,80.81 38.37,79.95 38.37,78.56 38.76,78.16 38.76,77.07 37.58,75.88 25.9,75.88 25.12,76.67 24.35,76.67 22.42,74.75 22.42,74.29 22.23,74.09 21.61,74.09 20.48,72.96 20.15,72.96 19.93,72.74 v1(19.41,72.74)
  BOTTOM w0.14: v1(36.57,70.47) 36.21,70.84 35.76,70.84 35.69,70.76 32.2,70.76 32.12,70.69 29.83,70.69 29.76,70.76 27.6,70.76 26.99,71.37 26.99,72.84 26.57,73.26 25.73,73.26 25.17,72.71 22.47,72.71 22.23,72.95 19.94,72.95 19.73,72.74 v1(19.41,72.74)
U9101_2_GND: length 2.1
  BOTTOM w0.254: R9101.2 149.47,145.23 U9103.2
  BOTTOM w0.305: R9101.2 150.07,145.26 v2(150.33,145.52)
UART_2_CRXD_DTXD: length 140
  TOP w0.14: v2(152.66,74.09) v1(153.16,74.45)
  L4 w0.127: v1(126.88,99.44) 126.91,99.47 127.01,99.47 127.5,99.96 127.81,99.96 129.09,101.25 133,101.25 133.28,100.97 133.28,100.63 133.25,100.61 133.25,100.59 133,100.33 133,99.96 133.37,99.59 133.53,99.42 134.87,99.42 134.99,99.29 136.22,98.07 136.22,97.03 136.22,96.86 136.22,96.6 139.4,93.42 139.4,92.77 144.13,88.04 144.31,88.04 144.66,87.69 144.67,87.69 145.04,87.32 145.22,87.32 148.29,84.25 148.29,83.14 149.22,82.21 149.22,79.69 149.8,79.11 149.8,78.7 149.8,77.19 152.53,74.45 v1(153.16,74.45)
  BOTTOM w0.076: CPU1.CR12 122.76,99.77 122.9,99.79 122.9,99.79 123.49,99.79 123.65,99.63 124.18,99.63 124.5,99.95 125.84,99.95 R2048.2
  BOTTOM w0.114: v1(126.88,99.44) 126.79,99.44 126.76,99.47 126.67,99.47 126.07,100.07 R2048.2
  BOTTOM w0.14: R6803.1 76.28,72.37 77.1,71.55 123.27,71.55 125.18,69.64 152.02,69.64 152.36,69.3 153.16,69.3 154.74,70.87 156.02,70.87 156.28,71.14 156.28,72.35 154.18,74.45 v1(153.16,74.45)
UART_2_CRXD_DTXD_CON: length 3
  BOTTOM w0.14: DBG1.14 70.13,71.63 70.87,72.37 R6803.2
UART_2_CTXD_DRXD: length 141.3
  TOP w0.14: v2(153.53,73.24) v1(153.62,73.98)
  L4 w0.127: v1(126.28,99.23) 126.37,99.13 126.37,99.11 126.5,98.99 127.19,98.99 129.07,100.86 130.79,100.86 131.91,99.75 132.85,99.75 132.85,99.74 133.11,99.48 133.11,99.48 133.43,99.16 134.76,99.16 135.96,97.96 135.96,97.13 135.96,96.97 135.96,96.8 135.96,96.5 139.15,93.31 139.15,92.82 139.15,92.82 139.15,92.66 144.03,87.78 144.2,87.78 144.55,87.43 144.57,87.43 144.94,87.06 145.12,87.06 148.03,84.15 148.03,83.03 148.96,82.1 148.96,79.59 149.55,79 149.55,78.81 149.55,77.08 152.64,73.98 v1(153.62,73.98)
  BOTTOM w0.076: v1(126.28,99.23) 126.28,99.28 125.87,99.68 125.7,99.68 125.6,99.79 124.6,99.79 124.28,99.47 123.58,99.47 123.42,99.63 122.96,99.63 122.9,99.59 122.78,99.5 122.75,99.48 122.7,99.44 122.44,99.44 122.16,99.59 122.12,99.59 122.02,99.65 CPU1.CP12
  BOTTOM w0.14: R2049.2 128.07,100.03 127.06,99.01 126.5,99.01 126.3,99.21 126.3,99.21 v1(126.28,99.23) ; v1(153.62,73.98) 154.25,73.98 155.77,72.46 155.77,71.93 155.54,71.69 155.16,71.69 153.05,69.58 152.48,69.58 152.13,69.92 125.29,69.92 123.39,71.83 77.3,71.83 75.94,73.18 R6802.1
UART_2_CTXD_DRXD_CON: length 4.5
  BOTTOM w0.14: DBG1.13 69.13,71.96 70.35,73.18 R6802.2
USB1_SBU1: length 36.2
  TOP w0.127: U7101.27 21,109.48 20.42,110.05 16.68,110.05 R7331.2 16.51,110.26 16.29,110.48 15.63,110.48 15.28,110.83 15.28,113.17 16.01,113.9 16.01,118.06 16.2,118.25 ; AFTP7101.1 16.2,118.25 ; 16.2,118.25 17.4,119.45 17.4,120.79 17.28,120.91 16.91,120.91 16.5,120.5 ED7307.2 16.47,120.19 v1(15.77,120.89)
  L4 w0.114: v1(9.15,124.26) 9.15,123.62 8.45,122.92 8.05,122.92 7.93,123.05 7.93,124.15 8.5,124.72 9.35,124.72 11.61,122.46 11.61,121.52 12.43,120.7 14.19,120.7 14.68,121.18 15.48,121.18 v1(15.77,120.89)
  BOTTOM w0.114: v1(9.15,124.26) 8.26,124.26 8.07,124.45 JUSB1.A8
