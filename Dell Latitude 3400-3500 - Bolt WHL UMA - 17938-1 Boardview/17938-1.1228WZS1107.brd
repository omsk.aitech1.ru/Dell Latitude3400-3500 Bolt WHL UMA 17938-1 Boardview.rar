# Allegro board 17938-1.1228WZS1107.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HDMI_DDI_TX_CMC_N0: length 4.8
  BOTTOM w0.127: C5781.2 23.81,98.82 22.85,98.82 R5775.1 22.24,98.74 21.65,98.74 21.11,98.21 21.11,98.02 20.98,97.89 20.8,97.89 20.64,98.04 EL5703.1
HDMI_DDI_TX_CMC_N1: length 3.7
  BOTTOM w0.127: C5779.2 22.95,96.71 21.96,96.71 R5773.1 21.48,96.56 21.14,96.56 20.91,96.34 20.69,96.34 20.53,96.49 EL5702.1
HDMI_DDI_TX_CMC_N2: length 4.5
  BOTTOM w0.127: EL5701.1 20.5,94.94 20.68,94.77 21.01,94.77 21.38,94.39 22.31,94.39 R5705.1 22.71,94.59 23.6,94.59 C5777.2
HDMI_DDI_TX_CMC_N3: length 6.6
  BOTTOM w0.127: v2(20.8,100.52) 20.97,100.52 ; 20.97,100.52 20.97,100.61 21.24,100.88 21.4,100.88 C5724.2 22.04,101.02 23.1,101.02 R5777.1 23.75,100.97 24.46,100.97 C5783.2 ; 20.97,100.52 20.97,99.59 20.84,99.46 20.71,99.46 20.56,99.62 EL5704.1
HDMI_DDI_TX_CMC_P0: length 4.8
  BOTTOM w0.127: EL5703.2 20.64,97.49 20.8,97.65 21.08,97.65 21.35,97.92 21.35,98.11 21.75,98.5 22.33,98.5 R5776.1 22.91,98.58 23.86,98.58 C5782.2
HDMI_DDI_TX_CMC_P1: length 3.7
  BOTTOM w0.127: C5780.2 23.19,96.47 22.23,96.47 R5774.1 21.77,96.04 21.49,96.32 21.24,96.32 21.01,96.1 20.69,96.1 20.53,95.94 EL5702.2
HDMI_DDI_TX_CMC_P2: length 4.6
  BOTTOM w0.127: v2(21.1,94.1) 21.22,94.22 ; 21.22,94.22 20.91,94.53 20.61,94.53 20.48,94.39 EL5701.2 ; 21.22,94.22 21.28,94.15 22.31,94.15 R5759.1 22.62,93.85 23.11,94.35 23.92,94.35 C5778.2
HDMI_DDI_TX_CMC_P3: length 6.6
  BOTTOM w0.127: C5784.2 24.43,100.72 23.64,100.72 R5778.1 23.1,100.78 22.22,100.78 C5724.1 21.52,100.63 21.34,100.63 21.21,100.51 21.21,99.49 21.08,99.36 ; v2(21.19,99.25) 21.08,99.36 ; 21.08,99.36 20.94,99.22 20.71,99.22 20.56,99.07 EL5704.2
HDMI_DDI_TX_CON_N0: length 16.8
  L3 w0.114: v1(13.6,98.87) 13.32,98.59 13.06,98.59 12.82,98.34 12.82,95.31 12.22,94.72 11.19,94.72 10.88,95.02 10.88,98.18 10.62,98.44 10.41,98.44 HDMI1.9
  BOTTOM w0.127: v1(13.6,98.87) 13.88,98.6 14.13,98.6 14.5,98.24 14.73,98.24 ER5703.2 15.42,98.18 ED5702.7 ED5702.4 17.64,98.18 17.8,98.03 18.09,98.03 18.24,97.89 18.54,97.89 18.69,98.04 EL5703.4
HDMI_DDI_TX_CON_N1: length 8.3
  BOTTOM w0.127: EL5702.4 18.72,96.49 18.56,96.34 18.31,96.34 18.11,96.54 17.74,96.54 17.62,96.66 ED5701.6 ED5701.5 15.99,96.66 15.88,96.55 15.36,96.55 ER5702.2 14.74,96.54 13.25,96.54 12.82,96.97 11.93,96.97 HDMI1.6
HDMI_DDI_TX_CON_N2: length 10.3
  BOTTOM w0.127: HDMI1.3 10.36,95.49 10.62,95.49 10.89,95.22 10.89,94.98 11.26,94.62 12.75,94.62 12.98,94.84 14.74,94.84 ER5701.2 15.3,94.9 15.75,94.9 15.99,95.14 ED5701.2 ED5701.9 17.59,95.14 17.71,95.02 18,95.02 18.23,94.79 18.54,94.79 18.69,94.94 EL5701.4
HDMI_DDI_TX_CON_N3: length 8.2
  BOTTOM w0.127: EL5704.4 18.69,99.62 18.49,99.42 18.29,99.42 18.1,99.61 17.69,99.61 17.6,99.71 ED5702.1 ED5702.10 15.8,99.71 15.63,99.88 15.43,99.88 ER5704.2 14.74,99.94 11.96,99.94 HDMI1.12
HDMI_DDI_TX_CON_P0: length 16.9
  L3 w0.114: v1(13.6,98.08) 13.32,98.36 13.16,98.36 13.04,98.25 13.04,95.22 12.32,94.49 11.09,94.49 10.66,94.93 10.66,98.09 10.53,98.21 10.37,98.21 HDMI1.7
  BOTTOM w0.127: v1(13.6,98.08) 13.88,98.36 14.03,98.36 14.4,97.99 14.75,97.99 ER5703.1 15.3,97.94 15.63,97.94 15.87,97.71 ED5702.6 ED5702.5 17.67,97.71 17.76,97.79 17.99,97.79 18.14,97.65 18.54,97.65 18.69,97.49 EL5703.3
HDMI_DDI_TX_CON_P1: length 8.3
  BOTTOM w0.127: HDMI1.4 11.93,96.73 12.72,96.73 13.15,96.3 14.74,96.3 ER5702.1 15.37,96.31 15.87,96.31 15.99,96.18 ED5701.4 ED5701.7 17.62,96.18 17.74,96.3 18.01,96.3 18.21,96.1 18.54,96.1 18.69,95.94 EL5702.3
HDMI_DDI_TX_CON_P2: length 10.3
  BOTTOM w0.127: EL5701.3 18.64,94.39 18.49,94.55 18.13,94.55 17.9,94.78 17.69,94.78 17.57,94.66 ED5701.10 ED5701.1 15.42,94.66 ER5701.1 14.74,94.6 13.08,94.6 12.85,94.37 11.16,94.37 10.65,94.88 10.65,95.12 10.52,95.25 10.4,95.25 HDMI1.1
HDMI_DDI_TX_CON_P3: length 8.2
  BOTTOM w0.127: EL5704.3 18.74,99.07 18.63,99.18 18.19,99.18 18,99.37 17.73,99.37 17.59,99.23 ED5702.2 ED5702.9 15.94,99.23 15.53,99.64 15.3,99.64 ER5704.1 14.74,99.7 11.9,99.7 HDMI1.10
HDMI_DDI_TX_N0: length 81.6
  L4 w0.114: v1(95.16,104.16) 94.72,103.72 94.72,102.58 94.6,102.46 94.6,102.27 94.6,99.58 94.08,99.05 90.6,99.05 88.27,96.73 74.33,96.73 v1(73.69,96.09)
  BOTTOM w0.127: 64.46,94.03 61.53,94.03 60.46,92.95 56.39,92.95 56.04,92.6 53.13,92.6 52.34,91.81 47.21,91.81 46.71,91.3 40.63,91.3 38.88,93.05 38.88,94.05 38.27,94.66 35.89,94.66 35.4,94.17 34.82,94.17 34.46,94.54 32.21,94.54 32.11,94.44 29.58,94.44 29.06,94.96 25.01,94.96 C5777.1 ; 64.46,94.03 70.83,94.03 70.88,94.08 72.31,94.08 73.69,95.45 v1(73.69,96.09) ; 64.46,94.03 v2(64.46,94.17) ; CPU1.AL5 95.41,103.92 v1(95.16,104.16)
HDMI_DDI_TX_N1: length 80.9
  L4 w0.114: v1(75.26,98.07) 75.44,97.89 75.74,97.89 76.81,98.96 87.18,98.96 87.91,99.7 93.73,99.7 94.17,100.13 94.17,100.52 93.78,100.91 93.78,103.19 v1(94.23,103.64)
  BOTTOM w0.127: 25.72,97.17 25.44,96.88 24.49,96.88 C5779.1 ; 25.72,97.17 v2(25.63,97.26) ; 25.72,97.17 28.66,100.1 30.63,100.1 30.69,100.04 44.37,100.04 44.85,100.52 45.98,100.52 46.4,100.1 51.44,100.1 52.99,98.55 61.23,98.55 65.1,94.68 70.68,94.68 73.77,97.77 74.97,97.77 v1(75.26,98.07) ; CPU1.AJ5 v1(94.23,103.64)
HDMI_DDI_TX_N2: length 79.8
  L4 w0.114: v1(93.29,102.98) 93.11,102.79 93.11,102.38 92.56,101.83 92.56,101.24 92.22,100.9 88.2,100.9 86.67,99.37 76.74,99.37 75.51,100.6 74.9,100.6 74.64,100.34 74.64,100 74.88,99.77 75.13,99.77 75.24,99.87 v1(75.24,100.15)
  BOTTOM w0.127: v1(93.29,102.98) 93.06,102.93 92.91,103.03 CPU1.AF6 ; 26.45,98.98 28.32,100.85 30.94,100.85 31,100.79 44.06,100.79 44.54,101.27 46.29,101.27 46.71,100.86 51.6,100.86 53.26,99.2 61.49,99.2 65.25,95.44 70.36,95.44 74.52,99.6 74.89,99.6 75.24,99.95 v1(75.24,100.15) ; 26.45,98.98 26.03,98.57 25.59,98.57 25.48,98.68 25.48,98.99 25.35,99.11 C5781.1 ; 26.45,98.98 v2(26.34,99.09)
HDMI_DDI_TX_N3: length 76.2
  L4 w0.114: v1(70.31,97.22) 70.55,97.46 70.55,97.79 70.88,98.13 71.31,98.13 74.82,101.64 77.39,101.64 77.76,102.01 79.2,102.01 79.4,101.8 81.48,101.8 81.49,101.82 82.02,101.82 82.04,101.8 91.65,101.8 91.89,102.04 91.89,102.39 91.52,102.76 91.52,103.55 91.91,103.94 92.16,103.94 v1(92.39,104.17)
  BOTTOM w0.127: 62.21,99.4 65.52,96.09 69.95,96.09 70.5,96.64 70.5,97.03 v1(70.31,97.22) ; 62.21,99.4 v2(62.31,99.49) ; 62.21,99.4 61.76,99.85 53.52,99.85 51.77,101.61 47.02,101.61 46.6,102.02 44.23,102.02 43.75,101.54 31.31,101.54 31.25,101.6 27.7,101.6 27.04,100.94 25.91,100.94 C5783.1 ; CPU1.AE5 v1(92.39,104.17)
HDMI_DDI_TX_P0: length 81.6
  L4 w0.114: v1(95.15,103.53) 94.95,103.32 94.95,102.48 94.83,102.36 94.83,99.51 94.84,99.49 94.17,98.82 90.69,98.82 88.37,96.5 74.42,96.5 74.25,96.32 74.25,96.17 v1(74.35,96.06)
  BOTTOM w0.127: 66.77,93.79 61.63,93.79 60.56,92.71 56.49,92.71 56.14,92.36 53.23,92.36 52.44,91.57 47.31,91.57 46.81,91.06 40.73,91.06 40.53,91.06 38.64,92.95 38.64,93.95 38.17,94.42 35.99,94.42 35.5,93.93 34.72,93.93 34.36,94.3 32.31,94.3 32.21,94.2 29.48,94.2 28.96,94.72 25.48,94.72 25.3,94.54 25.3,94.34 25.2,94.24 C5778.1 ; 66.77,93.79 v2(66.77,93.66) ; 66.77,93.79 70.93,93.79 70.98,93.84 72.41,93.84 73.93,95.35 73.93,95.64 v1(74.35,96.06) ; CPU1.AL6 95.63,103.29 95.17,103.53 v1(95.15,103.53)
HDMI_DDI_TX_P1: length 80.9
  L4 w0.114: v1(75.26,97.28) 75.26,97.54 75.39,97.66 75.84,97.66 76.9,98.73 87.27,98.73 88.01,99.47 93.83,99.47 94.4,100.03 94.4,100.62 94.01,101 94.01,102.87 94.14,103 v1(94.26,103)
  BOTTOM w0.127: CPU1.AJ6 v1(94.26,103) ; v1(75.26,97.28) 75.01,97.53 74.27,97.53 ; C5780.1 24.58,96.64 25.54,96.64 28.76,99.86 30.53,99.86 30.59,99.8 44.47,99.8 44.95,100.28 45.88,100.28 46.3,99.86 51.34,99.86 52.89,98.31 61.13,98.31 65,94.44 70.78,94.44 73.87,97.53 74.27,97.53 ; 74.27,97.53 v2(74.27,97.38)
HDMI_DDI_TX_P2: length 79.8
  L4 w0.114: v1(93.29,103.61) 92.88,103.2 92.88,102.48 92.33,101.93 92.33,101.33 92.12,101.13 88.11,101.13 86.58,99.59 76.83,99.59 75.6,100.83 74.81,100.83 74.42,100.43 74.42,99.9 74.78,99.54 75.06,99.54 v1(75.24,99.36)
  BOTTOM w0.127: CPU1.AF5 v1(93.29,103.61) ; 74.13,98.87 74.62,99.36 v1(75.24,99.36) ; 74.13,98.87 70.46,95.2 65.15,95.2 61.39,98.96 53.16,98.96 51.5,100.62 46.61,100.62 46.19,101.03 44.64,101.03 44.16,100.55 30.9,100.55 30.84,100.61 28.42,100.61 26.13,98.32 C5782.1 ; 74.13,98.87 v2(74.25,98.76)
HDMI_DDI_TX_P3: length 76.2
  L4 w0.114: v1(70.97,97.23) 70.78,97.42 70.78,97.7 70.98,97.9 71.4,97.9 74.92,101.41 77.48,101.41 77.85,101.78 79.1,101.78 79.31,101.57 81.57,101.57 81.59,101.59 81.93,101.59 81.94,101.57 91.74,101.57 92.12,101.95 92.12,102.48 91.75,102.85 91.75,103.46 92,103.71 92.2,103.71 v1(92.38,103.53)
  BOTTOM w0.127: CPU1.AE6 v1(92.38,103.53) ; v1(70.97,97.23) 70.74,97 70.74,96.54 70.05,95.85 65.42,95.85 61.66,99.61 53.42,99.61 51.67,101.37 46.92,101.37 46.5,101.78 44.33,101.78 43.85,101.3 31.21,101.3 31.15,101.36 27.8,101.36 27.14,100.7 26.83,100.7 ; 26.83,100.7 25.9,100.7 C5784.1 ; 26.83,100.7 v2(26.83,100.56)
HDMI_HPD_B: length 4.4
  BOTTOM w0.102: Q5703.B 14.71,105.07 14.71,106.65 14.98,106.91 15.78,106.91 R5781.1
HDMI_HPD_CON: length 22.4
  TOP w0.102: ED5703.6 ED5703.5 16.68,95.69 14.86,97.51 14.86,100 14.34,100.52 v1(13.87,100.52)
  L3 w0.102: HDMI1.19 10.43,104.28 12.23,104.28 13.36,103.15 13.36,101.02 v1(13.87,100.52)
  BOTTOM w0.102: HDMI1.19 11.31,105.16 12.17,105.16 14.83,107.65 15.15,107.65 R5764.2 15.88,108.38 R5781.2
HDMI_PLL_GND: length 12
  TOP w0.102: Q5701.D 23.11,95.36 23.24,95.48 v1(23.24,95.56) ; v1(23.5,92.99) 23.89,93.39 v2(23.89,93.53)
  BOTTOM w0.102: R5774.2 22.17,95.18 22.55,95.56 R5705.2 v1(23.24,95.56) ; R5773.2 22.05,97.74 22.41,97.38 R5776.2 22.84,97.38 22.99,97.54 23.8,97.54 v1(23.98,97.72) ; R5777.2 23.96,102.19 v1(24.16,101.98) ; v1(26.22,99.88) 23.89,99.88 23.63,99.62 R5778.2 22.91,99.62 R5775.2 ; R5759.2 v1(23.5,92.99)
HDMI_SCL_CON: length 26.8
  TOP w0.14: HDMI1.15 10.65,102.5 10.65,103.36 11.25,103.95 12.05,103.95 15.56,100.44 15.56,97.78 16.67,96.67 17.94,96.67 18.68,95.93 ED5703.1 ED5703.10 18.68,94.19 17.17,92.69 17.17,91.77 18.11,90.84 v2(20.44,90.84) 20.9,90.84 Q5702.3 20.6,89.69 20.6,89.25 20.3,88.95 20.3,88.85 20.19,88.72 R5755.2
HDMI_SCL_R: length 2.4
  TOP w0.14: 20.02,89.49 19.46,90.04 D5701.2 ; 20.02,89.49 v2(20.03,89.49) ; 20.02,89.49 R5755.1
HDMI_SDA_CON: length 25.1
  TOP w0.14: 18.85,87.76 18.85,87.82 18.09,88.58 R5751.2 18.09,90.4 16.89,91.59 16.89,92.89 18.2,94.2 ED5703.9 ED5703.2 18.2,95.95 17.81,96.34 16.56,96.34 15.28,97.63 15.28,100.33 13.07,102.53 11.74,102.53 HDMI1.16 ; 18.85,87.76 19.08,87.98 22.31,87.98 22.62,88.3 Q5702.6 ; 18.85,87.76 v2(18.85,87.71)
HDMI_SDA_R: length 2.3
  TOP w0.14: R5751.1 16.86,88.83 v2(16.4,89.29) 16.4,89.55 16.89,90.04 D5701.1
HOST_DEBUG_TX: length 20
  TOP w0.102: DBEC1.5 44.9,74.03 45.74,73.19 46.72,73.19 47.63,74.1 48.29,74.1 48.42,73.97 48.42,72.09 48.11,71.78 48.11,70.91 46.71,69.51 46.71,68.67 46.35,68.3 45.21,68.3 44.93,68.02 44.35,68.02 R6801.1 43.91,67.58 42.26,67.58 R2480.1 41,66.3 40.06,66.3 39.86,66.49 U2401.81
HOST_DEBUG_TX_CON: length 29.5
  TOP w0.102: R6801.2 45.29,68.1 46.49,68.1 46.92,68.53 46.92,69.43 48.31,70.83 48.31,71.63 49.74,73.05 v1(49.74,73.2)
  BOTTOM w0.102: DBG1.11 67.13,72.32 65.75,73.7 56.68,73.7 55.81,72.83 50.52,72.83 50.14,73.2 v1(49.74,73.2)
HPDIN: length 2.3
  TOP w0.102: U7101.32 v1(19.32,106.79)
  BOTTOM w0.102: R7190.2 17.79,106.81 R7176.1 19.3,106.81 v1(19.32,106.79)
HW_ACAV_IN: length 356
  TOP w0.089: v1(204.93,33.02) 204.93,35.09 206.5,36.65 206.5,38.41 206.21,38.7 206.21,39.24 205.87,39.58 205.87,41.01 205.87,41.02 205.87,41.1 204.77,42.19 v1(204.77,42.58) ; v1(22.23,76.66) 22.23,77.24 v2(22.51,77.52) 23.09,76.94 23.09,76.42 23.52,75.99 24.24,75.99 24.65,75.58 24.65,74.12 24.85,73.91 U2401.128 ; v1(25.83,114.76) 25.48,115.11 25.48,115.16 25.13,115.52 25.13,116.92 24.54,117.5 24.54,118.16 25.05,118.68 26.45,118.68 26.55,118.78 26.55,118.81 26.7,118.96 26.7,119.77 R4482.1
  L4 w0.089: v1(25.83,114.76) 25.45,114.37 25.45,114.32 25.38,114.25 25.38,112.83 26.18,112.03 26.18,111.68 25.83,111.32 25.83,103.28 28.48,100.64 31.79,100.64 35.99,96.43 35.99,94.58 38.54,92.04 38.54,81.13 37.52,80.11 37.52,78.15 37.33,77.96 37.33,76.93 36.98,76.58 28.53,76.58 27.75,77.36 27.7,77.36 22.88,77.36 22.23,76.71 22.23,76.66 v1(22.23,76.66) 22.23,76.21 21.63,75.61 20.96,75.61 18.09,72.73 18.09,70.1 17.76,69.78 17.76,67.86 17.54,67.64 16.78,67.64 15.17,66.03 15.17,62.98 14.55,62.36 14.55,51.41 v1(14.06,50.92) 13.67,50.53 13.67,48.86 11.31,46.5 11.31,40.87 14.23,37.95 14.23,35.31 14.48,35.06 14.48,29.98 15.54,28.92 15.54,28.69 15.56,28.67 15.56,28.32 15.54,28.3 15.54,26.63 17.3,24.86 21.03,24.86 21.41,24.48 28.57,24.48 29.1,25.02 32.24,25.02 32.82,25.02 36.47,28.67 42.29,28.67 43.11,29.48 53.46,29.48 54,30.02 74.59,30.02 77.34,32.77 100.12,32.77 101.12,31.77 106.22,31.77 107.5,33.05 107.5,34.26 113.16,39.92 119.48,39.92 120.99,38.41 121.73,38.41 124.16,35.98 127,35.98 130.06,32.92 133.18,32.92 134.93,31.17 139.55,31.17 140.13,30.59 182.46,30.59 183.42,31.55 188.71,31.55 190.23,33.07 204.89,33.07 v1(204.93,33.02)
  BOTTOM w0.089: v1(14.06,50.92) 14.53,51.4 D6403.K ; PG4408.2 205.53,45.3 205.07,45.3 204.56,44.79 203.78,44.79 203.68,44.69 203.68,44.1 203.99,43.79 PQ4415.5 204.88,43.79 205.01,43.67 205.01,42.82 v1(204.77,42.58)
HW_ACAV_IN0: length 3
  TOP w0.102: Q4349.2 26.87,120.75 R4482.2 26.84,120.71 26.35,120.23 26.35,119.3 R4481.1
HW_ACAVIN_NB: length 125.2
  TOP w0.102: R4471.2 28.67,119.55 28.5,119.71 28.5,121.79 28.32,121.97 28.13,121.97 27.99,122.11 27.99,122.68 ; v1(34.14,132.64) 34.47,132.97 D4305.A 33.96,133.41 R4315.2 33.54,132.8 R4311.2 33.51,131.65 D4309.A ; v1(18.75,66.29) 19.14,66.29 20.53,64.9 20.53,64.36 20.81,64.09 21.24,64.09 21.67,63.65 22.76,63.65 23.12,63.29 U2401.24 ; 27.99,122.68 26.9,122.68 R4381.2 26.27,120.75 v1(26.11,120.6) ; 27.99,122.68 28.27,122.96 28.27,123.98 28.04,124.21 27.31,124.21 R4380.2 ; U4302.1 38.16,118.39 37.8,118.03 R4378.2 37.4,118.64 37.44,118.69 37.44,118.76 v1(37.46,118.78)
  L4 w0.102: v1(18.75,66.29) 18.75,66.8 19.57,67.63 19.57,68.76 19.64,68.83 19.64,69.22 20.7,70.28 20.7,71.25 21.54,72.09 21.54,72.58 21.88,72.91 23.47,72.91 24.71,74.14 37.2,74.14 40.2,77.14 40.2,95.84 39.9,96.14 39.9,105.06 38.84,106.12 38.84,114.53 38.85,114.54 38.85,114.9 38.84,114.91 38.84,115.88 37.62,117.1 37.62,118.67 37.49,118.8 37.48,118.8 v1(37.46,118.78) ; v1(26.11,120.6) 26.6,120.6 27.49,121.49 27.49,124.41 28.6,125.53 28.6,128.45 30.61,130.46 30.61,132.23 31.04,132.67 34.11,132.67 v1(34.14,132.64)
  BOTTOM w0.102: v1(37.46,118.78) 37.46,120.01 37.08,120.4 35.99,120.4 35.69,120.7 31.35,120.7 30.95,121.1 29.32,121.1 29.02,121.4 27.93,121.4 v2(27.88,121.35) 27.39,121.35 26.64,120.6 v1(26.11,120.6)
HW_ACAVIN_NB0: length 4.6
  TOP w0.102: R4470.1 28.81,122.03 28.81,121.02 29.08,120.75 ; 29.08,120.75 Q4349.5 ; 29.08,120.75 29.05,120.75 28.83,120.53 28.83,119.84 29.01,119.66 29.24,119.66 29.53,119.37 R4471.1
I2C0_SCL_TCH_PAD: length 243.9
  TOP w0.14: Q9301.1 158.97,139.05 v1(158.75,139.26) ; v1(105.41,30.15) 106.08,30.82 106.08,31.28 EC6504.1 106.63,31.83 R6505.1 106.63,32.74 106.28,33.09 106.28,33.09 105.69,33.68 105.69,34.9 105.11,35.48 105.11,39.23 v1(105.41,39.53)
  L3 w0.127: v1(142.65,120.5) 142.22,120.93 142.22,132.36 146.54,136.68 149.38,136.68 151.47,138.77 151.47,138.96 153.94,141.42 156.35,141.42 156.76,141.02 156.78,141.02 158.53,139.26 v1(158.75,139.26) ; v1(170.22,61.89) 166.63,65.48 166.63,66.61 161.42,71.83 161.42,72.42 153.29,80.55 153.29,82.96 152.2,84.04 152.2,85.06 149.4,87.86 148.85,87.86 138.03,98.68 137.14,98.68 133.74,102.07 128.92,102.07 128.92,102.07 128.56,102.07 128.36,101.87 127.22,101.87 126.86,101.51 125.82,101.51 v1(125.07,100.76)
  L4 w0.127: v1(125.25,103.05) 125.07,102.87 v1(125.07,100.76)
  BOTTOM w0.076: v1(125.07,100.76) 124.64,100.33 124.41,100.33 124.06,99.98 123.77,99.98 123.63,100.12 122.45,100.12 122.36,100.09 122.12,100.09 121.92,100.16 CPU1.CN11
  BOTTOM w0.14: v1(105.41,30.15) 104.8,30.15 104.07,29.41 101.4,29.41 100.92,29.9 100.92,30.89 100.51,31.29 99.65,31.29 Q6504.1 ; v1(105.41,39.53) 105.48,39.6 105.48,40.7 105.22,40.97 105,40.97 102.9,43.06 102.9,43.66 103.11,43.86 103.11,45.92 102.65,46.38 102.65,51.32 104.78,53.45 110.04,53.45 110.09,53.49 110.46,53.49 111.27,54.31 111.28,54.31 111.31,54.33 144.63,54.33 145.07,53.89 147.01,53.89 147.45,53.45 156.9,53.45 157.73,54.28 164.71,54.28 166.05,55.62 166.99,55.62 167.65,56.28 167.65,56.92 170.22,59.49 v1(170.22,61.89) ; R9321.1 158.05,138.95 R2066.2 159.1,138.39 159.1,138.91 v1(158.75,139.26) ; v1(125.25,103.05) 126.6,104.4 130.44,104.4 132.79,106.76 132.79,111.53 134.93,113.66 v2(134.93,113.92) 137.5,116.49 137.5,117.96 137.49,117.97 137.49,118.95 138.84,120.3 142.45,120.3 v1(142.65,120.5)
I2C0_SCL_TCH_PNL: length 137.3
  TOP w0.14: v1(211.33,50.6) 211.5,50.43 212.21,50.43 AFTP5504.1
  L3 w0.127: v1(119.07,99.07) 119.51,99.52 122,99.52 123.83,101.35 124.66,101.35 125.33,102.01 126.64,102.01 127.14,102.51 127.14,103.39 127.63,103.87 134.58,103.87 134.87,103.58 v1(134.87,103.01) 134.87,102.22 137.4,99.7 138.36,99.7 149.23,88.82 149.72,88.82 153.22,85.32 153.22,84.45 154.23,83.43 154.23,81.64 154.23,80.94 162.36,72.81 162.36,72.28 168.07,66.56 168.07,65.62 175.02,58.68 176.48,58.68 177.86,57.29 178.77,57.29 180.49,57.29 180.83,56.95 180.83,56.95 180.99,56.78 190.35,56.78 192.53,58.96 203.53,58.96 203.88,58.62 203.9,58.62 203.95,58.57 204.54,58.57 205.34,57.77 206.48,57.77 206.55,57.84 208.11,57.84 208.11,57.84 208.35,57.84 211.13,55.06 211.13,51.98 211.33,51.78 v1(211.33,50.6)
  BOTTOM w0.14: v1(211.33,50.6) 211.33,50.98 211.7,51.35 212.08,51.35 212.43,51 216.89,51 217.84,50.05 LCD1.15 ; v1(134.87,103.01) 135.14,103.28 136.14,103.28 R5518.2 ; CPU1.CJ12 119.32,99.32 v1(119.07,99.07)
I2C0_SDA_TCH_PAD: length 257.6
  TOP w0.14: Q9301.4 161.21,140.7 v1(161.44,140.46) ; R2065.2 136.29,99.86 135.83,99.86 v1(133.15,102.55) 132.65,103.05 132.65,105.5 v1(132.8,105.65) ; EC6502.1 v1(108.97,32.41) 108.97,32.79 109.3,33.12 109.3,35.28 R6506.1 109.4,35.64 109.07,35.97 108.26,35.97 107.71,35.42 105.86,35.42 105.39,35.89 105.39,38.84 v1(106.05,39.5)
  L3 w0.127: v1(161.44,140.46) 161.4,140.42 161.33,140.42 160.71,139.79 158.37,139.79 156.89,141.27 156.87,141.27 156.46,141.68 153.83,141.68 151.22,139.07 151.22,138.87 149.28,136.93 146.15,136.93 141.79,132.56 141.79,120.67 v1(142.62,119.84) ; v1(124.43,100.76) 125.44,101.76 126.75,101.76 127.12,102.13 127.91,102.13 128.07,102.29 128.07,103.1 128.35,103.38 132.32,103.38 v1(133.15,102.55) 133.63,102.55 137.24,98.93 138.13,98.93 148.96,88.11 149.5,88.11 152.48,85.14 152.48,84.12 153.54,83.06 153.54,80.66 161.67,72.52 161.67,71.93 167.01,66.6 167.01,65.74 170.7,62.04 v1(170.7,61.46)
  BOTTOM w0.076: CPU1.CM11 121.31,100.6 121.71,100.6 121.77,100.58 122.06,100.58 122.12,100.6 122.36,100.6 122.42,100.58 123.13,100.58 123.33,100.77 123.48,100.77 123.66,100.95 124.24,100.95 v1(124.43,100.76)
  BOTTOM w0.14: v1(161.44,140.46) 161.42,140.44 R9322.1 ; Q6504.4 97.9,32.68 97.53,32.3 97.53,31.13 99.81,28.86 107.68,28.86 108.44,29.61 108.44,31.88 v1(108.97,32.41) ; v1(132.8,105.65) 133.07,105.93 133.07,111.39 137.78,116.1 137.78,118.08 137.77,118.08 137.77,118.55 139.06,119.84 v2(139.25,119.84) v1(142.62,119.84) ; v1(106.05,39.5) 105.86,39.68 105.86,39.71 105.76,39.82 105.76,40.82 105.33,41.24 105.11,41.24 103.18,43.17 103.18,43.55 103.39,43.75 103.39,46.04 102.93,46.5 102.93,51.21 104.89,53.17 110.16,53.17 110.21,53.22 110.58,53.22 111.39,54.03 111.4,54.03 111.43,54.05 144.51,54.05 144.95,53.61 146.9,53.61 147.33,53.17 157.02,53.17 157.85,54 164.83,54 166.17,55.34 167.1,55.34 167.93,56.17 167.93,56.8 170.7,59.58 v1(170.7,61.46)
I2C0_SDA_TCH_PNL: length 175.1
  TOP w0.14: R5517.2 136.34,94.09 133.32,94.09 130.15,97.26 128.6,97.26 v1(128.17,97.69) ; v1(192.89,36.55) 192.61,36.55 192.47,36.41 192.19,36.41 191.85,36.07 191.85,35.95 191.24,35.33 190.78,35.33 190.2,35.33 190.15,35.38 190.14,35.38 189.69,35.84 184.92,35.84 183.54,34.46 AFTP5505.1 183.19,33.69 181.25,33.69 180.83,33.27 176.52,33.27 171.92,37.86 v1(167.03,37.86)
  L4 w0.127: v1(192.89,36.55) 195.71,36.55 196.1,36.16 198.73,36.16 199.07,36.5 202.7,36.5 203.9,37.71 206.31,37.71 207.02,37 207.96,37 209.18,38.22 211.67,38.22 213.53,40.08 213.74,40.08 216.22,42.56 217.3,42.56 218.86,44.12 218.86,48.15 219.56,48.85 219.56,49.68 220.02,50.14 v1(220.2,50.14) ; v1(167.03,37.86) 167.81,37.86 170.31,40.36 170.61,40.36 171.49,41.24 171.49,42.69 171.39,42.79 171.39,49.75 158.07,63.07 157.92,63.07 155.9,65.09 155.9,66.41 155.68,66.62 155.68,67.12 156.02,67.45 156.02,68 151.83,72.19 151.01,72.19 150.86,72.04 150.39,72.04 148.98,73.46 148.98,75.69 148.19,76.48 148.19,78.51 147.75,78.95 147.75,81.42 144.74,84.44 144.74,85.18 143.5,86.42 143.5,86.5 143.21,86.79 143.21,86.81 142.91,87.11 142.91,88.24 138.68,92.47 138.68,93.12 134.48,97.32 133.5,97.32 132.74,98.07 131.97,98.07 131.45,98.59 128.96,98.59 128.17,97.8 v1(128.17,97.69) 128.17,97.46 127.96,97.25 126.74,97.25 125.54,98.45 124.96,98.45 123.59,99.83 121.88,99.83 121.14,99.09 v1(119.75,99.09)
  BOTTOM w0.14: v1(220.2,50.14) 219.99,50.14 219.4,49.55 LCD1.16 ; CPU1.CK12 119.97,99.31 v1(119.75,99.09)
I2C1_SCL_R: length 27.5
  TOP w0.114: RN6503.4 107.5,31.61 R6505.2
  TOP w0.14: R6505.2 107.5,32.69 v1(106.87,33.31) 106.43,33.76 AFTP6528.1
  BOTTOM w0.14: TP1.6 105.2,36.1 104.91,36.39 103.97,36.39 103.71,36.14 103.71,34.95 103.24,34.48 103.24,33.7 103.67,33.28 106.84,33.28 v1(106.87,33.31) 107.78,32.41 107.78,29.75 107.52,29.48 107.45,29.48 107.41,29.45 106.37,29.45 105.86,29.95 105.86,30.34 105.6,30.6 104.77,30.6 103.97,29.8 101.47,29.8 101.2,30.06 101.2,31.01 99.21,33.01 Q6504.6
I2C1_SDA_R: length 26.7
  TOP w0.14: R6506.2 108.77,35.15 AFTP6527.1 108.73,33.95 108.6,33.95 v1(107.95,33.3) 107.95,33.2 108.16,32.99 RN6503.3
  BOTTOM w0.14: Q6504.3 97.9,31.15 99.92,29.14 107.56,29.14 108.06,29.63 108.06,33.19 v1(107.95,33.3) 107.49,33.76 106.51,33.76 106.3,33.55 103.79,33.55 103.52,33.82 103.52,34.36 104.2,35.04 TP1.7
I2C_CLK: length 25.6
  TOP w0.14: Q5801.4 40.56,94.98 R5834.2 v2(41.34,95.07) 41.44,95.07 v1(41.8,95.43) ; v1(45.62,114.8) 45.94,114.8 46.64,115.5 U5802.1
  L4 w0.127: v1(45.62,114.8) 45.71,114.7 45.71,113.38 44.97,112.64 44.96,112.64 44.4,112.07 44.4,107.87 43.86,107.34 43.86,106.47 41.34,103.94 41.34,95.98 41.8,95.52 v1(41.8,95.43)
I2C_CLK_PD: length 14.8
  TOP w0.114: R7114.2 26.81,109.27 27.19,109.65 28.19,109.65 v1(28.58,110.04)
  TOP w0.14: v2(35.94,108.4) 36.44,108.4 v1(36.63,108.59) 36.82,108.77 RN7202.3 37.67,109.3 38.03,109.66 U7201.17
  L3 w0.127: v1(28.58,110.04) 28.58,110.04 28.58,110.15 28.71,110.28 30.57,110.28 31.43,109.41 35.64,109.41 36.46,108.59 v1(36.63,108.59)
I2C_CLK_PD_MUX: length 2.8
  TOP w0.114: U7101.21 23.4,109.16 23.58,109.34 v2(24.73,109.34) 25.62,109.34 R7114.1
I2C_CTL_EN: length 2.9
  TOP w0.102: R5821.2 46.28,114.15 R5812.2 46.34,114.17 46.34,114.55 46.59,114.8 47.12,114.8 47.3,114.98 U5802.2
I2C_DATA_PD: length 14.4
  TOP w0.114: v1(27.93,110.17) 27.84,110.08 26.6,110.08 R7116.2
  TOP w0.14: U7201.16 38.13,110.16 37.87,109.9 37.84,109.9 37.75,109.81 36.98,109.81 RN7202.4 36.43,110.36 v1(36.43,110.64) 36.08,110.99 v2(35.85,110.99)
  L3 w0.127: v1(27.93,110.17) 28.29,110.53 30.77,110.53 31.64,109.67 35.5,109.67 36.43,110.6 v1(36.43,110.64)
I2C_DATA_PD_MUX: length 3.6
  TOP w0.114: U7101.22 23,109.43 v2(23.26,109.68) 23.32,109.74 25.39,109.74 R7116.1
I2C_SDA: length 31.1
  TOP w0.14: v1(41.87,96.36) 41.07,96.36 40.57,95.86 39.48,95.86 v2(39.34,95.99) 38.82,95.47 38.82,93.39 39.26,92.95 Q5801.1 ; R5817.2 44.67,113.88 45.02,114.23 45.02,114.77 45.17,114.92 45.17,114.99 45.63,115.45 v1(45.63,115.49) 45.63,115.61 46.06,116.03 U5802.60
  L4 w0.127: v1(41.87,96.36) 41.87,104.04 44.17,106.34 44.17,107.21 44.7,107.75 44.7,111 45.32,111.63 45.32,112.09 45.21,112.2 45.21,112.49 46.06,113.34 46.06,115.06 v1(45.63,115.49)
I2CEN: length 3.9
  TOP w0.102: U7101.17 v1(24.63,106.79)
  BOTTOM w0.102: R7174.2 23.43,108.1 23.87,107.65 C7166.2 23.85,107.01 R7173.1 24.37,106.53 v1(24.63,106.79)
I_ADP: length 6
  TOP w0.102: U2401.110 32.35,74.62 32.44,74.7 32.44,75.26 32.85,75.67 32.93,75.67 33.18,75.92 35.06,75.92 R2421.2 35.44,76.38 36.12,77.06 C2435.1
I_BATT: length 3.6
  TOP w0.203: U2401.114 30.76,74.57 30.97,74.78 30.97,75.37 v2(30.95,75.38)
  TOP w0.254: v2(30.95,75.38) 30.95,75.52 31.25,75.83 31.25,76.24 C2431.1 31.37,76.3 R2483.2
IC_DELAY: length 1.2
  TOP w0.102: U4302.4 41.36,116.49 C4344.1
ICSP_CLK: length 12.1
  TOP w0.14: DBEC1.2 44.47,75.53 44.64,75.69 44.64,76.24 44.52,76.36 43.2,76.36 42.52,75.68 v2(42.42,75.68) 42.31,75.57 40.69,75.57 40.06,76.19 38.38,76.19 37.58,75.39 36.8,75.39 36.79,75.41 36.42,75.41 36.4,75.39 36.4,75.39 36.34,75.34 36.33,75.34 35.95,74.97 U2401.101
ICSP_CLR: length 17.4
  TOP w0.102: U2401.87 39.56,68.89 39.79,69.12 39.79,70.84 39.99,71.05 40.59,71.05 40.64,71.09 42.6,71.09 42.6,71.1 43.46,71.1 R2414.1 44.35,70.21 44.35,69.92 44.86,69.41 45.27,69.41 45.46,69.61 46.18,69.61 47.56,70.99 47.56,72.34 46.92,72.99 45.57,72.99 45.02,73.53 DBEC1.6
ICSP_DAT: length 13.8
  TOP w0.14: DBEC1.3 44.61,75.03 44.92,75.34 44.92,76.36 44.64,76.63 43.08,76.63 42.6,76.16 41.91,76.16 41.28,76.79 40.5,76.79 v2(40.25,76.54) 40.18,76.47 38.26,76.47 37.46,75.67 36.28,75.67 35.69,75.08 35.69,74.82 35.55,74.68 U2401.102
ILIM_HI: length 2
  TOP w0.102: R3604.2 23.87,52 v2(23.69,52.19) 23.43,52.44 U3601.16
ILIM_LO: length 2
  TOP w0.102: R3603.2 23.32,51.02 23.32,51.59 22.97,51.94 U3601.15
ILIM_SEL: length 2.3
  TOP w0.102: U3601.4 20.52,53.55 20.15,53.92 v2(19.89,53.92) 19.64,53.92 19.19,54.37 R3605.2
IN_AUX_N: length 3.3
  TOP w0.127: U5802.25 55.4,117.63 55.48,117.55 55.75,117.55 56.81,116.49 56.81,116.18 56.95,116.04 57.16,116.04 C5854.2
IN_AUX_P: length 3.5
  TOP w0.127: 56.23,116.73 55.65,117.31 55.44,117.31 55.36,117.23 U5802.24 ; 56.23,116.73 v2(56.11,116.61) ; 56.23,116.73 56.57,116.39 56.57,116.08 56.85,115.8 57.18,115.8 C5862.2
INPUT3VSEL: length 35.6
  L4 w0.102: v1(134.95,82.65) 134.14,82.65 128.91,87.89 121.96,87.89 120.83,89.01 119.99,89.01 119.57,89.44 117.92,89.44 117.63,89.73 117.63,90.42 117.43,90.62 v1(109.69,90.62)
  BOTTOM w0.102: v1(134.95,82.65) 134.95,82.93 135.13,83.11 135.8,83.11 136.05,82.87 136.05,82.35 v2(136.17,82.22) 136.38,82.02 137.43,82.02 R1521.1 138.46,81.56 R1520.2 ; CPU1.BT27 110.8,90.62 v1(109.69,90.62)
INT#_ITE8010: length 6.7
  TOP w0.102: R2438.1 212.42,51.89 214.05,50.27 v2(215.95,50.27) 216.39,50.27 217.17,51.05 WWAN1.12
IO_DB_DET#: length 23.1
  TOP w0.102: R6602.1 136.32,92.9 136.32,93.68 136.65,94.01 136.92,94.01 137.16,94.25 137.16,94.83 137.02,94.97 133.4,94.97 130.22,98.16 127.73,98.16 127.32,98.56 127.32,99.64 127.06,99.9 AFTP6609.1 125.94,99.91 125.64,99.91 125.01,99.28 v1(125.01,99.2)
  BOTTOM w0.076: CPU1.CM14 121.03,98.79 122.19,98.79 122.38,98.89 122.79,98.89 123.01,98.67 123.36,98.67 123.77,99.08 124.71,99.08 124.85,99.21 125,99.21 v1(125.01,99.2)
IO_DB_DET#_EC: length 239.3
  TOP w0.102: R6610.1 200.42,32.88 R5563.1 201.73,32.88 v1(201.99,32.61) ; v2(147.68,33.1) v1(147.09,33.1) ; v1(19.06,59.1) 20.15,59.1 20.51,59.46 24.69,59.46 24.81,59.58 25.36,59.58 25.55,59.39 U2401.34
  L2SGND w0.102: v1(20.08,41.31) 20.13,41.31 20.35,41.1 20.35,39.88 21.14,39.09 21.14,38.43 22.43,37.14 24.36,37.14 24.69,36.81 25.24,36.81 25.48,36.58 25.48,35.89 25.03,35.44 25.03,32.96 26.4,31.59 26.4,30.55 26.9,30.05 31.35,30.05 31.96,29.44 34.33,29.44 34.99,28.78 37.01,28.78 37.69,28.1 37.72,28.08 44.81,28.08 45.6,28.86 53.38,28.86 53.7,28.55 54.51,28.55 55.15,29.19 62.92,29.19 65.87,32.13 v1(66.11,32.13)
  L3 w0.102: v1(201.99,32.61) 201.45,33.15 188.04,33.15 187.56,32.68 176.55,32.68 175.39,33.83 170.63,33.83 169.74,32.94 166.17,32.94 166.05,32.94 166.01,32.94 165.37,32.95 165.36,32.95 159.64,32.95 158.91,32.23 147.97,32.23 v1(147.09,33.1) ; v1(19.06,59.1) 19.06,58.5 18.78,58.22 18.78,58.08 18.86,57.99 18.86,56.77 18.86,56.77 18.86,56.62 18.86,51.61 19.03,51.44 19.03,50.66 18.27,49.89 18.27,46.11 18.27,45.78 18.26,45.78 18.26,44.8 18.27,44.8 18.27,44.74 18.27,44.54 19.61,43.19 19.62,43.18 19.68,43.12 19.69,43.11 19.78,43.02 19.78,41.94 20.08,41.64 v1(20.08,41.31)
  L4 w0.102: v1(147.09,33.1) 146.75,33.44 135.37,33.44 133.56,35.26 130.85,35.26 130.22,35.88 129.33,35.88 127.7,37.51 124.83,37.51 122.38,39.96 121.6,39.96 120.72,40.84 120.72,41.46 119.85,42.34 112.51,42.34 111.23,41.06 111.23,40.16 104.37,33.3 101.76,33.3 100.75,34.3 76.49,34.3 74.32,32.13 v1(66.11,32.13)
  BOTTOM w0.102: R6611.2 65.92,36.38 65.92,34.44 66.43,33.93 66.43,33.9 66.43,33.89 66.43,32.46 v1(66.11,32.13)
IO_DB_DET#_GPPG5: length 2
  TOP w0.102: R6608.1 118.94,86.92 118.94,85.67 118.98,85.64 v1(118.98,85.55)
  BOTTOM w0.102: v1(118.98,85.55) 118.97,85.54 CPU1.CH35
IO_DB_DET#_R: length 146.3
  TOP w0.102: R6610.2 200.41,34.8 v2(199.97,35.24) 198.57,36.64 v1(198.12,36.64) ; R6609.2 136.72,92.43 R6602.2 130.37,91.61 v1(125.15,86.39) 123.67,86.39 122.46,87.59 121.55,87.59 121.1,88.04 120.06,88.04 R6608.2
  L3 w0.102: v1(158.43,40.27) 159.08,40.92 165.48,40.92 165.64,40.77 165.64,40.5 166.37,39.76 168.14,39.76 168.77,40.39 171.82,40.39 173.11,39.1 182.21,39.1 184.2,41.09 188.22,41.09 188.38,41.25 189.69,42.56 190.56,42.56 191.09,42.03 v1(191.09,41.99)
  L4 w0.102: v1(125.15,86.39) 125.15,86.11 126.6,84.66 126.6,83.29 128.95,80.94 131.56,80.94 133.45,79.05 133.45,78.7 133.34,78.59 133.34,78.23 133.34,78.22 133.34,78.22 133.6,77.97 133.61,77.97 134.39,77.18 136.06,77.18 138.73,74.52 139.84,74.52 147.67,66.68 147.67,65.76 150.07,63.36 150.07,61.6 150.72,60.95 152.17,60.95 162.59,50.53 162.59,44.74 158.43,40.57 v1(158.43,40.27)
  BOTTOM w0.102: v1(191.09,41.99) 190.84,41.75 190.84,40.16 190.86,40.14 190.86,39.19 191.65,38.41 192.91,38.41 193.61,37.71 193.61,36.94 194.58,35.97 196.93,35.97 197.6,36.64 v1(198.12,36.64) 198.35,36.87 201.55,36.87 202.8,38.13 IOBD1.2
IR_CAM_DET#: length 124.9
  TOP w0.089: R2046.2 125.95,92.63 v1(125.41,93.17) ; AFTP5506.1 209.51,51.02 v1(209.51,51.19)
  L3 w0.089: v1(209.51,51.19) 209.51,52.51 207.75,54.27 206.88,54.27 205.73,55.42 204.72,55.42 203.87,54.57 202.26,54.57 201.79,55.04 193.04,55.04 191.7,53.7 191.56,53.7 179.68,53.7 179.17,54.21 177.49,54.21 177.43,54.15 177.42,54.15 177.19,53.92 177.19,53.92 176.85,53.58 173.91,53.58 173.7,53.79 173.6,53.89 157.97,69.52 157.97,70.87 152.98,75.85 152.13,75.85 151.97,76.02 151.95,76.02 148.64,79.33 148.64,81.41 145.31,84.73 145.15,84.73 141.94,87.93 141.91,87.93 141.66,88.18 141.66,88.24 140.04,89.86 133.97,89.86 131.83,91.99 128.31,91.99 127.21,93.09 127.21,93.4 126.9,93.7 125.94,93.7 v1(125.41,93.17)
  BOTTOM w0.076: CPU1.CM22 121.2,93.69 121.3,93.75 122.21,93.75 122.23,93.75 122.4,93.85 122.81,93.85 123.04,93.62 123.83,93.62 123.91,93.54 124.51,93.54
  BOTTOM w0.089: v1(125.41,93.17) 125.04,93.54 124.51,93.54 ; v1(209.51,51.19) 209.88,50.82 210.52,50.82 211.15,50.18 211.6,50.18 211.89,50.48 216.58,50.48 218.51,48.55 LCD1.18
ISOLATE#: length 5
  TOP w0.102: v1(49.23,83.26) 49.19,83.21 48.92,83.21 48.8,83.34 U3101.20
  BOTTOM w0.102: v1(49.23,83.26) 49.2,83.26 48.97,83.03 48.97,82.27 R3113.1 49.09,81.88 49.09,81.21 v2(49.17,81.13) 49.24,81.13 50.06,81.96 R3109.2
IST_TRIG: length 6.9
  TOP w0.102: v1(123.25,83.3) 123.25,83.8 122.44,84.6 122.44,86.99 TP620.1
  BOTTOM w0.076: CPU1.CP36 122.08,84.75 122.87,84.75
  BOTTOM w0.102: v1(123.25,83.3) 123.29,83.3 123.42,83.42 123.42,84.2 122.87,84.75
ITP_PMODE: length 38.5
  BOTTOM w0.076: 87.85,106.64 87.79,106.4 87.79,106.2 87.81,106.12 87.94,105.99 88.09,105.99 88.38,105.7 88.51,104.81 CPU1.W4
  BOTTOM w0.102: v2(58.58,105.12) 58.58,105.12 ; 58.58,105.12 58.58,103.42 59.07,102.93 R604.2 ; 58.58,105.12 58.58,105.26 59.32,106 62.82,106 64.48,104.33 66.36,104.33 66.74,104.71 69.77,104.71 74.13,109.07 85.76,109.07 87.85,106.98 87.85,106.64
JACK_PLUG: length 20.4
  TOP w0.254: v1(18.22,8) 18.3,8 ED2911.1 ; HPMIC1.5 12.33,20.42 14.99,20.42 15.73,19.69 15.73,17.22 16.18,16.77 R2923.1 16.56,15.94 v2(16.41,15.78) 15.5,14.87 v1(15.5,14.56)
  L3 w0.254: v1(18.22,8) 16.94,8 15.71,9.23 15.69,9.23 14.85,10.08 14.85,10.1 14.8,10.15 14.8,11.46 15.4,12.06 15.4,14.45 v1(15.5,14.56)
JACK_PLUG_DET: length 12.3
  TOP w0.254: v1(17.88,20.11) 17.92,20.14 18.01,20.14 18.19,20.32 ED2912.2 18.86,20.14 18.62,19.87 18.39,19.64 18.16,19.64 17.86,19.33 R2914.1
  L3 w0.254: v1(17.88,20.11) 17.85,20.11 17.83,20.09 14.61,20.09 13.85,20.85 10.01,20.85 HPMIC1.6
JGND:
  vias: v1(15.42,126.84)
JIO3_PCIE_WAKE#: length 26.9
  TOP w0.102: v1(51.9,87.71) 51.9,87.72 51.9,89.18 50.8,90.29 49.24,90.29 48.34,91.19 48.34,92.2 R1806.2 46.68,93.85 43.14,93.85 AFTP6115.1 42.93,94.27 v1(43.51,94.84)
  BOTTOM w0.102: WLAN1.55 44.45,95.61 43.68,94.84 v1(43.51,94.84) ; D2404.2 53.34,79.3 52.53,80.11 52.53,84.15 D1702.2 53.1,86.5 v1(51.9,87.71)
KB_BL_CTRL#: length 23.7
  BOTTOM w0.102: Q6501.D 69.56,37.21 C6507.1 v2(74.12,37.21) 74.53,37.62 77.45,37.62 79.25,35.82 79.25,34.34 79.56,34.04 85.75,34.04 88.34,36.62 KBBL1.4
KB_DET#: length 313.7
  TOP w0.089: R2045.2 27.92,27.36 27.92,26.67 28.04,26.54 v2(28.12,26.54) 28.69,26.54 v1(28.78,26.63) ; AFTP6567.1 56.66,34.55 56.43,34.32 56.39,34.32 v1(56.21,34.14)
  L3 w0.089: v1(125.7,100.76) 125.7,100.79 126.19,101.27 126.95,101.27 127.32,101.64 128.46,101.64 128.65,101.84 133.65,101.84 137.04,98.45 137.93,98.45 148.75,87.62 148.97,87.62 149.3,87.62 151.95,84.98 151.95,83.97 153.05,82.86 153.05,80.45 161.19,72.32 161.19,71.73 165.74,67.18 v1(165.74,66.02)
  L4 w0.089: v1(56.21,34.14) 56.21,33.15 54.61,31.55 54.46,31.55 53.36,31.55 52.82,31.01 42.48,31.01 41.68,30.21 35.86,30.21 32.77,27.13 29.28,27.13 v1(28.78,26.63) 28.66,26.63 27.82,25.79 21.95,25.79 16.77,30.98 16.77,34.64 16.38,35.02 16.38,38.25 16.06,38.58 16.06,38.89 14.38,40.57 14.38,40.73 14.38,47.87 14.8,48.3 14.8,49.62 14.83,49.65 15.66,50.47 15.66,52.17 16.27,52.79 16.27,57.96 15.7,58.53 15.7,60.33 16.29,60.92 16.29,61.15 18.75,63.61 v1(19.18,63.61)
  BOTTOM w0.076: 125.26,100.31 125.11,100.16 124.48,100.16 124.11,99.8 123.72,99.8 123.56,99.96 122.48,99.96 122.39,99.92 122.09,99.92 121.85,100.01 121.84,100.02 121.8,100.03 121.12,100.03 CPU1.CM12
  BOTTOM w0.089: KB1.30 54.32,34.76 54.76,34.32 56.03,34.32 v1(56.21,34.14) ; 125.26,100.31 v1(125.7,100.76) ; v1(19.18,63.61) 19.81,62.99 21.47,62.99 22.4,62.06 23.04,62.06 23.58,62.59 23.68,62.59 23.68,62.59 24.65,62.59 24.79,62.73 25.56,62.73 25.67,62.62 26.57,61.72 26.57,56.4 27.36,55.61 27.36,53.56 27.65,53.28 36.73,53.28 37.56,54.1 42.58,54.1 42.92,54.44 55.64,54.44 57.59,56.39 108.75,56.39 110.16,57.81 146.16,57.81 146.72,57.25 150.44,57.25 151.1,57.9 155.63,57.9 158.44,60.71 161.16,60.71 163.02,62.58 163.02,63.3 v1(165.74,66.02)
KB_LED_BL_DET: length 147
  TOP w0.089: v1(86.03,41.2) v2(86.03,40.16) 84.39,38.52 84.39,36.58 84.71,36.26 85.98,36.26 R6508.1 R6507.1
  L4 w0.089: v1(86.03,41.2) 86.34,40.89 90.37,40.89 90.64,41.16 93.53,41.16 94.16,41.78 95.72,41.78 95.97,42.04 97.82,42.04 98.38,42.6 99.93,42.6 100.18,42.85 100.94,42.85 101.67,43.58 101.99,43.58 102.04,43.53 102.14,43.53 102.17,43.51 102.54,43.14 102.54,43.14 102.74,42.93 106.81,42.93 108.58,44.71 122.43,44.71 125.09,42.05 132.26,42.05 132.42,41.89 157.32,41.89 159.05,43.62 159.05,50.66 151.61,58.1 149.53,58.1 149.5,58.07 145.67,58.07 122.11,81.63 122.11,81.96 121.26,82.81 120.67,82.81 v1(120.27,83.21)
  BOTTOM w0.089: CPU1.CK36 119.91,84.49 119.91,83.81 120.27,83.45 v1(120.27,83.21)
KB_LED_DET_C: length 3.9
  TOP w0.102: v1(86.81,38.48) 86.88,38.56 v2(87.42,38.56) 87.42,38.54 88.09,37.87 C6508.1 88.04,37.69 R6507.2
  BOTTOM w0.089: KBBL1.2 86.34,38.01 v1(86.81,38.48)
KB_LED_PWM: length 120.3
  TOP w0.102: v1(19.89,55.45) 22.23,57.79 24.05,57.79 24.88,56.96 24.88,55.25 26.11,54.02 27.59,54.02 27.78,54.2 28.3,54.2 28.46,54.37 28.46,54.42 29.5,55.46 29.5,57.45 29.56,57.5 U2401.44 ; v2(78.88,34.13) 78.82,34.18 v1(78.82,34.81)
  L3 w0.102: v1(78.82,34.81) 78.25,34.81 73.76,30.33 42.32,30.33 41.49,29.5 41.35,29.5 34.51,29.5 34.38,29.38 32.68,29.38 32.31,29.74 30.66,29.74 30.41,29.49 30.41,29.09 30.11,28.79 27.34,28.79 27.15,28.6 25.87,28.6 25.21,29.26 24.42,29.26 24.26,29.26 21.92,31.6 21.92,31.6 21.7,31.82 21.7,37.47 22.39,38.17 22.39,40.77 21.05,42.11 21.05,43.09 19.06,45.08 19.06,45.44 19.07,45.45 19.07,45.78 19.07,49.54 19.86,50.34 19.86,50.39 19.86,55.42 v1(19.89,55.45)
  BOTTOM w0.102: Q6501.G 68.17,36.61 68.58,36.2 74.07,36.2 75.29,37.42 77.36,37.42 78.82,35.96 v1(78.82,34.81)
KBC_BEEP_R: length 2.9
  TOP w0.254: D2703.2 22.41,23.58 22.41,24.24 v2(22.02,24.63) 21.82,24.82 21.82,25.48 R2739.2
KBC_PWRBTN#: length 324.3
  TOP w0.089: RN6401.2 209.4,61.93 209.53,62.06 209.53,62.07 209.56,62.09 209.57,62.09 v1(209.83,62.35) ; v1(20.07,68.99) 19.94,68.99 19.31,69.62 19.31,70.26 19.68,70.63 19.68,71.73 R2432.1
  L3 w0.089: v1(222.88,65.15) 223.62,65.15 224.84,63.94 224.84,62.37 223.63,61.16 223.63,43.99 225.63,41.99 225.63,36.17 224.84,35.38 222.66,35.38 221.24,33.96 215.19,33.96 212.25,31.02 209,31.02 208.37,31.64 197.65,31.64 197.39,31.38 189.99,31.38 189.49,31.89 176.23,31.89 175.1,33.03 170.87,33.03 169.34,31.5 147.15,31.5 145.95,32.7 138.53,32.7 137.53,31.7 136.7,31.7 136.06,32.33 130.99,32.33 126.92,36.41 126.12,36.41 123.63,38.9 120.9,38.9 120.9,38.9 120.46,38.9 119.43,39.93 110.75,39.93 109.03,38.22 107.94,37.13 105.67,37.13 103.7,35.15 102.02,35.15 101.14,34.27 94.14,34.27 93.81,33.94 93.63,33.94 92.36,33.94 91.61,33.19 90.25,33.19 89.9,32.84 78.21,32.84 74,28.63 55.91,28.63 55.49,28.21 45.93,28.21 45.09,29.05 42.83,29.05 42.01,28.23 41.4,28.23 41.36,28.23 35.45,28.23 33.2,25.99 27.36,25.99 26.65,26.7 26.65,26.99 26.36,27.28 25.54,27.28 24.79,28.04 23.06,28.04 23.05,28.04 22.91,28.04 20.79,30.15 20.16,30.79 20.16,31.7 20.59,32.13 20.59,37.93 21.11,38.46 21.11,39.43 20.03,40.51 19.56,40.51 19.27,40.51 18.55,41.24 18.55,43.33 17.71,44.16 17.71,44.23 17.71,44.51 17.71,46.34 17.71,46.34 17.71,50.64 v1(18.21,51.14) 18.21,51.91 18.31,52.01 18.31,56.85 18.31,57 18.31,57.77 17.88,58.2 17.88,59.53 17.91,59.56 17.91,61.29 17.51,61.69 17.51,62.05 17.71,62.25 17.71,64.18 17.77,64.25 17.77,64.26 18.93,65.41 19.11,65.41 19.81,66.11 19.81,68.72 19.99,68.91 v1(20.07,68.99)
  BOTTOM w0.089: v1(209.83,62.35) 210.27,61.91 210.86,61.91 212.28,63.33 217.71,63.33 219.8,65.42 222.62,65.42 v1(222.88,65.15) 222.84,65.11 222.84,64.39 222.53,64.09 221.49,64.09 220.45,63.04 FP1.2 ; v1(18.21,51.14) 18.61,51.54 20.47,51.54 v2(20.72,51.79) 21.14,52.21 21.89,52.21 Q6408.E
KBC_PWRBTN#_C: length 27.9
  TOP w0.102: v1(211.29,58.12) 211.29,57.85 210.75,57.32 209.4,57.32 209,57.72 EC6403.1 208.87,58.85 AFTP6404.1 208.37,59.57 G6402.1 208.77,60.72 RN6401.3
  BOTTOM w0.089: ED6401.1 211.01,56.03 211.67,56.03 211.95,56.31 PWR1.2
  BOTTOM w0.102: G6401.1 224.32,61.35 217.55,61.35 216.96,61.93 213.71,61.93 212.1,60.33 212.1,59.98 211.29,59.16 v1(211.29,58.12) 211.29,58.06 211.25,58.03 211.25,57.71 211.95,57.01 PWR1.2
KSI0: length 82.1
  TOP w0.089: RN2403.5 62.49,30.58 AFTP6548.1 61.95,32.67 61.92,32.7 61.92,33.39 v1(61.76,33.55) ; U2401.98 37.15,72.87 36.59,72.3 36.05,72.3 34.67,70.91 34.67,69.08 35.72,68.03 v1(35.72,67.92)
  L2SGND w0.089: v1(61.76,33.55) 61.05,34.27 57.88,34.27 56.48,32.86 52.85,32.86 52.46,32.47 42.09,32.47 41.76,32.8 36.61,32.8 34.39,35.01 34.39,37.29 33.44,38.25 33.44,38.26 33.43,38.39 33.43,39.31 33.43,39.32 33.43,40.45 33.44,40.47 33.68,40.71 33.68,41.81 31.48,44.01 31.48,45.69 31.41,45.76 31.41,46.99 31.37,47.02 31.37,51.78 32.35,52.75 32.35,53.59 33.26,54.51 33.26,55.59 32.07,56.78 32.07,57.57 33.23,58.73 33.78,58.73 34.64,59.59 34.64,64.89 35.72,65.97 35.72,66.17 36.52,66.97 36.52,67.44 36.04,67.92 v1(35.72,67.92)
  BOTTOM w0.089: v1(61.76,33.55) 61.76,34.06 60.72,35.09 KB1.22
KSI1: length 82.6
  TOP w0.089: v1(35.41,67.36) 35.29,67.48 35.29,68.09 34.49,68.89 34.49,70.99 35.98,72.47 36.31,72.47 36.75,72.92 U2401.99 ; v1(60.91,33.33) 60.91,33.32 AFTP6547.1 61.28,32.37 61.28,30.37 61.4,30.25 RN2403.7
  L2SGND w0.089: v1(60.91,33.33) 60.15,34.09 57.96,34.09 56.55,32.68 52.93,32.68 52.53,32.29 42.02,32.29 41.68,32.62 36.53,32.62 34.22,34.94 34.22,35.68 33.26,36.64 33.26,38.25 33.26,38.25 33.26,38.38 33.26,39.24 32.84,39.65 32.84,40.82 32.64,41.02 32.64,42.01 31.77,42.88 31.44,42.88 28.15,46.17 28.15,47.99 29.86,49.7 29.86,51.05 31.74,52.93 31.74,55.38 32.12,55.76 32.12,56.46 31.9,56.69 31.9,57.65 33.16,58.91 33.71,58.91 34.46,59.67 34.46,64.97 35.41,65.91 v1(35.41,67.36)
  BOTTOM w0.089: v1(60.91,33.33) 60.91,33.86 59.87,34.9 59.25,34.9 59.12,35.03 KB1.24
KSI2: length 86.3
  TOP w0.089: U2401.6 24.31,70.49 24.76,70.94 25.47,70.94 25.51,70.9 27.21,70.9 27.39,70.71 27.39,70.4 26.92,69.93 26.92,68.29 29.41,65.79 30.9,65.79 32.82,63.88 32.82,63.53 33.24,63.12 v1(33.24,62.89) ; RN2404.5 59.92,31.09 AFTP6545.1 59.9,31.83 59.67,32.06 v1(59.67,32.74)
  L2SGND w0.089: v1(59.67,32.74) 59.67,32.13 59.33,31.8 53.29,31.8 52.87,31.37 41.68,31.37 41.32,31.73 38.08,31.73 38.07,31.73 36.14,31.73 34.76,33.12 33.8,33.12 32.85,34.07 32.85,35.64 31.67,36.81 31.67,39.73 31.36,40.04 31.35,40.05 30.9,40.51 30.9,42.15 27.26,45.78 27.26,48.46 27.56,48.76 27.56,48.85 28.8,50.08 28.8,51.25 30.85,53.3 30.85,54.91 30.56,55.2 30.56,57.97 33.14,60.55 33.22,60.55 33.58,60.9 33.58,62.55 v1(33.24,62.89)
  BOTTOM w0.089: KB1.26 57.52,35.07 58.25,34.34 59.54,34.34 60.07,33.81 60.07,33.15 v1(59.67,32.74)
KSI3: length 88.4
  TOP w0.089: v1(32.63,63.06) 32.63,63.11 32.6,63.14 32.6,63.84 30.83,65.62 29.34,65.62 26.51,68.45 26.51,70.36 26.26,70.61 25.15,70.61 24.63,70.09 U2401.7 ; AFTP6550.1 61.47,34.57 61.34,34.44 61.34,33.74 61.33,33.73 61.33,33.38 61.34,33.37 61.34,32.95 v1(61.5,32.79) 61.5,32.67 61.6,32.56 61.6,30.68 61.9,30.38 RN2403.6
  L2SGND w0.089: v1(32.63,63.06) 32.63,62.89 33.07,62.45 33.12,62.45 33.4,62.17 33.4,60.98 33.15,60.73 33.07,60.73 30.38,58.04 30.38,55.13 30.64,54.86 30.64,53.37 28.96,51.69 28.48,51.69 27.39,50.59 27.39,48.83 27.08,48.53 27.08,45.71 30.72,42.07 30.72,40.43 31.22,39.93 31.23,39.92 31.49,39.65 31.49,36.74 32.64,35.59 32.64,34.03 33.72,32.95 34.68,32.95 36.07,31.56 38,31.56 38.01,31.55 41.25,31.55 41.6,31.2 52.94,31.2 53.37,31.62 60.32,31.62 v1(61.5,32.79)
  BOTTOM w0.089: v1(61.5,32.79) 61.5,33.21 61.33,33.38 61.33,34.13 60.76,34.7 60.37,34.7 59.92,35.15 KB1.23
KSI4: length 81.8
  TOP w0.089: U2401.104 34.75,73.28 34.45,72.98 34.45,72.86 34.41,72.83 34.41,71.81 34.31,71.71 34.31,68.44 v1(34.86,67.89) ; RN2404.6 59.33,31.78 58.88,32.23 58.88,32.77 AFTP6544.1 59.13,33.01 59.13,33.17 59.29,33.33 v1(59.31,33.33)
  L2SGND w0.089: v1(59.31,33.33) 59.29,33.33 58.88,33.73 58.17,33.73 56.76,32.33 53.07,32.33 52.65,31.91 41.9,31.91 41.54,32.26 38.3,32.26 38.29,32.27 36.36,32.27 34.98,33.66 34.02,33.66 33.45,34.22 33.45,35.94 32.9,36.49 32.9,38.23 32.9,38.24 32.9,38.38 32.9,39.09 32.49,39.5 32.49,40.62 32.29,40.82 32.29,41.86 31.62,42.53 31.29,42.53 27.8,46.02 27.8,48.14 29.46,49.8 29.46,51.15 31.38,53.08 31.38,55.13 31.09,55.42 31.09,57.63 32.78,59.33 33.62,59.33 34.11,59.81 34.11,65.56 34.14,65.59 34.14,66.12 34.86,66.84 v1(34.86,67.89)
  BOTTOM w0.089: KB1.27 57.01,35.5 57.23,35.28 57.23,35.02 58.37,33.89 59.01,33.89 59.29,33.61 59.29,33.35 v1(59.31,33.33)
KSI5: length 83.5
  TOP w0.089: AFTP6546.1 60.35,33.99 v1(60.35,32.77) 60.35,31.88 60.81,31.42 RN2403.8 ; U2401.105 34.35,73.19 34.23,73.07 34.23,72.85 34.23,72.85 34.23,71.88 34.13,71.78 34.13,68.02 34.88,67.27 v1(34.88,66.12)
  L2SGND w0.089: v1(34.88,66.12) 34.88,65.66 34.29,65.07 34.29,59.74 33.63,59.09 33.09,59.09 31.72,57.72 31.72,56.61 31.94,56.39 31.94,55.89 31.56,55.51 31.56,53.01 29.67,51.12 29.67,49.76 27.97,48.07 27.97,46.1 31.36,42.71 31.69,42.71 32.46,41.93 32.46,40.94 32.67,40.74 32.67,39.57 33.08,39.16 33.08,38.38 33.08,38.25 33.08,38.24 33.08,36.56 34.04,35.6 34.04,34.87 36.46,32.45 41.61,32.45 41.94,32.11 52.61,32.11 53,32.51 56.63,32.51 58.03,33.91 59.33,33.91 60.35,32.88 v1(60.35,32.77)
  BOTTOM w0.089: v1(60.35,32.77) 60.35,34.01 59.79,34.57 58.75,34.57 58.32,35 KB1.25
KSI6: length 81.3
  TOP w0.089: v1(34.29,67.24) 34.29,67.33 33.38,68.25 33.38,72.88 33.55,73.05 U2401.107 ; RN2404.7 58.83,30.22 AFTP6543.1 57.94,31.47 58.01,31.54 58.08,31.54 58.56,32.02 58.56,33.19 v1(58.67,33.3)
  L2SGND w0.089: v1(58.67,33.3) 57.99,33.3 56.84,32.15 53.15,32.15 52.72,31.73 41.82,31.73 41.47,32.08 38.23,32.08 38.22,32.09 36.29,32.09 34.9,33.48 33.94,33.48 33.28,34.14 33.28,35.74 32.03,36.98 32.03,39.58 32.31,39.85 32.31,40.54 32.11,40.75 32.11,41.79 31.55,42.35 31.22,42.35 27.62,45.95 27.62,48.27 29.2,49.85 29.2,51.15 31.21,53.15 31.21,55.05 30.91,55.35 30.91,57.82 33.29,60.2 33.37,60.2 33.93,60.76 33.93,65.63 33.96,65.66 33.96,66.27 34.29,66.6 v1(34.29,67.24)
  BOTTOM w0.089: KB1.28 55.92,35.09 56.09,34.92 57.06,34.92 v1(58.67,33.3)
KSI7: length 82.2
  TOP w0.089: U2401.108 33.15,68.2 33.79,67.57 v1(33.79,66.85) ; RN2404.8 57.58,29.74 57.41,29.57 AFTP6542.1 56.75,30.54 58.13,31.92 v1(58.13,32.75)
  L2SGND w0.089: v1(33.79,66.85) 33.79,65.73 33.75,65.7 33.75,60.83 33.3,60.37 33.21,60.37 30.73,57.89 30.73,55.27 31.03,54.98 31.03,53.23 28.98,51.18 28.98,49.99 27.74,48.75 27.74,48.69 27.44,48.38 27.44,45.85 31.07,42.22 31.07,40.59 31.45,40.21 31.49,40.16 31.85,39.8 31.85,36.91 33.07,35.69 33.07,34.1 33.87,33.3 34.83,33.3 36.22,31.91 38.15,31.91 38.16,31.9 41.4,31.9 41.75,31.55 52.8,31.55 53.22,31.97 57.36,31.97 v1(58.13,32.75)
  BOTTOM w0.089: KB1.29 55.12,34.88 55.25,34.74 56.91,34.74 57.18,34.47 57.18,33.79 58.13,32.84 v1(58.13,32.75)
KSO0: length 107.7
  TOP w0.089: U2401.2 24.31,72.09 25.29,71.12 25.54,71.12 25.59,71.08 27.28,71.08 27.57,70.79 27.57,70.32 27.1,69.85 27.1,68.36 27.32,68.13 29.49,65.97 30.98,65.97 v1(33.32,63.64) ; v1(72.37,33.73) 73.08,33.02 AFTP6557.1 73.08,30.96 72.8,30.68 72.24,30.68 71.71,30.15 RN2410.5
  L2SGND w0.089: v1(72.37,33.73) 71.92,33.28 68.18,33.28 67.92,33.54 67.92,33.86 67.1,34.68 64.34,34.68 63.74,34.08 62.89,34.08 62.75,34.08 62.36,33.7 62.36,32.8 60.82,31.26 53.51,31.26 53.09,30.84 42.56,30.84 42.19,30.46 38.59,30.46 37.85,31.2 35.92,31.2 34.53,32.59 33.28,32.59 31.49,34.38 31.49,36.03 30.33,37.19 30.33,41.96 26.73,45.56 26.73,48.68 27.03,48.98 27.03,50.74 28.33,52.05 28.81,52.05 30.29,53.52 30.29,54.72 30.02,54.98 30.02,58.23 32.22,60.42 32.22,62.3 32.2,62.31 32.2,63.24 32.6,63.64 v1(33.32,63.64)
  BOTTOM w0.089: KB1.13 67.92,33.53 68.23,33.22 71.86,33.22 v1(72.37,33.73)
KSO1: length 90.5
  TOP w0.089: v1(30.81,64.35) 30.32,64.84 28.32,64.84 25.87,67.29 U2401.14 ; v1(66.91,34.01) 66.91,33.43 67.11,33.22 67.62,33.22 68.28,32.56 AFTP6558.1 68.28,30.91 67.47,30.1 RN2412.8
  L2SGND w0.089: v1(30.81,64.35) 31.81,63.35 31.81,62.45 32.04,62.22 32.04,60.5 29.85,58.31 29.85,54.91 30.11,54.64 30.11,53.59 28.74,52.22 28.26,52.22 26.85,50.81 26.85,49.05 26.55,48.75 26.55,45.49 30.15,41.89 30.15,37.01 31.26,35.89 31.26,34.36 33.21,32.41 34.46,32.41 35.85,31.02 37.78,31.02 38.52,30.28 42.26,30.28 42.64,30.66 53.17,30.66 53.59,31.08 60.89,31.08 62.54,32.73 62.54,33.62 62.82,33.9 63.81,33.9 64.41,34.5 65.06,34.5 65.04,34.51 66.41,34.51 v1(66.91,34.01)
  BOTTOM w0.089: v1(66.91,34.01) 66.32,34.6 KB1.15
KSO2: length 91.9
  TOP w0.089: RN2412.7 68.05,30.23 69.57,31.75 AFTP6556.1 68.09,33.08 v1(67.47,33.71) ; v1(30.1,64.36) 28.55,64.36 26.02,66.89 U2401.15
  L2SGND w0.089: v1(67.47,33.71) 67.35,33.59 66.73,33.59 65.99,34.33 65.12,34.33 65.12,34.32 64.48,34.32 63.01,32.85 62.93,32.85 60.98,30.91 53.66,30.91 53.24,30.48 42.71,30.48 42.33,30.11 38.44,30.11 37.7,30.85 35.78,30.85 34.43,32.19 32.06,32.19 30.97,33.28 30.97,35.89 29.97,36.89 29.97,41.82 26.37,45.41 26.37,48.83 26.67,49.13 26.67,50.89 28.19,52.4 28.67,52.4 29.93,53.66 29.93,54.57 29.67,54.83 29.67,58.38 31.86,60.58 31.86,62.15 31.63,62.38 31.63,63.13 30.84,63.92 30.54,63.92 v1(30.1,64.36)
  BOTTOM w0.089: v1(67.47,33.71) 67.47,34.21 67.12,34.56 KB1.14
KSO3: length 88.9
  TOP w0.089: v1(30.69,63.47) 30.27,63.89 28.76,63.89 26.17,66.49 U2401.16 ; v1(66,33.71) 66.04,33.71 66.21,33.54 66.21,33.52 66.46,33.27 66.66,33.27 67.14,32.79 AFTP6555.1 67.21,31.4 66.6,30.79 RN2409.5
  L2SGND w0.089: v1(30.69,63.47) 31.45,62.71 31.45,62.31 31.68,62.08 31.68,60.65 29.49,58.46 29.49,54.76 29.75,54.5 29.75,53.74 28.59,52.58 28.11,52.58 26.5,50.96 26.5,49.2 26.2,48.9 26.2,45.34 29.79,41.74 29.79,36.76 30.76,35.79 30.76,33.24 31.99,32.01 34.36,32.01 35.7,30.67 37.63,30.67 38.37,29.93 42.41,29.93 42.79,30.31 53.31,30.31 53.74,30.73 61.06,30.73 63,32.67 63.08,32.67 64.56,34.15 65.19,34.15 65.19,34.15 65.56,34.15 v1(66,33.71)
  BOTTOM w0.089: v1(66,33.71) 65.52,34.19 KB1.16
KSO4: length 84.3
  TOP w0.089: v1(30.06,63.47) 30.04,63.45 29.59,63.45 26.75,60.61 U2401.37 ; v1(63.99,32.26) 63.88,32.16 AFTP6551.1 64.06,30.89 RN2407.3
  L2SGND w0.089: v1(30.06,63.47) 30.5,63.03 30.86,63.03 31.28,62.61 31.28,62.23 31.5,62 31.5,60.77 29.29,58.55 29.29,54.6 28.89,54.2 28.89,53.6 28.14,52.84 28.13,52.84 26.32,51.04 26.32,49.28 26.02,48.97 26.02,45.26 29.61,41.67 29.61,36.58 30.56,35.64 30.56,33.19 31.91,31.83 34.28,31.83 35.63,30.49 37.56,30.49 38.3,29.75 42.48,29.75 42.86,30.13 53.39,30.13 53.81,30.55 61.13,30.55 63.08,32.5 63.75,32.5 v1(63.99,32.26)
  BOTTOM w0.089: v1(63.99,32.26) 63.99,33.25 62.32,34.92 KB1.20
KSO5: length 82.7
  TOP w0.089: v1(30.69,62.6) 30.26,63.03 29.7,63.03 27.15,60.48 U2401.38 ; v1(62.97,33.45) 62.84,33.33 62.84,32.82 AFTP6549.1 63.38,32.29 63.38,32.11 63.37,32.1 v1(63.37,32.07) 63.37,32.06 63.41,32.03 RN2407.4
  L2SGND w0.089: v1(30.69,62.6) 31.1,62.19 31.1,62.16 31.33,61.93 31.33,60.84 29.11,58.62 29.11,54.67 28.71,54.27 28.71,53.67 28.06,53.02 28.05,53.02 26.14,51.11 26.14,49.35 25.84,49.05 25.84,45.19 29.44,41.6 29.44,36.51 30.36,35.59 30.36,32.97 31.67,31.66 34.21,31.66 35.55,30.31 37.48,30.31 38.22,29.57 42.56,29.57 42.93,29.95 53.46,29.95 53.88,30.37 61.67,30.37 v1(63.37,32.07)
  BOTTOM w0.089: KB1.21 61.52,35.06 62.97,33.61 v1(62.97,33.45)
KSO6: length 85.6
  TOP w0.089: U2401.39 27.55,60.37 29.74,62.56 30.01,62.56 v1(30.05,62.6) ; AFTP6553.1 64.73,34.61 v1(64.73,33.72) 65.51,32.94 RN2409.7
  L2SGND w0.089: v1(30.05,62.6) 30.48,62.17 30.83,62.17 31.15,61.86 31.15,60.92 28.93,58.69 28.93,54.75 28.66,54.49 28.66,54.48 28.53,54.35 28.53,53.75 27.99,53.2 27.98,53.2 25.96,51.18 25.96,49.42 25.66,49.12 25.66,45.12 29.26,41.52 29.26,36.3 30.14,35.42 30.14,32.88 31.54,31.48 34.14,31.48 35.48,30.13 37.41,30.13 38.15,29.4 42.63,29.4 43.01,29.77 53.53,29.77 53.96,30.2 62.52,30.2 64.73,32.41 v1(64.73,33.72)
  BOTTOM w0.089: KB1.18 63.92,34.53 v1(64.73,33.72)
