# Allegro board 17938-1.1228WZS1107.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VRAM_ID2: length 7.8
  TOP w0.089: R2063.1 125.19,90.35 125.51,90.67 125.51,91.12 124.89,91.74 R2064.2 v1(124.82,92.9)
  BOTTOM w0.076: 124.25,92.48 122.86,92.48 122.79,92.55 122.46,92.55 122.37,92.52 122.13,92.52 122.08,92.53 122.06,92.56 121.91,92.59 121.84,92.59 121.73,92.7 CPU1.CN23
  BOTTOM w0.089: 124.25,92.48 124.67,92.9 v1(124.82,92.9) 125.29,92.43 v2(125.33,92.43)
VREF_CPU: length 5.9
  TOP w0.203: 40,73.2 40.78,72.42 C2406.1 40.11,72.37 39.85,72.09 U2401.95
  TOP w0.254: R2402.2 v2(40.44,74.63) 40.41,74.63 39.7,73.92 39.7,73.5 40,73.2
VREG3PD:
  vias: v2(52.86,129.08)
WHITE_LED_BAT: length 30.7
  TOP w0.127: v1(14.81,129.01) 14.43,128.62 14.43,128.15 14.44,128.14 14.44,126.16 15.18,125.42 15.87,125.42 16.54,124.75 16.54,124.3 17.32,123.52 v2(17.32,123.46) 17.32,122.58 17.8,122.1 v1(18.45,122.1)
  L4 w0.127: v1(10.7,112.02) 10.7,117.27 11.17,117.74 13.05,117.74 15.42,120.12 16.87,120.12 18.45,121.7 v1(18.45,122.1)
  BOTTOM w0.127: Q6404.C 13.03,111.23 12.22,112.04 10.72,112.04 v1(10.7,112.02) ; v1(14.81,129.01) 14.64,129.17 13.93,129.17 EC6404.1 13.39,129.52 R6406.1
WIFI_RF_EN: length 203
  TOP w0.089: v1(47.73,69.45) 47.89,69.45 47.89,69.44 48.65,69.44 50.26,71.06 50.26,71.55 52.16,73.44 52.16,80.33 52.38,80.55 52.38,83.48 53.71,84.8 53.71,92.18 53.37,92.51 53.37,97.56 50.1,100.84 47.17,100.84 AFTP6110.1 45.59,101.78 R6109.2
  L3 w0.089: v1(138.38,78.11) 138.77,77.72 139.99,77.72 v1(140.62,77.09)
  L4 w0.089: v1(138.38,78.11) 138.71,78.43 138.71,78.81 138.86,78.97 138.86,81.96 138.71,82.12 138.71,83.08 138.09,83.69 137.08,83.69 135.44,85.33 134.54,85.33 132.33,87.54 131.14,87.54 128.89,89.8 125.95,89.8 125.94,89.81 124.5,89.81 123.75,90.55 121.49,90.55 120.57,91.48 118.66,91.48 v1(118.29,91.84) ; v1(140.62,77.09) 140.7,77.09 140.83,76.96 140.83,76.81 150,67.63 150,66.68 151.52,65.16 152.88,65.16 v1(152.9,65.13)
  BOTTOM w0.089: CPU1.CG25 v1(118.29,91.84) ; v1(152.9,65.13) 149.58,65.13 146.95,67.76 124.4,67.76 122.49,69.67 77.93,69.67 73.31,65.05 52.04,65.05 47.81,69.29 47.81,69.38 v1(47.73,69.45)
WIFI_RF_EN_R: length 4.1
  TOP w0.102: v1(44.15,102.9) 44.39,102.9 44.81,103.32 R6109.1 44.92,104.03 R6114.2
  BOTTOM w0.102: WLAN1.56 44.7,103.43 44.18,102.9 v1(44.15,102.9)
WLAN_CLK_CPU_N: length 101.9
  L4 w0.114: v1(63.15,95.6) 63.15,95.19 63.05,95.09 62.73,95.09 62.61,95.2 62.61,95.89 66.5,99.78 66.5,102.14 67.58,103.22 67.58,103.57 66.75,104.39 66.75,104.58 66.9,104.73 67.06,104.73 67.9,103.89 68.25,103.89 68.55,104.19 68.55,104.54 68,105.08 68,105.24 68.16,105.41 68.33,105.41 68.87,104.86 69.22,104.86 70.03,105.67 70.19,105.67 70.63,105.23 70.98,105.23 71.28,105.52 71.28,105.87 70.84,106.32 70.84,106.48 71,106.64 71.16,106.64 71.6,106.2 71.95,106.2 72.25,106.49 72.25,106.84 71.81,107.29 71.81,107.45 72.1,107.74 72.1,108.09 71.22,108.96 71.22,109.13 71.39,109.29 71.55,109.29 73.06,107.77 73.43,107.77 73.69,108.04 73.69,108.44 72.19,109.93 72.19,110.1 72.36,110.26 72.52,110.26 73.96,108.82 74.32,108.82 74.61,109.11 74.61,109.46 73.17,110.91 73.17,111.07 73.33,111.23 73.49,111.23 74.73,109.98 75.24,109.98 76.38,111.13 100.42,111.13 101.63,109.91 101.63,109.27 102.23,108.66 102.23,108.02 102.32,107.94 v1(102.65,107.94)
  BOTTOM w0.127: v1(63.15,95.6) 62.93,95.82 62.75,95.82 62.61,95.68 62.61,95.43 62.87,95.18 62.87,95.05 62.71,94.89 62.16,94.89 61.73,95.33 61.73,97.14 61.07,97.79 60.23,97.79 60.03,97.6 57.3,97.6 54.24,96.68 51.25,93.7 47.49,93.7 47.34,93.85 44.81,93.85 44.45,93.91 43.34,94.33 42.69,94.98 42.69,96.33 42.95,96.59 WLAN1.49 ; CPU1.BC1 103.35,106.81 103.18,106.97 103.18,108.11 103.08,108.21 102.92,108.21 v1(102.65,107.94)
WLAN_CLK_CPU_P: length 101.9
  L4 w0.114: v1(63.14,94.65) 62.93,94.86 62.63,94.86 62.39,95.11 62.39,95.98 66.27,99.87 66.27,102.23 67.35,103.31 67.35,103.47 66.52,104.3 66.52,104.67 66.81,104.96 67.16,104.96 68,104.12 68.16,104.12 68.32,104.28 68.32,104.44 67.77,104.99 67.77,105.34 68.07,105.63 68.42,105.63 68.97,105.09 69.13,105.09 69.93,105.9 70.28,105.9 70.73,105.45 70.89,105.45 71.05,105.62 71.05,105.78 70.61,106.22 70.61,106.57 70.9,106.87 71.26,106.87 71.7,106.43 71.86,106.43 72.02,106.59 72.02,106.75 71.58,107.19 71.58,107.54 71.87,107.83 71.87,107.99 71,108.87 71,109.22 71.29,109.52 71.64,109.52 73.16,108 73.34,108 73.46,108.13 73.46,108.34 71.97,109.84 71.97,110.19 72.26,110.49 72.61,110.49 74.05,109.05 74.23,109.05 74.38,109.2 74.38,109.36 72.94,110.81 72.94,111.16 73.23,111.46 73.58,111.46 74.83,110.21 75.14,110.21 76.29,111.35 100.51,111.35 101.86,110.01 101.86,109.36 v1(102.65,108.57)
  BOTTOM w0.127: v1(102.65,108.57) 102.77,108.45 103.18,108.45 103.42,108.21 103.42,107.07 103.68,106.82 103.68,106.56 CPU1.BC2 ; v1(63.14,94.65) 62.06,94.65 61.48,95.23 61.48,97.04 60.97,97.55 60.33,97.55 60.13,97.36 57.34,97.36 54.36,96.47 51.35,93.46 47.39,93.46 47.24,93.61 44.78,93.61 44.39,93.68 43.21,94.12 42.8,94.53 42.45,94.88 WLAN1.47
WLAN_EN#: length 12.2
  TOP w0.102: 53.09,107.8 52.53,107.24 51.06,107.24 50.41,106.59 v2(50.37,106.59) 50.05,106.59 v1(49.81,106.83) 50.22,107.24 50.22,108.51 Q6102.D
  BOTTOM w0.102: U6101.4 55.15,106.99 49.96,106.99 v1(49.81,106.83)
WLAN_PCIE_RX_N10: length 101.4
  L3 w0.114: v1(60.7,96.39) 60.29,95.98 60.11,95.98 59.97,96.13 59.97,97.22 62.18,99.43 62.18,105.34 63.82,106.98 63.82,108.34 71.89,116.41 101.2,116.41 102.22,115.39 107.89,115.39 109.38,113.91 109.38,113.67 109.38,109.87 109.07,109.57 109.07,105.13 109.46,104.74 109.46,103.08 109.62,102.92 v1(109.93,102.92)
  BOTTOM w0.127: CPU1.BN6 109.9,102.92 v1(109.93,102.92) ; WLAN1.43 41.45,96.6 41.31,96.46 41.31,94.52 42.61,93.23 47.08,93.23 47.23,93.08 51.6,93.08 54.52,96 60.2,96 60.3,96.09 60.3,96.29 60.4,96.39 v1(60.7,96.39)
WLAN_PCIE_RX_P10: length 101.5
  L3 w0.114: v1(109.91,103.59) 109.69,103.81 109.69,104.84 109.3,105.23 109.3,109.48 109.47,109.65 109.6,109.78 109.6,113.57 109.6,114.01 107.99,115.62 102.31,115.62 101.3,116.64 71.79,116.64 63.59,108.43 63.59,107.07 61.95,105.43 61.95,99.53 59.74,97.31 59.74,96.04 60.02,95.76 60.55,95.76 v1(60.65,95.66)
  BOTTOM w0.127: v1(60.65,95.66) 60.55,95.75 54.62,95.75 51.7,92.84 47.13,92.84 46.98,92.99 42.51,92.99 41.07,94.42 41.07,96.48 40.95,96.6 WLAN1.41 ; CPU1.BN5 v1(109.91,103.59)
WLAN_PCIE_TX_CON_N: length 2.3
  BOTTOM w0.127: WLAN1.37 39.95,96.6 39.82,96.47 39.82,95.66 C6107.1
WLAN_PCIE_TX_CON_P: length 2.3
  BOTTOM w0.127: C6108.1 39.58,95.7 39.58,96.47 39.45,96.6 WLAN1.35
WLAN_PCIE_TX_N10: length 105.5
  L3 w0.114: v1(60.53,94.49) 60.27,94.75 60.1,94.75 59.97,94.63 59.97,94.2 59.84,94.08 59.62,94.08 59.19,94.5 59.19,97.32 61.56,99.69 61.56,105.79 63.16,107.39 63.16,108.53 71.61,116.98 101.5,116.98 102.51,115.96 108.18,115.96 109.65,114.5 110.17,114.5 110.75,113.93 110.75,111.11 111.01,110.85 111.24,110.85 v1(111.45,110.64)
  BOTTOM w0.076: CPU1.BR4 110.67,104.91 110.44,105.14 110.39,105.25 110.39,105.47 110.26,105.79 110.24,105.8 110.24,106.1 110.27,106.18 110.27,106.4 110.25,106.45 110.24,106.48 110.24,106.85 110.51,107.12 110.87,107.12 111.65,107.9 111.65,107.95 111.66,107.96
  BOTTOM w0.127: 111.66,107.96 111.7,108 111.7,110.39 v1(111.45,110.64) ; C6107.2 40.07,94.15 40.01,94.09 39.65,94.09 39.53,93.96 39.53,93.36 40.29,92.6 46.82,92.6 46.97,92.45 51.87,92.45 54.5,95.09 58.08,95.09 59.07,94.1 60.14,94.1 v1(60.53,94.49)
WLAN_PCIE_TX_P10: length 105.6
  L3 w0.114: v1(111.5,111.28) 111.3,111.08 111.1,111.08 110.98,111.2 110.98,114.02 110.26,114.73 109.74,114.73 108.28,116.19 102.61,116.19 101.59,117.21 71.51,117.21 62.93,108.63 62.93,107.48 61.33,105.88 61.33,99.78 58.97,97.41 58.97,94.4 59.52,93.85 60.52,93.85 v1(60.53,93.85)
  BOTTOM w0.076: 111.83,107.79 111.81,107.77 111.77,107.77 110.95,106.94 110.59,106.94 110.42,106.78 110.42,106.51 110.45,106.43 110.45,106.15 110.42,106.07 110.42,105.86 110.57,105.51 110.57,105.42 CPU1.BR3
  BOTTOM w0.127: C6108.2 39.29,93.26 40.19,92.36 46.72,92.36 46.87,92.21 51.97,92.21 54.6,94.85 57.98,94.85 58.97,93.85 v1(60.53,93.85) ; v1(111.5,111.28) 111.94,110.84 111.94,107.9 111.83,107.79
WWAN_BB_RST#: length 126.9
  TOP w0.089: v1(207.46,54.9) 207.44,54.91 v2(207.44,55.75) 207.6,55.91 209.53,55.91 209.83,56.21 210.85,56.21 211.33,56.69 213.09,56.69 213.33,56.45 215.93,56.45 216.32,56.06 216.32,55.48 216.89,54.9 216.89,53.37 217.21,53.05 WWAN1.16
  L3 w0.089: v1(207.46,54.9) 206.75,54.9 205.88,55.77 205.58,55.77 204.57,55.77 204.5,55.7 201.66,55.7 201.35,55.39 192.89,55.39 191.56,54.06 179.83,54.06 179.42,54.46 179.32,54.57 177.64,54.57 177.34,54.57 177.28,54.5 177.27,54.5 177.04,54.27 177.04,54.27 176.7,53.93 174.06,53.93 173.95,54.04 173.95,54.04 158.37,69.62 158.37,70.97 153.13,76.21 152.28,76.21 152.11,76.37 152.1,76.37 149.03,79.45 149.03,81.56 146.36,84.23 146.36,85.06 144.89,86.52 144.86,86.52 142.9,88.48 142.9,88.5 142.87,88.53 142.87,88.79 138.41,93.24 137.78,93.24 137.35,92.82 130.96,92.82 129.68,94.1 123.7,94.1 123.2,94.59 119.43,94.59 119.15,94.86 119.15,95.12 118.69,95.58 117.99,95.58 v1(117.5,96.06)
  BOTTOM w0.089: CPU1.CF17 117.5,96.42 v1(117.5,96.06)
WWAN_CLKREQ_CPU_N: length 137.3
  TOP w0.089: v1(206.2,53.45) 206.68,53.93 v2(206.68,54.1) 206.68,56.59 207.22,57.13 207.6,57.13 207.8,56.92 211,56.92 211.17,57.09 213.03,57.09 213.03,57.08 213.2,57.08 213.48,56.8 216.07,56.8 216.67,56.2 216.67,55.62 217.24,55.05 WWAN1.20 ; v1(118.03,87.33) 118.03,87.26 118.26,87.04 118.26,77.87 118.54,77.59 118.54,77.27 118.94,76.86 119.48,76.86 120.02,77.41 120.02,77.46 120.37,77.81 121.5,77.81 R1825.2
  L2SGND w0.089: v1(206.2,53.45) 205.67,53.98 204.27,53.98 204,54.25 199.8,54.25 198.35,55.71 176.66,55.71 175.89,54.94 172.27,54.94 172.17,55.04 172.17,55.04 157.58,69.63 157.58,71.39 153.04,75.92 150.47,75.92 146.92,79.48 146.92,80.32 146.59,80.64 146.59,81.13 145.83,81.89 144.95,81.89 144.93,81.87 144.58,81.87 144.56,81.89 144.29,81.89 141.56,84.62 137.94,84.62 134.84,87.73 127.82,87.73 127.32,87.23 121.2,87.23 120.98,87.46 120.98,87.81 120.73,88.06 119.89,88.06 119.34,87.5 118.2,87.5 v1(118.03,87.33)
  BOTTOM w0.089: v1(118.03,87.33) 117.87,87.33 CPU1.CF31
WWAN_DB_DET#: length 280.4
  TOP w0.089: v1(208.79,63.7) 208.96,63.53 R1922.2 ; v1(161.19,68.68) 161.67,68.68 163.12,67.24 163.12,64.03 v2(164.2,62.95) 164.2,61.04 v1(164.99,60.26) ; v1(207.44,56.66) 207.71,56.39 R6201.1
  L3 w0.089: v1(207.44,56.66) 206.87,56.66 206.72,56.81 204.94,56.81 204.31,57.43 202.28,57.43 201.87,57.43 200.74,56.29 192.52,56.29 191.18,54.96 180.24,54.96 179.73,55.47 178.01,55.47 176.96,55.47 176.9,55.41 176.67,55.18 176.67,55.18 176.33,54.84 174.43,54.84 163.17,66.1 163.17,66.21 163.17,66.22 163.17,67.11 161.94,68.34 161.6,68.68 v1(161.19,68.68) 161.14,68.73 161.14,69.14 159.32,70.96 159.32,71.29 153.5,77.11 152.65,77.11 152.49,77.27 152.47,77.27 149.93,79.81 149.93,82.32 v1(148.73,83.52)
  BOTTOM w0.076: CPU1.CH36 118.71,84.45 118.71,84.28 arc(118.73,84.19) 118.78,84.12 118.95,83.94 118.95,83.82
  BOTTOM w0.089: v1(164.99,60.26) 164.56,60.26 161.4,57.1 156.59,57.1 155.74,56.25 148.78,56.25 148.34,56.69 146.32,56.69 145.84,57.18 110.28,57.18 108.97,55.86 57.81,55.86 55.86,53.91 43.14,53.91 42.78,53.55 37.79,53.55 37.21,52.97 37.18,52.97 36.95,52.74 R2403.2 ; v1(148.73,83.52) 148.73,83.37 147.74,82.37 147.74,81.64 147.58,81.48 147.58,80.53 147.31,80.26 147.31,77.46 146.79,76.94 145.85,76.94 144.38,75.47 127.79,75.47 123.82,79.45 123.81,79.45 122.34,80.92 122.34,81.08 120.98,82.44 119.91,82.44 119.51,82.84 119.49,82.84 119.02,83.3 119.02,83.32 118.95,83.39 118.95,83.82 ; v1(207.44,56.66) 207.44,58.92 207.95,59.44 207.95,62.31 208.77,63.12 208.77,63.68 v1(208.79,63.7)
WWAN_DB_DET#_R: length 11.1
  TOP w0.089: R6201.2 209.43,56.57 v2(210.52,56.57) 210.93,56.57 211.25,56.88 213.15,56.88 213.41,56.62 216,56.62 216.49,56.13 216.49,55.55 217.07,54.97 217.07,53.7 217.22,53.55 WWAN1.17
WWAN_FULL_PWR_EN: length 5.9
  TOP w0.102: v1(123.65,92.88) 123.47,93.06 123.47,93.69 123.68,93.9 125.21,93.9 R2051.1
  BOTTOM w0.076: v1(123.65,92.88) 123.26,93.28 122.82,93.28 122.58,93.03 121.2,93.03 CPU1.CM23
WWAN_FULL_PWR_EN_D8: length 7
  TOP w0.102: R2067.1 125.13,94.62 124.93,94.42 121.81,94.42 120.93,93.54 119.95,93.54 119.53,93.96 v1(119.48,93.96)
  BOTTOM w0.102: CPU1.CJ22 119.32,93.8 v1(119.48,93.96)
WWAN_FULL_PWR_EN_R: length 132.1
  TOP w0.102: v2(216.59,49.12) WWAN1.8 218.14,49.05 218.44,49.35 218.44,51.98 218.56,52.21 218.56,52.8 218.87,53.11 220.27,53.11 221.2,54.04 221.2,57.6 v1(219.93,58.86) ; R2067.2 126.13,94.59 R2051.2 126.7,93.27 v1(126.7,93.27)
  L3 w0.102: v1(205.57,54.97) 205.57,54.62 205.32,54.37 202.17,54.37 201.7,54.84 193.12,54.84 191.73,53.46 179.62,53.46 179.12,53.95 177.5,53.95 177.27,53.72 177.27,53.72 176.84,53.29 173.84,53.29 156.62,70.51 156.62,71.88 152.85,75.65 152.04,75.65 148.44,79.25 148.44,81.2 145.25,84.39 145.21,84.39 143.97,85.62 143.01,85.62 142.57,86.07 142.51,86.13 142.29,86.35 142.29,87.27 141.46,88.1 141.46,88.16 139.96,89.66 133.89,89.66 131.75,91.8 127.94,91.8 127.43,92.3 127.43,92.5 126.7,93.23 v1(126.7,93.27)
  L4 w0.102: v1(205.57,54.97) 206.84,54.97 208.47,56.61 214.32,56.61 214.58,56.87 214.58,57.25 v1(214.58,57.25)
  BOTTOM w0.102: v1(214.58,57.25) 214.58,57.25 215.04,56.8 216.6,56.8 217.78,57.97 217.78,58.22 218.42,58.86 v1(219.93,58.86)
WWAN_GPIO_PERST#: length 125
  TOP w0.089: v1(207.8,53.44) 207.8,54.16 v2(209.08,55.44) 209.37,55.44 209.96,56.03 210.92,56.03 211.4,56.51 213.02,56.51 213.26,56.27 215.85,56.27 216.14,55.98 216.14,55.4 216.71,54.83 216.71,53.2 217.35,52.55 WWAN1.15
  L3 w0.089: v1(119.1,92.96) 119.12,92.98 119.12,93.06 119.54,93.47 121.27,93.47 122.39,92.36 124.48,92.36 124.56,92.27 127.03,92.27 127.87,91.43 131.69,91.43 133.74,89.38 139.95,89.38 141.26,88.08 141.26,88.02 142.08,87.2 142.08,86.28 142.37,86 142.43,85.93 142.8,85.56 142.8,85.55 142.92,85.43 142.92,85.31 144.04,84.19 145.17,84.19 148.24,81.12 148.24,79.17 151.95,75.46 152.76,75.46 153.08,75.13 153.08,75.13 156.29,71.93 156.29,70.56 173.76,53.09 176.92,53.09 177.35,53.53 177.35,53.53 177.58,53.75 179.02,53.75 179.45,53.32 179.51,53.26 191.82,53.26 193.2,54.64 201.62,54.64 202.09,54.17 206.66,54.17 206.74,54.09 207.15,54.09 v1(207.8,53.44)
  BOTTOM w0.089: v1(119.1,92.96) 119.1,93 CPU1.CH22
WWAN_PCIE_CLK_N: length 164.8
  TOP w0.114: v1(216.51,57.86) 216.7,58.05 WWAN1.26
  L3 w0.114: v1(216.51,57.86) 216.33,58.04 215.99,58.04 215.08,58.94 212.92,58.94 212.48,59.38 210.11,59.38 208.94,60.55 204.68,60.55 203.69,61.53 191.75,61.53 188.92,58.71 181.8,58.71 181.29,59.22 178.92,59.22 168.74,69.41 168.74,71.28 158.13,81.88 158.13,85.27 136.32,107.07 136.32,112.62 135.36,113.58 124.3,113.58 118.6,119.29 118.6,120.07 v1(119.05,120.52)
  BOTTOM w0.076: CPU1.BE1 104.36,106.73 104.36,107.17 104.14,107.39 104.14,108.77 103.84,109.07 103.84,110.3 103.43,110.71 103.39,110.71 103.38,110.72
  BOTTOM w0.127: v1(119.05,120.52) 118.21,119.69 112.93,119.69 112.07,120.55 107.88,120.55 107.27,120.55 106.27,119.56 106.27,119.2 106,118.92 103.64,118.92 103.1,118.39 103.1,110.99 103.38,110.72
WWAN_PCIE_CLK_P: length 164.9
  TOP w0.114: v1(216.49,58.5) 216.49,58.5 216.54,58.55 WWAN1.27
  L3 w0.114: v1(119.36,119.94) 119.26,120.04 118.95,120.04 118.83,119.91 118.83,119.38 124.39,113.81 135.45,113.81 136.55,112.71 136.55,107.16 158.36,85.36 158.36,81.98 168.96,71.37 168.96,69.5 179.01,59.45 181.38,59.45 181.89,58.94 188.83,58.94 191.65,61.76 203.79,61.76 204.77,60.78 209.04,60.78 210.2,59.61 212.58,59.61 213.02,59.17 215.18,59.17 216.08,58.27 216.3,58.27 216.49,58.46 v1(216.49,58.5)
  BOTTOM w0.076: CPU1.BE2 104.73,106.22 104.73,106.77 104.54,106.96 104.54,107.25 104.32,107.47 104.32,108.84 104.02,109.14 104.02,110.38 103.56,110.83 103.56,110.87 103.55,110.89
  BOTTOM w0.127: 103.55,110.89 103.34,111.09 103.34,118.29 103.74,118.68 106.1,118.68 106.52,119.1 106.52,119.46 107.37,120.31 107.88,120.31 111.97,120.31 112.83,119.44 118.31,119.44 118.95,120.08 119.22,120.08 v1(119.36,119.94)
WWAN_PCIE_RX_N: length 155.1
  TOP w0.127: v1(216.46,59.77) 216.46,59.87 216.59,60 216.78,60 217.23,59.55 WWAN1.29
  L4 w0.114: v1(216.46,59.77) 216,60.22 215.74,60.22 215.45,59.94 215.45,59.41 215.11,59.07 212.96,59.07 212.65,59.38 206.07,59.38 204.95,58.26 190.45,58.26 188.66,56.47 179.73,56.47 175.74,60.47 173.32,60.47 169.81,63.97 169.81,64.4 163.92,70.3 163.53,70.3 161.21,72.62 161.21,74.49 155.62,80.08 155.62,82.56 155.88,82.82 155.88,85.78 142.22,99.45 142.22,103.15 137.7,107.67 137.7,112.86 135.94,114.61 124.34,114.61 122.79,116.16 118.21,116.16 116.17,114.12 116.17,107.58 113.1,104.52 113.1,102.93 114.05,101.98 114.14,101.98 114.2,101.98 v1(114.51,102.29)
  BOTTOM w0.127: v1(114.51,102.29) 114.23,102.32 114.08,102.21 114.06,102.03 CPU1.BY8
WWAN_PCIE_RX_P: length 155.2
  TOP w0.127: v1(216.44,60.45) 216.65,60.24 216.89,60.24 217.08,60.05 WWAN1.30
  L4 w0.114: v1(114.51,101.64) 113.95,101.75 112.87,102.83 112.87,104.61 115.94,107.68 115.94,114.22 118.11,116.39 122.89,116.39 124.43,114.84 136.04,114.84 137.93,112.95 137.93,107.77 142.45,103.24 142.45,99.54 156.11,85.88 156.11,82.73 155.85,82.47 155.85,80.17 161.43,74.59 161.43,72.71 163.62,70.52 164.01,70.52 170.04,64.5 170.04,64.07 173.42,60.69 175.83,60.69 179.82,56.7 188.57,56.7 190.36,58.49 204.85,58.49 205.97,59.61 212.74,59.61 213.06,59.3 215.01,59.3 215.22,59.51 215.22,60.03 215.64,60.45 v1(216.44,60.45)
  BOTTOM w0.127: CPU1.BY9 v1(114.51,101.64)
WWAN_PCIE_TX_N: length 148.6
  TOP w0.127: C6201.1 214.08,61.13 213.86,60.9 213.86,60.07 v1(214.01,59.92)
  L4 w0.114: v1(114.91,111.23) 115.37,111.69 115.37,114.45 117.88,116.97 123.17,116.97 124.71,115.43 136.52,115.43 139.09,112.85 139.09,108.38 143.06,104.42 143.06,99.74 157.03,85.77 157.03,79.83 162.01,74.85 162.01,72.95 163.86,71.1 164.25,71.1 164.37,71.1 170.67,64.8 170.67,64.25 173.65,61.27 176.08,61.27 180.07,57.27 188.33,57.27 190.14,59.08 204.59,59.08 206.27,60.76 210.98,60.76 211.51,61.29 213.64,61.29 214.01,60.91 v1(214.01,59.92)
  BOTTOM w0.076: 114.14,108.64 114.14,108.62 114.17,108.59 114.17,107.82 113.96,107.61 113.96,106.49 CPU1.CA2
  BOTTOM w0.127: 114.14,108.64 114.14,110.78 114.41,111.05 114.73,111.05 v1(114.91,111.23)
WWAN_PCIE_TX_N_C: length 3.2
  TOP w0.127: WWAN1.32 217.41,61.05 217.28,61.18 217.08,61.18 216.72,61.55 216.72,61.89 216.64,61.96 216.37,61.96 216.03,61.63 216.03,61.62 215.83,61.42 215.71,61.42 C6201.2
WWAN_PCIE_TX_P: length 148.7
  TOP w0.127: C6202.1 213.62,61 213.62,60.17 v1(213.37,59.92)
  L4 w0.114: v1(114.91,110.43) 115.6,111.13 115.6,114.36 117.98,116.74 123.07,116.74 124.61,115.2 136.43,115.2 138.86,112.76 138.86,108.29 142.83,104.33 142.83,99.65 156.8,85.68 156.8,79.74 161.78,74.76 161.78,72.85 163.76,70.87 164.16,70.87 164.28,70.87 170.44,64.71 170.44,64.16 173.56,61.04 175.99,61.04 179.98,57.05 188.42,57.05 190.23,58.85 204.69,58.85 206.36,60.53 211.07,60.53 211.6,61.06 213.54,61.06 213.78,60.82 213.78,60.33 v1(213.37,59.92)
  BOTTOM w0.076: 114.38,108.64 114.38,108.62 114.35,108.59 114.35,107.74 114.14,107.53 114.14,106.87 CPU1.CA1
  BOTTOM w0.127: v1(114.91,110.43) 114.91,110.68 114.78,110.81 114.51,110.81 114.38,110.68 114.38,108.64
WWAN_PCIE_TX_P_C: length 3.1
  TOP w0.127: WWAN1.33 217.43,61.55 217.33,61.45 217.15,61.45 216.96,61.65 216.96,61.99 216.74,62.21 216.27,62.21 215.78,61.71 215.6,61.71 C6202.2
WWAN_PCIE_WAKE_N: length 16.1
  TOP w0.089: WWAN1.21 218.19,55.55 218.82,54.92 219.87,54.92 220.3,55.34 220.3,56.53 219.05,57.78 219.05,59.49 219.33,59.77 219.33,60.12 219.17,60.28 219.17,64.53 219.87,65.23 220.98,65.23 TP6201.1
WWAN_USB20_N: length 151.4
  TOP w0.127: v2(213.87,57.46) v1(213.96,58.02) 213.96,58.28 214.1,58.42 214.28,58.42 R6203.1
  L4 w0.089: v1(115.54,101.63) 115.54,101.46 115.36,101.27 115.21,101.27 115.12,101.36 115.12,103.86 115.55,104.29 115.61,104.29 115.65,104.34
  L4 w0.114: 115.65,104.34 117.1,105.78 117.1,109.04 117.51,109.46 117.51,114.41 118.69,115.59 122.46,115.59 124,114.04 135.65,114.04 137.06,112.63 137.06,107.5 141.58,102.98 141.58,99.24 141.71,99.11 155.31,85.51 155.31,83.22 155.05,82.96 155.05,79.81 160.63,74.23 160.63,72.38 163.29,69.72 163.68,69.72 169.24,64.16 169.24,63.74 174.25,58.73 176.65,58.73 179.48,55.9 188.9,55.9 190.69,57.69 195.28,57.69 196,56.97 200.86,56.97 201.49,57.6 203.31,57.6 203.79,57.12 207.81,57.12 207.93,57 212.08,57 213.13,58.04 213.3,58.04 213.55,57.79 213.73,57.79 v1(213.96,58.02)
  BOTTOM w0.127: CPU1.CB8 115.03,101.75 115.25,101.53 115.44,101.53 v1(115.54,101.63)
WWAN_USB20_N_R: length 3.3
  TOP w0.127: 216.11,57.28 216.58,56.81 217,56.81 217.07,56.75 217.07,56.68 217.19,56.55 WWAN1.23 ; 216.11,57.28 215.89,57.5 215.66,57.5 215.46,57.69 R6203.2 ; 216.11,57.28 v2(216,57.18)
WWAN_USB20_P: length 151.1
  TOP w0.127: v2(213.43,59.06) v1(213.54,58.5) R6202.1
  L4 w0.089: 115.49,104.5 115.47,104.48 114.93,103.94 114.93,101.28 115.14,101.07 v1(115.59,100.94)
  L4 w0.114: v1(213.54,58.5) 213.09,58.33 211.99,57.23 208.03,57.23 207.91,57.35 203.88,57.35 203.4,57.83 201.4,57.83 200.76,57.2 196.09,57.2 195.37,57.92 190.59,57.92 188.8,56.13 179.57,56.13 176.75,58.95 174.35,58.95 169.47,63.83 169.47,64.26 163.78,69.95 163.38,69.95 160.86,72.48 160.86,74.32 155.28,79.9 155.28,82.86 155.54,83.12 155.54,85.6 142.03,99.11 141.81,99.33 141.81,103.07 137.29,107.59 137.29,112.72 135.74,114.27 124.1,114.27 122.55,115.82 118.59,115.82 117.28,114.51 117.28,109.55 116.87,109.14 116.87,105.88 115.49,104.5
  BOTTOM w0.127: CPU1.CB9 v1(115.59,100.94)
WWAN_USB20_P_R: length 3.3
  TOP w0.127: WWAN1.24 216.68,57.05 215.94,57.79 215.94,58.27 215.85,58.5 R6202.2
XCLK_BIASREF: length 13.5
  BOTTOM w0.127: R1803.1 127.87,115.16 v2(127.56,114.86) 127.16,114.45 126.05,114.45 119.04,107.44 119.04,106.7 CPU1.CJ1
XDP_CLK_CPU_N: length 4.8
  BOTTOM w0.127: TP1808.1 101.22,110.52 100.59,109.88 100.59,108.46 99.5,107.37 99.5,106.71 CPU1.AU1
XDP_CLK_CPU_P: length 4.2
  BOTTOM w0.127: TP1807.1 100.35,109.36 100.35,108.56 99.26,107.47 99.26,106.3 CPU1.AU2
XDP_DBRESET#: length 21.7
  TOP w0.102: R1701.2 117.53,93.12 118.14,93.73 118.14,93.75 118.14,93.76 118.14,94.09 117.59,94.65 v2(117.59,95.4) 117.1,95.9 117.1,96.23 117.34,96.47 121.89,96.47 123.92,98.5 124.45,98.5 124.58,98.63 124.58,99.63 125.25,100.31 126.11,100.31 126.35,100.54 v1(126.35,100.83)
  BOTTOM w0.076: CPU1.CN10 121.6,100.77 121.71,100.77 121.8,100.74 122.03,100.74 122.1,100.76 122.39,100.76 122.42,100.75 122.45,100.74 123.06,100.74 123.31,100.99 123.44,100.99 123.58,101.13 123.63,101.13
  BOTTOM w0.102: v1(126.35,100.83) 126.01,101.17 123.67,101.17 123.63,101.13
XDP_TCK_JTAGX: length 21.1
  L4 w0.127: v1(85.93,103.49) 84.68,103.49 83.58,104.59 80.22,104.59 80.1,104.46 78.71,104.46 78.71,104.46 78.17,104.46 77.12,104.46 71,98.34 70.42,98.34 v1(70.15,98.07)
  BOTTOM w0.14: R315.1 70.89,98.07 v1(70.15,98.07) 69.93,98.07 v2(69.47,97.61) ; CPU1.P6 v1(85.93,103.49)
XDP_TCLK: length 21.1
  TOP w0.14: v1(71.66,99.9) 71.66,99.39 R317.1
  L4 w0.127: v1(71.66,99.9) 76.65,104.9 79.4,104.9 79.52,105.02 82.66,105.02 82.75,105.11 84.92,105.11 85.37,104.65 86.01,104.65 86.35,104.31 86.35,103.99 v1(86.85,103.49)
  BOTTOM w0.14: v2(72.06,99.16) 71.66,99.57 v1(71.66,99.9) ; v1(86.85,103.49) 86.62,103.27 CPU1.T6
XDP_TDI: length 24.1
  TOP w0.14: v2(88.25,103.17) 88.09,103.17 v1(87.78,103.49)
  L4 w0.127: v1(69.52,99.26) 69.93,99.26 76,105.34 79.23,105.34 79.34,105.45 82.46,105.45 82.75,105.74 86.07,105.74 87.36,104.45 87.36,103.9 v1(87.78,103.49)
  BOTTOM w0.14: v1(69.52,99.26) 69.54,99.25 R311.1 ; CPU1.U6 v1(87.78,103.49)
XDP_TDO_CPU: length 28.1
  L4 w0.127: v1(69.75,101.3) 69.75,101.7 71.2,103.15 72.54,103.15 77.33,107.94 85.86,107.94 v1(89.63,104.17)
  BOTTOM w0.14: R310.1 72.39,101.07 70.99,101.07 v2(70.55,101.51) 69.96,101.51 v1(69.75,101.3) ; CPU1.Y5 89.58,104.11 89.59,104.15 v1(89.63,104.17)
XDP_TMS: length 25.4
  L4 w0.127: v1(68.88,96.9) 68.88,97.71 76.28,105.11 79.31,105.11 79.43,105.23 82.56,105.23 82.85,105.53 85.98,105.53 86.32,105.18 86.32,104.84 v1(86.82,104.34)
  BOTTOM w0.14: v1(68.88,96.9) 68.34,97.44 v2(68.23,97.44) 67.45,97.44 R309.1 ; v1(86.82,104.34) CPU1.T5
XDP_TRST#: length 3.5
  TOP w0.14: R316.1 89.2,104.37 89.2,103.93 v1(89.63,103.5) 89.95,103.18 v2(90.14,103.18)
  BOTTOM w0.14: CPU1.Y6 89.62,103.48 v1(89.63,103.5) 89.63,103.48 CPU1.AB6
XTL_24M_X1_CPU: length 17
  BOTTOM w0.14: CPU1.CK3 120.08,105.61 120.09,105.62 120.09,105.95 120,106.04 120,106.33 120.34,106.67 120.42,106.67 120.8,107.05 120.8,107.6 121.14,107.94 122.02,107.94 122.4,108.32 122.86,108.32 127.29,112.75 129.5,112.75 131.7,114.95 R1839.1
XTL_24M_X1_R: length 3.6
  BOTTOM w0.14: R1839.2 131.88,115.85 R1841.1 131.89,115.95 132.53,115.95 C1807.2 132.54,116.55 X1801.1
XTL_24M_X2_CPU: length 15.7
  BOTTOM w0.127: CPU1.CK2 119.47,106.13 119.47,106.7 119.69,106.92 119.78,106.92 119.92,107.06 119.92,107.42 119.98,107.48
  BOTTOM w0.14: 119.98,107.48 120.77,108.27 121.9,108.27 126.93,113.3 128.82,113.3 130.1,114.59 R1840.1
XTL_24M_X2_R: length 5.1
  BOTTOM w0.14: X1801.3 131.56,118.5 131.22,118.17 131.22,116.8 130.83,116.41 130.68,116.41 130.36,116.08 C1808.2 R1841.2 131.02,115.22 R1840.2
XTL_32K_X1_CPU: length 36.2
  TOP w0.14: X1802.1 137.63,79.46 C1804.1 136.7,78.53 R1815.1 136.13,77.2 134.78,77.2 134.53,77.45 v1(134.53,77.72)
  L3 w0.127: v1(134.53,77.72) 134.37,77.88 134.37,78.51 133.95,78.93 133.95,79.29 133.1,80.14 127.48,80.14 124.88,82.74 124.55,82.74 124.31,82.98 123.61,82.98 123.46,82.83 123.03,82.83 122.82,83.04 122.46,83.04 122.45,83.05 122.04,83.05 121.79,82.81 120.46,82.81 120.45,82.79 119.49,82.79 119.36,82.67 116.48,82.67 116.17,82.98 116.17,83.26 115.3,84.13 112.25,84.13 110.29,86.09 110.29,86.93 v1(109.82,87.4)
  BOTTOM w0.14: CPU1.BN31 v1(109.82,87.4)
XTL_32K_X2_CPU: length 36.2
  TOP w0.14: X1802.2 135.17,78.96 C1803.1 135.83,78.29 R1815.2 135.23,77.76 v1(135.16,77.7)
  L3 w0.127: v1(135.16,77.7) 135.03,77.57 135.03,77.51 134.74,77.21 134.32,77.21 134.22,77.31 134.16,77.31 133.34,78.12 133.34,78.2 133.32,78.22 133.32,78.59 133.34,78.61 133.34,79.18 132.89,79.63 127.27,79.63 124.67,82.23 124.56,82.23 124.17,82.61 123.14,82.61 122.72,82.2 122.11,82.2 121.73,82.58 120.54,82.58 120.54,82.58 119.62,82.58 119.49,82.45 116.32,82.45 115.86,82.91 115.86,83.24 115.21,83.9 112.11,83.9 111.32,84.69 111.14,84.69 110.96,84.51 110.77,84.51 110.59,84.68 110.59,84.86 110.78,85.05 110.78,85.23 110.6,85.4 110.42,85.4 110.24,85.23 110.01,85.23 109.86,85.38 109.86,85.57 110.06,85.76 110.06,85.94 109.78,86.22 v1(109.78,86.64)
  BOTTOM w0.14: CPU1.BN32 v1(109.78,86.64)

## Copper pours and planes (outline as drawn)
1V_CPU_CORE on TOP: outline of 94 points within 84.66,89.71 105.08,130.58 ; 77 cut-outs
1V_CPU_CORE on BOTTOM: 96.98,89.79 96.88,89.89 96.88,92.43 97.03,92.58 105.41,92.58 105.46,92.53 105.46,92.1 105.39,92.03 105.39,90.96 105.87,90.48 105.87,90.04 105.62,89.79
1V_CPU_CORE on BOTTOM: 93.07,113.69 91.72,115.04 85.22,115.04 84.72,115.53 84.72,119.36 85.07,119.7 85.07,121.21 86.67,122.81 86.67,125.6 85.6,126.67 85.6,130.38 85.73,130.51 88.24,130.51 88.4,130.35 88.4,129.87 88.47,129.8 89.56,129.8 89.61,129.85 89.61,130.33 89.87,130.58 94.97,130.58 95.13,130.43 95.13,129.95 95.35,129.72 96.9,129.72 97.01,129.82 97.01,130.4 97.16,130.56 100.49,130.56 100.57,130.47 100.57,122.82 98.07,120.32 98.07,114.58 97.18,113.69 ; 4 cut-outs
1V_CPU_CORE on BOTTOM: 97.34,100 96.83,100.51 96.83,101.53 96.95,101.65 97.97,101.65 98.35,102.03 98.35,103.56 98.22,103.68 98.22,103.94 98.61,104.32 103.69,104.32 104.57,103.43 104.57,101.78 104.7,101.65 105.34,101.65 105.46,101.53 105.46,100.13 105.34,100
1V_CPU_CORE on L2SGND: 103.66,101.58 104.22,101.02 105.03,101.02 105.34,100.71 105.34,92.03 104.97,91.66 97.32,91.66 96.12,92.86 92.38,92.86 92.15,92.64 91.23,92.64 91.1,92.76 91.1,99.34 87.59,102.85 87.59,107.13 85.44,109.28 85.44,113.04 84.76,113.72 84.76,114.45 84.79,114.48 84.79,115.67 85.09,115.98 100.92,115.98 103.66,113.23 ; 7 cut-outs
1V_CPU_CORE on L3: 105.46,100.94 105.46,100.41 105.1,100.04 105.1,91.88 104.87,91.65 97.42,91.65 96.46,92.61 96.45,92.61 96.14,92.91 92.48,92.91 92.18,92.61 91.57,92.61 91.21,92.96 91.21,95.35 89.46,97.1 89.46,100.97 87.58,102.85 87.58,107.09 85.46,109.21 85.46,113.11 84.67,113.89 84.67,115.23 84.69,115.24 84.69,115.88 84.89,116.08 100.35,116.08 101.98,114.44 102.58,114.44 103.71,113.31 103.71,101.7 104.35,101.07 105.34,101.07 ; 7 cut-outs
1V_CPU_CORE on L4: 103,107.11 99.27,107.11 98.48,106.33 98.48,103.23 96.04,100.79 96.04,98.43 94.31,96.7 94.31,93.04 94.67,92.69 95.61,92.69 96.98,91.31 104.83,91.31 105.11,91.59 105.11,99.29 105.49,99.67 105.49,100.46 105.67,100.64 105.67,100.97 104.73,101.91 104.73,102.26 104.3,102.69 104.3,103.66 105.44,104.8 105.44,107.09 105.06,107.47 103.36,107.47
1V_GT_CORE on TOP: 89.89,98.38 89.8,98.46 89.8,99.81 89.61,99.99 89.26,99.99 88.91,100.35 88.91,102.46 88.99,102.54 89.92,102.54 90.05,102.67 90.05,103 90.48,103.43 90.66,103.43 90.66,105.31 89.84,106.12 88.6,106.12 87.79,106.93 87.79,107.29 88.09,107.6 94.85,107.6 95.18,107.26 95.48,107.26 95.58,107.16 95.58,106.91 93.96,105.28 93.96,103.18 93.95,103.17 93.95,102.58 93.78,102.41 93.32,102.41 93.3,102.39 93.3,100.53 93.65,100.18 94.98,100.18 95.14,100.02 95.14,98.82 95.12,98.8 91.82,98.8 91.39,98.38
1V_GT_CORE on BOTTOM: 88.7,100 88.57,100.13 88.57,100.89 88.7,101.02 88.83,101.02 89.08,101.27 89.08,102.29 89.33,102.54 96.32,102.54 96.7,102.16 96.7,101.53 96.19,101.02 96.19,100.26 95.94,100
1V_VCCGT on TOP: outline of 89 points within 72.11,92.91 91.32,131.98 ; 47 cut-outs
1V_VCCGT on BOTTOM: 75.51,115.15 71.16,119.5 71.16,125.69 72.62,127.15 72.62,130.48 72.65,130.51 72.65,131.37 72.77,131.5 74.7,131.5 75.39,130.81 78.16,130.81 78.34,130.63 78.34,129.85 78.46,129.72 79.68,129.72 79.73,129.77 79.73,130.46 79.89,130.61 82.38,130.61 82.86,130.13 82.86,126.77 82.02,125.93 82.02,123.06 84,121.08 84,119.46 84.33,119.13 84.33,115.51 83.97,115.15
1V_VCCGT on BOTTOM: 77.65,94.67 76.76,95.56 76.76,103.81 77.4,104.45 77.78,104.45 78.29,104.95 78.29,105.59 78.84,106.15 79.15,106.15 79.4,105.89 79.4,105.74 80.57,104.57 82.22,104.57 82.48,104.32 82.48,103.18 82.6,103.05 85.14,103.05 85.14,102.92 85.52,102.54 88.7,102.54 88.83,102.41 88.83,101.4 88.7,101.27 88.19,101.27 87.94,101.02 87.94,100.64 87.43,100.13 83.52,100.13 83.29,99.9 83.29,94.87 83.09,94.67
1V_VCCGT on L2SGND: 75.68,96 75.36,96.32 73.97,96.32 73.16,97.14 73.16,103.3 72.52,103.94 72.52,104.45 73.54,105.46 73.54,114.35 75.19,116 84,116 84.33,115.67 84.33,113.34 85.04,112.62 85.04,109.25 87.46,106.83 87.46,102.72 90.96,99.21 90.96,93.57 90.33,92.94 80.24,92.94 80.06,93.12 80.06,94.69 79.68,95.07 77.5,95.07 77.32,95.25 77.32,95.78 77.09,96.01 76.84,96.01 76.83,96
1V_VCCGT on L3: 85.11,109.23 87.46,106.88 87.46,102.52 88.95,101.02 88.95,97 91.12,94.83 91.12,91.21 90.4,90.49 84.89,90.49 83.82,91.55 83.82,93.17 83.06,93.93 78.64,93.93 77.45,95.13 76.84,95.13 76.23,95.73 75.92,95.73 75.14,96.52 73.36,96.52 73.16,96.72 73.16,103.33 72.42,104.07 72.42,104.45 73.38,105.41 73.38,114.33 75.42,116.36 82.68,116.36 82.68,116.36 83.76,116.36 84.24,115.88 84.24,114.82 84.23,114.81 84.23,113.51 85.11,112.63
1V_VCCIO on TOP: 105.95,89.74 105.55,90.13 105.55,91.26 105.8,91.5 105.86,91.5 106.06,91.7 106.06,92.12 105.98,92.2 105.98,92.49 106.07,92.58 107.19,92.58 107.34,92.43 107.34,92.2 107.06,91.92 107.06,90.32 107.32,90.07 107.32,89.87 107.19,89.74 ; 1 cut-out
1V_VCCIO on TOP: 94.44,90.98 94.31,91.11 94.31,91.44 94.19,91.57 94.19,92.1 94.08,92.2 93.65,92.2 93.58,92.28 93.58,92.94 93.63,92.99 94.72,92.99 95.02,92.69 95.24,92.69 95.98,91.95 95.98,91.73 95.79,91.54 95.79,91.06 95.71,90.98 ; 2 cut-outs
1V_VCCIO on BOTTOM: 95.81,89.84 95.05,90.6 95.05,91.29 94.31,92.03 94.31,92.66 94.49,92.84 95.86,92.84 96.83,91.87 96.83,90.22 96.45,89.84
1V_VCCIO on BOTTOM: 106.99,113.34 106.73,113.59 106.73,117.32 108.08,118.67 120.7,118.67 121.77,117.6 121.77,115.62 121.62,115.47 119.05,115.47 118.98,115.55 114.48,115.55 114.23,115.8 110.4,115.8 110.18,115.57 110.18,114.09 109.45,113.36 108.28,113.36 108.26,113.34 ; 4 cut-outs
1V_VCCIO on BOTTOM: 105.97,89.71 105.97,92.51 106.1,92.64 106.99,92.64 107.24,92.38 107.24,89.84 107.11,89.71
1V_VCCIO on L2SGND: 95.43,89.61 98.05,89.61 98.81,90.37 102.67,90.37 103,90.04 103,89.74 103.13,89.61 106.94,89.61 106.96,89.64 107.19,89.64 107.34,89.79 107.34,91.31 107.15,91.5 107.15,92.06 107.34,92.25 107.34,92.51 107.19,92.66 105.74,92.66 105.59,92.51 105.59,91.85 105.27,91.53 97.3,91.53 96.09,92.74 94.47,92.74 94.31,92.58 94.31,90.73
1V_VCCIO on L3: 94.97,91.03 94.97,90.22 95.41,89.79 98.3,89.79 98.5,89.99 98.5,90.17 98.73,90.4 102.75,90.4 103.36,89.79 107.29,89.79 107.37,89.87 109.02,89.87 109.55,90.4 109.55,94.57 110.14,95.15 110.67,95.15 110.87,95.35 110.87,99.09 111.66,99.87 111.66,102.08 111.2,102.54 109.86,102.54 109.27,101.96 109.07,101.96 108.77,102.26 108.77,103.25 109.01,103.49 109.01,103.6 109.1,103.68 109.1,104.57 108.51,105.16 108.51,114.28 107.7,115.09 104.33,115.09 103.97,114.72 103.97,107.09 103.84,106.96 103.84,101.73 104.4,101.17 105.29,101.17 105.57,100.89 105.57,100.18 105.39,100 105.39,91.87 105.06,91.54 97.29,91.54 96.04,92.79 94.44,92.79 94.29,92.64 94.29,91.72
1V_VCCIO on L4: 107.75,89.64 105.9,89.64 105.49,90.04 105.49,99.14 106,99.65 108.51,99.65 108.87,99.29 108.87,97.77 109.3,97.33 110.09,97.33 110.65,96.78 110.65,96.47 110.42,96.24 109.22,96.24 108.97,95.99 108.97,93.12 109.38,92.71 109.38,90.96 108.79,90.37 108.28,90.37 107.88,89.97 107.88,89.76
1V_VCCSA on TOP: 107.39,91.7 107.32,91.77 107.32,92.08 107.42,92.18 107.42,92.48 107.22,92.69 106.1,92.69 105.84,92.94 105.84,98.63 105.27,99.2 105.27,99.65 104.83,100.09 104.83,102.57 104.6,102.57 104.42,102.74 104.42,105.08 103.94,105.56 103.94,113.97 104.73,114.76 104.73,126.47 104.14,127.05 104.14,129.25 104.5,129.61 105.75,129.61 106.32,130.18 109.78,130.18 109.81,130.2 110.04,130.2 110.24,130 110.24,126.52 109.22,125.5 109.22,119.31 108.93,119.01 108.93,115.28 109.22,114.99 109.22,114.99 109.22,108.75 108.92,108.45 108.92,104.8 109.58,104.15 109.58,100.81 109.22,100.46 108.79,100.46 107.52,99.19 107.52,93.55 108.23,92.84 108.89,92.84 109.21,92.52 109.21,92.14 108.77,91.7 ; 16 cut-outs
1V_VCCSA on BOTTOM: 107.6,89.76 107.42,89.94 107.42,92.43 107.6,92.61 108.99,92.61 109.35,92.25 109.35,91.47 109.58,91.24 109.58,91.09 109.35,90.86 108.66,90.86 108.23,90.43 108.23,89.82 108.18,89.76
1V_VCCSA on BOTTOM: 104.53,126.62 104.27,126.88 104.27,129.35 104.55,129.64 104.86,129.64 105.34,130.13 110.11,130.13 110.16,130.07 110.16,126.93 109.85,126.62
1V_VCCSA on BOTTOM: 105.72,99.99 105.55,100.17 105.55,100.46 105.62,100.54 105.62,102.04 106.06,102.47 108.26,102.47 108.74,102 108.74,100.56 108.16,99.99
1V_VCCSA on L2SGND: 105.46,101.07 105.46,100.05 105.48,100.04 105.48,93.16 105.67,92.97 107.27,92.97 107.55,92.69 107.55,92.28 107.27,92 107.27,91.72 107.47,91.52 109.15,91.52 109.32,91.7 109.32,92.61 109.99,93.27 109.99,95.18 109.97,95.19 109.97,96.89 109.32,97.54 109.32,98.55 108.64,99.24 108.64,102.97 108.97,103.3 108.97,104.78 108.64,105.11 108.64,108.05 107.47,109.22 107.47,113.95 106.76,114.66 105.01,114.66 103.86,113.51 103.86,106.83 103.79,106.76 103.79,102.26 103.8,102.25 103.8,101.79 104.32,101.27 105.24,101.27 105.25,101.28
1V_VCCST_CPU on TOP: 109.88,99.7 109.53,100.05 109.53,100.43 109.73,100.64 109.73,104.12 109.17,104.67 109.17,108.48 109.38,108.69 109.38,115.11 109.08,115.4 109.08,118.66 110.51,120.09 110.51,124.23 110.24,124.49 110.24,126.3 110.4,126.46 110.4,127.16 110.98,127.74 112.08,127.74 112.18,127.63 112.18,127.3 112.06,127.17 111.32,127.17 111.04,126.89 111.04,124.57 111.08,124.53 111.08,119.76 110.14,118.82 110.14,116.95 109.88,116.69 109.88,115.75 111.62,114 111.62,113.7 111.64,113.69 111.64,99.95 111.38,99.7 ; 3 cut-outs
1V_VCCST_CPU on BOTTOM: 109.87,99.74 109.65,99.96 109.65,100.5 109.8,100.65 111.41,100.65 111.56,100.5 111.56,100.04 111.26,99.74
1V_VCCST_CPU_R on BOTTOM: 114.15,125.43 113.86,125.71 112.94,125.71 112.93,125.72 112.02,125.72 111.94,125.81 111.94,126.39 112.16,126.61 112.82,126.61 113.03,126.82 113.03,127.23 113.26,127.46 114.84,127.46 115.17,127.13 115.17,125.48 115.12,125.43 ; 1 cut-out
5V_3V_TPAN_PWR on TOP: 208.64,42.37 208.51,42.5 208.51,44.48 208.84,44.81 208.92,44.81 209.3,45.19 209.3,45.67 209.4,45.77 209.65,45.77 209.91,46.03 210.42,46.03 210.59,45.85 210.59,45.31 210.49,45.21 210.11,45.21 209.95,45.06 209.95,44.78 209.2,44.03 209.2,43.64 209.94,42.9 209.94,42.43 209.87,42.37 ; 1 cut-out
5V_3V_TPAN_PWR on BOTTOM: 210.7,45.06 210.62,45.14 210.16,45.14 209.96,45.34 209.96,45.92 210.06,46.03 210.98,46.03 211.28,45.72 211.28,45.09 211.25,45.06
5V_FAN_VCC on BOTTOM: 158.22,88.42 158.17,88.47 158.17,90.7 158.35,90.88 160.12,90.88 160.81,91.57 160.81,92.1 161.62,92.91 161.62,93.93 161.8,94.11 162.44,94.11 162.51,94.03 162.51,93.55 162.79,93.27 163.17,93.27 163.27,93.17 163.27,92.46 163.07,92.25 162.23,92.25 161.67,91.7 161.67,90.96 161.39,90.68 161.22,90.68 160.18,89.64 160.18,89.41 159.62,88.85 159.62,88.47 159.57,88.42 ; 2 cut-outs
5V_HDD_S0 on TOP: 159.95,37.34 159.59,37.69 159.59,38.25 159.45,38.39 159.45,40.22 159.78,40.55 161.1,40.55 161.34,40.31 161.34,37.69 160.99,37.34 ; 3 cut-outs
5V_HDD_S0 on BOTTOM: 160.48,38.08 160.48,39.47 160.38,39.57 159.49,39.57 159.38,39.69 159.38,40.15 159.76,40.53 161.65,40.53 161.83,40.36 161.83,38.1 161.8,38.08
5V_ODD_S0 on TOP: 185.14,33.83 184.89,34.09 184.89,35.41 185.17,35.69 189.56,35.69 190.12,35.13 190.43,35.13 190.58,34.98 190.58,34.47 189.94,33.83 ; 3 cut-outs
5V_ODD_S0 on BOTTOM: 185.68,34.01 185.35,34.34 185.35,35.13 185.75,35.54 187.58,35.54 187.66,35.46 187.66,34.11 187.56,34.01
5V_ODD_S0 on BOTTOM: 188.5,34.52 188.37,34.64 188.37,35.91 188.5,36.04 189.97,36.04 190.66,35.35 190.66,34.67 190.5,34.52
5V_S0 on TOP: 158.7,36.17 157.53,37.34 157.53,39.65 157.84,39.96 158.96,39.96 159.29,39.63 159.29,37.39 159.57,37.11 159.57,36.35 159.39,36.17 ; 1 cut-out
5V_S0 on TOP: 175.21,30.58 174.76,31.04 174.76,31.78 174.55,31.98 174.15,31.98 173.55,32.58 172.43,32.58 170.36,34.65 168.68,34.65 168.28,35.05 168.28,36.48 169.17,37.36 172.16,37.36 176.46,33.07 180.98,33.07 181.33,33.43 183.49,33.43 183.7,33.63 188.12,33.63 188.32,33.43 188.32,33.3 188.5,33.12 190.61,33.12 191.17,32.56 191.17,31.51 190.25,30.58 ; 6 cut-outs
5V_S0 on TOP: 99.06,39.47 98.83,39.7 98.28,39.7 98.2,39.78 98.2,40.72 98.21,40.73 98.21,41.16 98.3,41.25 100.16,41.25 100.46,40.95 100.46,39.78 100.16,39.47 ; 1 cut-out
5V_S0 on TOP: 32.69,19.86 32.59,19.96 32.59,27.03 33.28,27.71 33.28,29.34 34.19,30.25 34.19,30.28 35.56,31.65 40.31,31.65 40.9,31.07 40.9,29.54 40.52,29.16 37.23,29.16 35.72,27.65 35.72,19.93 35.66,19.86
5V_S0 on TOP: 79.33,34.7 79.1,34.93 79.1,35.92 77.65,37.36 76.41,37.36 75.72,36.68 74.17,36.68 72.7,35.21 67.15,35.21 66.97,35.02 62.31,35.02 62.03,35.3 62.03,37.73 63.27,38.96 65.15,38.96 65.89,38.23 75.7,38.23 76.28,38.81 78.44,38.81 80.32,36.93 80.32,34.98 80.04,34.7 ; 4 cut-outs
5V_S0 on BOTTOM: 61.34,36.02 61.22,36.14 61.22,37.14 61.26,37.17 62.12,37.17 62.26,37.31 62.98,37.31 63.2,37.53 63.2,38.33 63.3,38.43 64.13,38.43 64.21,38.35 64.21,37.57 64.67,37.11 64.67,36.17 64.51,36.02
5V_S0 on L4: 63.1,37.97 63.17,37.9 66.81,37.9 67.44,37.26 71.35,37.26 72.72,38.63 90.05,38.63 90.33,38.91 97.08,38.91 99.22,41.05 100.84,41.05 101.1,40.79 101.1,40.13 101.26,39.96 102.1,39.96 102.69,40.55 108.61,40.55 109.12,40.03 109.12,38.36 105.17,34.4 91.25,34.4 91.12,34.27 56.19,34.27 56.19,33.5 54.38,31.7 53.09,31.7 52.76,31.37 42.65,31.37 41.71,30.43 38.64,30.43 38.13,30.94 38.13,32.44 39.37,33.68 51.64,33.68 55.15,37.19 55.6,37.19 56.39,37.97
5V_S0 on L5SGND: 156.27,35.36 155.53,36.09 154.01,36.09 152.73,37.37 99.09,37.37 98.2,38.26 98.2,41.25 98.68,41.73 168.57,41.73 169.6,40.7 169.6,38.3 170.06,37.84 170.06,36.39 169.39,35.72 169.3,35.63 161.07,35.63 160.8,35.36 ; 1 cut-out
5V_S5 on TOP: 140.53,84.58 140.48,84.63 140.48,85.03 140.53,85.08 141.44,85.08 141.87,85.51 142.58,85.51 142.72,85.38 142.72,84.78 142.52,84.58 ; 1 cut-out
5V_S5 on TOP: 43.82,121.57 43.58,121.81 43.58,122.72 43.56,122.73 43.56,123.12 43.31,123.37 43.06,123.37 42.98,123.45 42.98,124.23 43.13,124.39 43.44,124.39 43.56,124.51 43.56,125.42 43.67,125.53 44,125.53 44.4,125.94 45.56,125.94 45.73,125.77 46.32,125.77 46.33,125.76 46.33,125.48 45.75,125.48 45.59,125.33 45.59,124.4 45.67,124.32 46.26,124.32 46.36,124.22 46.36,123.78 46.28,123.69 44.83,123.69 44.62,123.48 44.62,122.64 44.71,122.56 44.71,121.62 44.66,121.57 ; 4 cut-outs
5V_S5 on TOP: outline of 138 points within 18.95,31.83 72.64,134.3 ; 7 cut-outs
5V_S5 on TOP: 110.7,28.2 110.42,28.47 110.42,29.31 110.62,29.52 111.05,29.52 111.36,29.21 111.36,28.25 111.31,28.2 ; 1 cut-out
5V_S5 on TOP: 146.08,134.32 143.79,136.6 143.79,142.65 144.83,143.69 146.69,143.69 147.02,143.36 147.02,139.5 148.39,138.13 148.39,135.08 147.63,134.32
5V_S5 on BOTTOM: 21.03,121.26 20.6,121.69 20.6,123.28 21.29,123.97 24.45,123.97 25.68,125.2 40.9,125.2 42.15,126.45 42.15,128.62 47.76,134.22 55.03,134.22 56.52,135.71 62.26,135.71 64.14,133.83 64.45,133.83 64.69,133.6 64.69,131.36 64.46,131.14 61.39,131.14 61.06,131.47 61.06,132.13 60.79,132.41 57.92,132.41 56.72,131.22 54.41,131.22 54,130.81 50.14,130.81 48.47,129.13 48.47,127.33 44.07,122.94 41.94,122.94 41.91,122.96 36.91,122.96 36.22,123.65 33.38,123.65 33.15,123.88 29.47,123.88 27.94,122.35 25.53,122.35 24.44,121.26 ; 4 cut-outs
5V_S5 on BOTTOM: 17.76,33.5 17.52,33.75 17.52,36.59 17.61,36.68 18.37,36.68 18.57,36.88 18.57,39.83 18.74,39.99 19.93,39.99 20.45,39.47 20.45,38.94 20.02,38.51 20.02,35.94 19.36,35.28 19.36,33.71 19.15,33.5 ; 2 cut-outs
5V_S5 on BOTTOM: 63.92,89.27 61.61,91.59 61.61,92.89 62.18,93.46 62.85,93.46 65.19,91.12 68.81,91.12 69.3,90.63 69.3,89.5 69.07,89.27
5V_S5 on BOTTOM: 49.03,34.98 47.76,36.25 47.76,40.06 48.36,40.67 51.06,40.67 51.51,40.21 55.01,40.21 55.11,40.31 55.11,40.97 55.17,41.03 55.53,41.03 55.59,40.97 55.59,39.59 55.93,39.24 56.56,39.24 58.64,37.16 59.79,37.16 59.83,37.13 59.83,36.16 59.71,36.05 56.25,36.05 56.05,36.25 56.05,36.74 55.83,36.96 55.35,36.96 54.99,37.31 54.11,37.31 53.88,37.09 51.74,37.09 51.41,36.76 51.41,35.21 51.18,34.98 ; 15 cut-outs
5V_S5 on BOTTOM: 193.72,38.2 193.19,38.73 193.19,39.89 193.25,39.95 195.12,39.95 195.46,39.61 195.46,38.2 195.45,38.2
5V_S5 on L2SGND: 215.19,38.96 215.19,37.72 214.76,37.29 214.28,37.29 213.82,37.75 208.26,37.75 206.43,35.92 204.37,35.92 202.72,37.57 201.58,37.57 201.2,37.95 196.52,37.95 196.36,38.11 195.21,38.11 194.72,38.61 193.88,38.61 193.3,39.19 193.3,40.62 193.83,41.15 201.53,41.15 202.06,40.62 205.44,40.62 206,40.06 214.1,40.06
5V_S5 on L2SGND: 48.64,34.98 46.89,36.73 46.89,38.53 46.38,39.04 38.15,39.04 35.7,41.49 35.7,42.08 34.42,43.36 34.17,43.36 33.91,43.61 33.66,43.61 32.77,44.5 32.77,46.28 33.28,46.79 33.28,52.76 34.72,54.2 34.72,56.64 35.13,57.05 35.13,57.06 35.27,57.2 35.56,57.2 36.83,55.93 38.87,55.93 42.1,59.17 42.1,63.01 43.23,64.14 44.73,64.14 45.88,62.99 45.88,61.47 35.13,50.73 35.13,44.25 37.98,41.4 51.26,41.4 53.27,39.4 57.81,39.4 57.97,39.55 58.37,39.55 59.51,38.41 60.99,38.41 61.14,38.25 61.14,36.19 60.84,35.89 51.84,35.89 50.93,34.98
5V_S5 on L2SGND: 71.15,112.16 68.53,112.16 64.59,108.22 64.59,104.89 65.64,103.84 68.54,103.84 71.74,107.04 71.74,111.57
5V_S5 on L2SGND: 159.9,112.29 159.9,110.14 155.53,105.77 155.53,96.93 162.21,90.25 167.85,90.25 168.89,91.29 168.89,95.25 168.28,95.86 162.97,95.86 160.3,98.53 160.3,102.34 163.96,106 163.96,106.76 166.14,108.94 166.14,112.29 164.49,113.95 161.55,113.95
5V_S5 on L3: 64.91,108.06 64.91,105.02 65.6,104.34 68.06,104.34 70.88,107.16 70.88,111.03 70.08,111.84 68.69,111.84
5V_S5 on L3: 20.12,39.47 20.32,39.47 20.55,39.24 20.55,39.04 20.37,38.86 19.94,38.86 19.74,38.66 19.74,33.73 19.56,33.55 18.98,33.55 18.85,33.68 18.85,39.09 19.12,39.36 20.01,39.36
5V_S5 on L3: 51.98,39.26 56.24,39.26 56.56,38.94 56.95,38.94 57.28,39.27 57.28,39.44 59,39.44 59.45,39 59.45,36.04 59.1,35.69 51.64,35.69 50.93,34.98 48.64,34.98 47.76,35.87 47.76,39.3 47.37,39.68 43.06,39.68 42.42,39.04 41.41,39.04 41.15,38.79 39.12,38.79 38.87,39.04 37.47,39.04 37.21,39.3 37.21,41.07 37.47,41.33 39.5,41.33 40.39,40.44 40.77,40.44 41.53,41.2 50.04,41.2
5V_S5 on L3: 54.33,77.19 54.05,77.47 54.05,90.93 55.93,92.81 60.89,92.81 61.83,93.75 62.54,93.75 62.77,93.52 62.77,93.17 61.55,91.95 57.2,91.95 55.2,89.94 55.2,77.27 55.12,77.19
5V_S5 on L4: 157.13,111.89 158.42,111.89 159.06,111.25 160.1,111.25 161.88,113.03 161.88,116.74 159.39,119.23 159.39,123.19 159.31,123.26 159.31,123.87 155.12,128.07 155.12,130.28 149.41,135.99 148.62,135.99 148.61,135.98 146.78,135.98 145.8,135 145.8,134.37 148.08,132.08 148.08,122.2 149.81,120.47 149.81,120.02 152.2,117.63 154.49,117.63 155.68,116.43 155.68,113.34
5V_S5 on L4: 13.64,111.62 11.2,109.18 11.2,108.44 12.02,107.62 12.7,107.62 15.12,105.21 15.12,99.49 15.62,98.99 19.69,98.99 19.82,99.11 19.82,100.64 19.56,100.89 18.04,100.89 17.66,101.27 17.66,106.05 16.65,107.05 16.65,110.49 18.02,111.86 18.02,116.02 21.64,119.64 21.64,122.53 21.36,122.82 20.04,122.82 16.32,119.1 14.94,119.1 13.64,117.81
5V_S5 on L4: 37.34,41.33 39.63,41.33 40.39,40.57 40.9,40.57 41.53,41.2 50.04,41.2 52.33,38.91 52.33,36.37 50.93,34.98 48.64,34.98 47.76,35.87 47.76,39.3 47.37,39.68 43.06,39.68 42.42,39.04 41.41,39.04 41.15,38.79 39.12,38.79 38.87,39.04 37.6,39.04 37.21,39.42 37.21,41.2
5V_S5 on L5SGND: 160.01,114.47 162.44,116.89 162.44,121.21 163.83,122.61 163.83,147.37 162.82,148.39 152.78,148.39 148.22,143.82 147.53,143.71 147.27,143.64 147.15,143.31 147.16,142.76 146.69,142.29 145.67,142.29 145.16,142.8 145.16,144.96 142.62,147.5 136.38,147.5 135.74,148.13 130.25,148.13 127.77,145.64 121.72,145.64 119.48,147.88 107.45,147.88 105.18,145.62 95.48,145.62 93.58,147.52 75.59,147.52 66.04,137.97 66.04,136.15 64.75,134.85 64.75,131.45 64.67,131.37 60.91,131.37 60.61,131.67 60.61,136.81 61.14,137.34 61.14,138.51 68.23,145.59 68.23,146.74 68.24,146.75 68.24,147.05 72.47,151.28 73.92,151.28 73.94,151.31 96.78,151.31 99.19,148.9 103.89,148.9 106.18,151.18 120.25,151.18 121.9,149.12 123.12,148.52 124.39,148.24 126.01,148.36 126.93,148.79 127.64,149.38 128.12,150.09 129.04,151.69 166.75,151.69 167.77,150.67 167.77,113.23 164.7,110.16 160.81,110.16 160.01,110.96
5V_S5 on L5SGND: 213.92,38.69 217.98,38.69 221.3,42.01 221.3,49.28 220.67,49.92 220.67,59.84 222.53,61.71 222.53,64.27 221.44,65.36 219.94,65.36 219.21,64.62 219.15,64.62 219.13,64.64 202.85,64.64 202.49,64.29 202.49,64.25 189.79,64.25 188.01,62.47 183.98,62.47 181.8,64.65 181.8,65.16 165.55,81.41 165.55,86.41 163.83,88.13 163.83,93.09 165.08,94.34 165.08,95.51 165.46,95.89 168.4,95.89 168.75,95.75 168.89,95.4 168.89,82.8 169.33,81.73 170.4,81.29 170.88,81.29 171.1,81.24 171.28,81.08 178.19,74.04 187,69.58 188.12,69.01 189.01,68.12 189.55,67.66 190.24,67.49 207.15,67.49 207.9,67.69 208.64,68.43 208.88,68.49 217.25,68.49 217.64,68.54 218,68.69 220.77,70.29 221.13,70.44 221.52,70.49 225,70.49 226.05,70.05 226.49,69 226.49,37.97 226.34,37.09 226.01,36.12 225.63,35.59 225.2,35.03 224.64,34.52 223.88,34.04 223.22,33.78 222.51,33.63 221.59,33.51 215.91,33.51 215.83,33.51 215.76,33.5 214.96,33.5 213.62,34.84 213.62,38.38
5V_TPAN_PWR on BOTTOM: 216.51,42.85 216.02,43.35 216.02,43.7 215.85,43.87 214.46,43.87 214.25,44.07 214.25,44.35 213.54,45.06 212.68,45.06 212.65,45.09 212.65,45.67 212.7,45.72 213.87,45.72 213.99,45.61 215.2,45.61 215.7,45.11 216.16,45.11 216.65,44.62 216.65,43.91 217.1,43.46 217.1,43.16 216.79,42.85
5V_TPAN_VDD on TOP: 221.49,40.98 221.02,41.45 220.25,41.45 220.14,41.56 220.14,42.65 219.96,42.83 219.96,43.08 219.6,43.45 219.6,43.77 219.7,43.87 220.75,43.87 221.16,43.46 221.16,42.7 221.39,42.47 222.63,42.47 222.79,42.32 222.79,41.78 222.24,41.24 222.23,41.24 221.98,40.98 ; 2 cut-outs
5V_USB30_VCCA on TOP: 12.78,33.4 12.47,33.71 12.47,35.84 14.96,38.33 16.23,38.33 16.63,37.94 17.02,37.94 17.4,37.56 17.4,35.92 18.09,35.23 18.39,35.23 18.77,34.85 18.77,33.99 18.34,33.55 14.74,33.55 14.58,33.4 ; 3 cut-outs
5V_USB30_VCCA on BOTTOM: 15.66,35.88 15.5,36.04 15.5,38.79 15.78,39.07 17.28,39.07 17.3,39.04 17.3,36.01 17.17,35.88 ; 2 cut-outs
19V_AD+ on TOP: 32.67,128.17 32.64,128.2 30.23,128.2 30.1,128.32 30.1,131.44 29.56,131.98 29.56,134.25 29.58,134.26 30.72,134.26 30.78,134.21 30.78,133.47 30.95,133.29 32.93,133.29 33.03,133.19 33.03,132.74 32.94,132.65 32.68,132.65 32.46,132.44 32.46,131.93 33.26,131.13 36.29,131.13 36.45,130.97 36.45,128.27 36.35,128.17 ; 6 cut-outs
20V_DCBATOUT on BOTTOM: 196.37,52.61 196.1,52.88 191.32,52.88 190.33,53.87 190.33,55.6 190.17,55.75 188.46,55.75 188.29,55.58 188.29,55.03 188,54.74 186.57,54.74 186.53,54.78 186.53,59.96 186.56,60 190.83,60 193.89,56.94 193.89,55.7 194.19,55.4 195,55.4 195.1,55.3 195.1,54.11 195.45,53.75 196.34,53.75 196.64,53.46 197.33,53.46 197.43,53.35 197.43,52.7 197.35,52.61
20V_VCCPD_VBUS on TOP: 39.58,122.38 39.47,122.48 39.47,123.72 39.32,123.88 39.12,123.88 38.87,124.13 38.87,124.47 39.23,124.83 39.23,125.03 38.87,125.4 38.87,127.69 39.14,127.97 41.68,127.97 42.93,129.21 48.26,129.21 48.9,128.58 49.63,128.58 49.74,128.47 49.74,126.7 49.55,126.51 48.63,126.51 48.34,126.8 41.79,126.8 41.66,126.67 41.66,124.41 41.84,124.23 41.84,123.88 41.94,123.78 42.17,123.78 42.29,123.65 42.29,123.37 42.22,123.29 41.25,123.29 41.18,123.37 40.64,123.37 40.52,123.5 40.52,124.26 40.39,124.39 40.14,124.39 39.86,124.11 39.86,122.45 39.78,122.38 ; 3 cut-outs
20V_VCCPD_VBUS on TOP: 8.4,121.41 7.75,122.05 7.65,121.95 6.71,121.95 6.38,122.27 6.38,122.57 6.65,122.84 6.65,124.52 6.38,124.79 6.38,125.18 6.44,125.24 6.44,125.55 6.74,125.85 6.74,126.02 7.42,126.7 9.15,126.7 10.42,125.43 10.42,124.59 10.21,124.39 9.3,124.39 8.87,123.95 8.87,122.73 8.83,122.7 9.39,122.14 9.39,121.79 9.01,121.41
20V_VCCPD_VBUS on BOTTOM: 26.7,125.43 26.29,125.83 26.29,129.31 26.77,129.8 40.67,129.8 42.01,128.45 42.01,126.52 40.92,125.43
20V_VCCPD_VBUS on L2SGND: 7.23,124.55 7.22,124.56 6.61,124.56 6.38,124.79 6.38,125.32 6.44,125.39 7.56,125.39 8,125.83 8.56,125.83 8.66,125.93 10.09,125.93 10.75,125.27 10.75,124.87 10.46,124.58 10.12,124.58 9.53,125.17 8.32,125.17 7.7,124.55
