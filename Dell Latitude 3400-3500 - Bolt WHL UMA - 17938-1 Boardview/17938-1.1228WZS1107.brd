# Allegro board 17938-1.1228WZS1107.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
R6115  10KR2J-3-GP  [R402H16]  44.12 104.88 0 top
R6117  33R2J-2-GP  [R402H16]  24.36 79 270 top
R6120  22R2J-2-GP  [R402H16]  37.14 101.57 270 top
R6121  71K5R2F-1-GP  [R402H16]  34.01 104.69 0 top
R6122  71K5R2F-1-GP  [R402H16]  34.77 104.69 0 top
R6123  22R2J-2-GP  [R402H16]  35.4 101.77 180 top
R6124  0R6J-L-GP  [R1206H26]  55.5 100.18 90 top
R6125  0R5J-5-GP  [R805H24]  53.34 104.56 0 top
R6201  0R2J-2-GP  [R402H16]  208.82 56.39 90 top
R6202  0R2J-2-GP  [R402H16]  215.03 58.89 90 top
R6203  0R2J-2-GP  [R402H16]  215.03 58.11 90 top
R6301  0R0402-PAD-1-GP  [0R0402-PAD]  26.02 28.75 0 top
R6302  0R3J-L1-GP  [R603H22]  42.02 29.88 90 bottom
R6322  0R2J-2-GP  [R402H16]  158.32 120.58 270 bottom
R6325  20KR2J-L3-GP  [R402H16]  146.35 115.7 90 bottom
R6326  20KR2J-L3-GP  [R402H16]  146.33 117.32 90 bottom
R6327  0R2J-2-GP  [R402H16]  160.28 113.59 90 bottom
R6328  20KR2J-L3-GP  [R402H16]  146.36 119.03 90 bottom
R6329  20KR2J-L3-GP  [R402H16]  146.35 114.04 90 bottom
R6330  20KR2J-L3-GP  [R402H16]  146.34 114.87 90 bottom
R6331  20KR2J-L3-GP  [R402H16]  146.33 116.54 90 bottom
R6332  20KR2J-L3-GP  [R402H16]  146.36 118.19 90 bottom
R6333  20KR2J-L3-GP  [R402H16]  146.35 119.83 90 bottom
R6334  20KR2J-L3-GP  [R402H16]  146.35 113.23 90 bottom
R6335  20KR2J-L3-GP  [R402H16]  141.21 108.42 90 bottom
R6336  20KR2J-L3-GP  [R402H16]  146.25 112.42 270 bottom
R6337  100KR2J-1-GP  [R402H16]  151.75 113 90 bottom
R6343  10KR2J-3-GP  [R402H16]  151.75 114.66 270 bottom
R6348  100KR2F-L1-GP  [R402H16]  31.25 21.82 0 top
R6349  0R3J-L1-GP  [R603H22]  41.99 28.25 90 bottom
R6358  10R2F-L-GP  [R402H14]  146.34 115.69 90 top
R6359  10R2F-L-GP  [R402H14]  146.33 117.32 90 top
R6360  10R2F-L-GP  [R402H14]  146.36 119.03 90 top
R6361  10R2F-L-GP  [R402H14]  146.34 114.03 90 top
R6362  10R2F-L-GP  [R402H14]  146.34 114.87 90 top
R6363  10R2F-L-GP  [R402H14]  146.33 116.54 90 top
R6364  10R2F-L-GP  [R402H14]  146.36 118.19 90 top
R6365  10R2F-L-GP  [R402H14]  146.34 119.83 90 top
R6366  10R2F-L-GP  [R402H14]  146.35 113.23 90 top
R6367  10R2F-L-GP  [R402H14]  146.25 112.42 90 top
R6368  10R2F-L-GP  [R402H14]  146.36 120.64 90 top
R6369  10KR2J-3-GP  [R402H16]  147.07 110.16 90 top
R6370  0R2J-L-GP  [R402H15]  148.34 105.72 90 top
R6403  10KR2J-3-GP  [R402H16]  62.44 40.92 90 bottom
R6404  1MR2F-GP  [R402H16]  39.22 75.36 90 top
R6405  330R2J-3-GP  [R402H16]  40.67 82.32 270 top
R6406  549R2F-GP  [R402H16]  12.4 129.52 90 bottom
R6407  499R2F-2-GP  [R402H16]  11.23 129.59 0 bottom
R6408  0R2J-2-GP  [R402H16]  24.36 79.09 180 bottom
R6409  0R2J-2-GP  [R402H16]  26.11 76.33 90 bottom
R6410  422R2F-2-GP  [R402H16]  212.08 59.5 90 top
R6411  10KR2J-3-GP  [R402H16]  29.52 22.71 90 top
R6412  0R2J-2-GP  [R402H16]  44.91 64.09 270 top
R6413  150R2F-1-GP  [R402H16]  40.31 78.21 90 top
R6414  330KR2F-L-GP  [R402H16]  24.44 59.34 270 bottom
R6415  10KR2J-3-GP  [R402H16]  30.91 32.28 270 top
R6502  0R2J-2-GP  [R402H16]  100.28 28.96 0 top
R6503  100R3J-4-GP  [R603H22]  96.14 31.04 270 bottom
R6504  20KR2F-L-GP  [R402H16]  97.93 33.01 270 top
R6505  0R2J-2-GP  [R402H16]  107.06 32.56 90 top
R6506  0R2J-2-GP  [R402H16]  108.97 35.38 270 top
R6507  51KR2J-1-GP  [R402H16]  87.31 37.26 180 top
R6508  100KR2J-1-GP  [R402H16]  86.55 37.26 180 top
R6511  10KR2J-3-GP  [R402H16]  103.08 37.24 180 bottom
R6513  1KR2J-1-GP  [R402H16]  101.7 37.67 270 bottom
R6601  0R2J-2-GP  [R402H16]  191.31 40.87 180 bottom
R6602  0R2J-2-GP  [R402H16]  135.9 92.04 0 top
R6604  0R2J-2-GP  [R402H16]  205.21 39.39 90 bottom
R6605  0R2J-2-GP  [R402H16]  205.21 40.15 90 bottom
R6606  0R2J-2-GP  [R402H16]  205.2 40.95 90 bottom
R6607  0R2J-2-GP  [R402H16]  205.2 41.72 90 bottom
R6608  0R2J-2-GP  [R402H16]  119.34 87.32 135 top
R6609  10KR2J-3-GP  [R402H16]  137.15 92.6 270 top
R6610  0R2J-2-GP  [R402H16]  200.41 33.3 180 top
R6611  10KR2J-3-GP  [R402H16]  66.6 36.63 90 bottom
R6801  0R2J-L-GP  [R402H15]  44.17 67.41 0 top
R6802  R402-PAD-NP-GP  [R402-PAD-NP]  72.14 73.18 90 bottom
R6803  R402-PAD-NP-GP  [R402-PAD-NP]  72.14 72.37 90 bottom
R6804  4K7R2F-GP  [R402H16]  16.59 42.98 180 top
R6877  1KR2J-1-GP  [R402H16]  17.25 29.34 0 top
R6878  0R2J-L-GP  [R402H15]  16.94 39.75 90 top
R7004  0R0402-PAD-1-GP  [0R0402-PAD]  146.76 79.59 315 top
R7006  10KR2J-3-GP  [R402H16]  145.39 76.96 90 top
R7007  0R0402-PAD-1-GP  [0R0402-PAD]  139.3 77.57 180 top
R7010  100KR2J-1-GP  [R402H16]  146.13 83.62 270 top
R7011  1MR2J-1-GP  [R402H16]  143.03 81.23 270 top
R7014  100KR2J-1-GP  [R402H16]  159.63 36.51 90 top
R7101  100KR2J-4-GP  [R402H15]  26.47 113.77 0 top
R7102  100KR2J-4-GP  [R402H15]  26.5 112.09 180 top
R7103  0R2J-2-GP  [R402H16]  27.66 112.57 270 top
R7104  0R2J-2-GP  [R402H16]  27.66 113.34 270 top
R7114  0R2J-2-GP  [R402H16]  26.11 109.27 90 top
R7115  0R2J-2-GP  [R402H16]  13.54 116.61 90 bottom
R7116  0R2J-2-GP  [R402H16]  26.11 110.03 90 top
R7117  0R2J-2-GP  [R402H16]  13.54 117.37 90 bottom
R7118  0R2J-2-GP  [R402H16]  24.48 110.29 90 top
R7119  0R2J-2-GP  [R402H16]  13.55 115.05 90 bottom
R7120  0R2J-2-GP  [R402H16]  13.55 115.81 90 bottom
R7122  0R2J-2-GP  [R402H16]  13.34 128.42 90 bottom
R7123  0R2J-2-GP  [R402H16]  13.34 127.66 90 bottom
R7124  0R2J-2-GP  [R402H16]  14.28 125.3 0 bottom
R7125  0R2J-2-GP  [R402H16]  13.52 125.3 0 bottom
R7126  0R0402-PAD-1-GP  [0R0402-PAD]  34.98 121.69 270 top
R7127  0R0402-PAD-1-GP  [0R0402-PAD]  32.98 121.48 0 top
R7128  0R0402-PAD-1-GP  [0R0402-PAD]  35.82 120.7 270 top
R7129  0R0402-PAD-1-GP  [0R0402-PAD]  31.75 120.76 90 top
R7130  0R0402-PAD-1-GP  [0R0402-PAD]  35.82 119.93 270 top
R7131  0R2J-2-GP  [R402H16]  30.32 118.72 0 top
R7132  0R2J-2-GP  [R402H16]  30.32 117.12 180 top
R7133  0R2J-2-GP  [R402H16]  31.59 114.61 0 top
R7134  0R2J-2-GP  [R402H16]  32.37 114.61 0 top
R7140  1KR2J-1-GP  [R402H16]  18.59 105.66 180 bottom
R7141  1KR2J-1-GP  [R402H16]  20.09 105.74 0 bottom
R7142  1KR2J-1-GP  [R402H16]  18.01 104.45 270 bottom
R7143  1KR2J-1-GP  [R402H16]  20.45 104.52 270 bottom
R7144  20KR2J-L3-GP  [R402H16]  22.02 103.28 0 bottom
R7145  1KR2J-1-GP  [R402H16]  24.29 103.28 0 bottom
R7146  1KR2J-1-GP  [R402H16]  23.55 104.5 90 bottom
R7147  1KR2J-1-GP  [R402H16]  19.82 100.69 180 top
R7152  1KR2J-1-GP  [R402H16]  20.63 100.66 180 top
R7153  0R2J-L-GP  [R402H15]  25.2 100.56 270 top
R7154  0R2J-L-GP  [R402H15]  25.2 101.37 270 top
R7155  0R2J-L-GP  [R402H15]  21.57 100.66 180 top
R7156  0R2J-L-GP  [R402H15]  22.38 100.66 180 top
R7170  1KR2J-1-GP  [R402H16]  21.24 103.28 0 bottom
R7171  1KR2J-1-GP  [R402H16]  25.07 103.28 0 bottom
R7172  1KR2J-1-GP  [R402H16]  23.75 105.26 90 bottom
R7173  1KR2J-1-GP  [R402H16]  23.42 106.53 90 bottom
R7174  1KR2J-1-GP  [R402H16]  22.87 108.53 180 bottom
R7175  0R2J-2-GP  [R402H16]  18.6 103.26 180 bottom
R7176  0R2J-2-GP  [R402H16]  18.59 107.25 0 bottom
R7177  5D1R2J-1-GP  [R402H16]  25.82 102.98 270 top
R7178  5D1R2J-1-GP  [R402H16]  25.82 103.74 270 top
R7179  5D1R2J-1-GP  [R402H16]  25.82 104.53 270 top
R7180  5D1R2J-1-GP  [R402H16]  25.82 105.32 270 top
R7181  5D1R2J-1-GP  [R402H16]  25.82 106.13 270 top
R7182  5D1R2J-1-GP  [R402H16]  25.82 106.89 270 top
R7183  5D1R2J-1-GP  [R402H16]  25.5 107.67 270 top
R7184  5D1R2J-1-GP  [R402H16]  25.5 108.46 270 top
R7185  220KR2F-GP  [R402H16]  16.54 104.09 180 top
R7186  220KR2F-GP  [R402H16]  17.48 109.12 135 top
R7187  220KR2F-GP  [R402H16]  16.79 107.88 270 top
R7188  220KR2F-GP  [R402H16]  16.54 102.49 0 top
R7189  10KR2J-3-GP  [R402H16]  18.12 108.58 270 bottom
R7190  4K7R2J-2-GP  [R402H16]  17.79 107.25 180 bottom
R7201  10KR2F-2-GP  [R402H16]  43.72 106.23 270 top
R7202  10KR2F-2-GP  [R402H16]  37.7 114.36 0 top
R7203  0R0402-PAD-1-GP  [0R0402-PAD]  49.05 125.38 0 top
R7204  0R0402-PAD-1-GP  [0R0402-PAD]  52.72 126.61 270 top
R7205  100KR2F-L1-GP  [R402H16]  46.59 124.04 90 top
R7206  0R2J-L-GP  [R402H15]  38.08 113.18 270 top
R7210  0R0402-PAD-1-GP  [0R0402-PAD]  52.71 125.81 270 top
R7211  4K7R2J-2-GP  [R402H16]  41.94 114.89 180 top
R7212  120KR2F-L-GP  [R402H16]  45 109.52 270 top
R7213  1KR2F-3-GP  [R402H16]  44.58 107.96 270 top
R7214  200KR2F-L-GP  [R402H16]  44.99 108.75 90 top
R7215  2K2R2J-2-GP  [R402H16]  41.07 114.89 0 top
R7216  10KR2J-3-GP  [R402H16]  44.28 132.74 180 top
R7217  909KR2F-GP  [R402H16]  47.9 129.34 180 top
R7218  301KR2F-1-GP  [R402H16]  48.69 130.2 180 top
R7219  10KR2F-2-GP  [R402H16]  26.1 110.91 270 top
R7330  2MR2F-GP  [R402H16]  16.87 111.15 315 top
R7331  2MR2F-GP  [R402H16]  16.21 109.58 135 top
R7332  0R2J-L-GP  [R402H15]  11.54 121.33 90 top
R7333  0R2J-L-GP  [R402H15]  11.54 122.11 90 top
R7334  0R2J-L-GP  [R402H15]  13.87 120.84 270 bottom
R7335  0R2J-L-GP  [R402H15]  13.87 120.08 270 bottom
R7401  200KR2F-L-GP  [R402H16]  29.33 110.74 270 top
R7402  10KR2F-2-GP  [R402H16]  39.97 120.09 0 top
R7403  0R2F-1-GP  [R402H16]  33.91 123.16 270 top
R7404  1MR2F-GP  [R402H16]  36.6 121.69 270 top
R7405  100KR2J-1-GP  [R402H16]  41.28 120.19 180 top
R7406  100KR2F-L1-GP  [R402H16]  29.29 125.99 0 top
R7407  100KR2J-1-GP  [R402H16]  34.3 124.34 180 top
R7408  100KR2F-L1-GP  [R402H16]  30.69 104.23 270 top
R7410  150R6J-1-GP  [R1206H26]  44.83 128.78 180 top
R7414  47KR2J-2-GP  [R402H16]  42.05 120.22 180 top
R7415  100KR2J-1-GP  [R402H16]  32.62 110.12 270 top
R7418  14K3R2F-GP  [R402H16]  42.83 120.45 0 top
R7422  1MR2F-GP  [R402H16]  27.1 115.85 0 bottom
R7423  100KR2F-L1-GP  [R402H16]  27.54 114.08 180 bottom
R7424  100KR2F-L1-GP  [R402H16]  37.57 120.24 180 top
R7425  100KR2F-L1-GP  [R402H16]  24.18 109.53 270 bottom
R7426  100KR2F-L1-GP  [R402H16]  24.72 108.14 180 bottom
R7427  100KR2F-L1-GP  [R402H16]  38.33 120.24 180 top
R7428  10KR2F-2-GP  [R402H16]  33.19 103.07 90 top
R7429  200KR2F-L-GP  [R402H16]  26.46 104.27 270 bottom
R7430  200KR2F-L-GP  [R402H16]  27.07 112.65 90 bottom
R7431  100KR2F-L1-GP  [R402H16]  30.94 110.73 90 top
R7432  200KR2F-L-GP  [R402H16]  29.44 115.37 180 top
R7433  100KR2F-L1-GP  [R402H16]  54.07 125.34 0 top
R7434  1MR2F-GP  [R402H16]  66.81 136.75 45 top
R9101  0R2J-2-GP  [R402H16]  149.43 145.7 180 bottom
R9118  2K2R2F-GP  [R402H16]  155.73 141.73 270 bottom
R9119  10KR2J-3-GP  [R402H16]  154.08 136.96 270 bottom
R9121  0R2J-2-GP  [R402H16]  146.76 139.29 270 bottom
R9130  0R2J-2-GP  [R402H16]  151.78 100.02 45 bottom
R9132  33R2J-2-GP  [R402H16]  153.06 100.22 45 bottom
R9133  33R2J-2-GP  [R402H16]  154.15 112.77 270 bottom
R9138  33R2J-2-GP  [R402H16]  157.42 113.73 0 bottom
R9148  10KR2J-3-GP  [R402H16]  151.29 136.88 0 bottom
R9149  0R2J-2-GP  [R402H16]  153.8 144.58 0 top
R9150  0R2J-2-GP  [R402H16]  154.33 137.8 270 bottom
R9151  0R2J-2-GP  [R402H16]  138.6 86.77 270 top
R9152  0R2J-2-GP  [R402H16]  138 87.62 270 top
R9209  0R0402-PAD-1-GP  [0R0402-PAD]  205.06 56.44 90 bottom
R9210  0R0402-PAD-1-GP  [0R0402-PAD]  205.06 55.63 90 bottom
R9211  0R2J-2-GP  [R402H16]  213.14 64.58 180 top
R9212  100KR2J-1-GP  [R402H16]  221.52 68.81 0 top
R9301  0R2J-2-GP  [R402H16]  157.99 140.44 0 top
R9302  0R1J-GP  [R0201H12]  212.09 42.24 90 top
R9303  0R1J-GP  [R0201H12]  213.42 41.59 270 top
R9304  0R1J-GP  [R0201H12]  221.86 39.86 90 top
R9305  0R1J-GP  [R0201H12]  221.7 40.38 90 top
R9308  0R1J-GP  [R0201H12]  104.3 142.41 270 bottom
R9309  0R1J-GP  [R0201H12]  85.32 146 270 bottom
R9312  0R1J-GP  [R0201H12]  85.09 144.15 0 bottom
R9313  0R1J-GP  [R0201H12]  42.32 31.04 0 bottom
R9314  0R1J-GP  [R0201H12]  41.3 31.04 0 bottom
R9316  0R1J-GP  [R0201H12]  104.62 144.45 180 bottom
R9317  0R1J-GP  [R0201H12]  118.11 34.09 180 top
R9318  0R1J-GP  [R0201H12]  108.11 144.17 270 bottom
R9319  0R1J-GP  [R0201H12]  118.37 35.97 270 top
R9320  0R1J-GP  [R0201H12]  108.13 144.91 270 bottom
R9321  0R0402-PAD-1-GP  [0R0402-PAD]  157.98 139.38 0 bottom
R9322  0R0402-PAD-1-GP  [0R0402-PAD]  160.73 140.01 180 bottom
R9323  0R1J-GP  [R0201H12]  154.34 143.83 270 bottom
R9324  0R1J-GP  [R0201H12]  155.38 143.82 270 bottom
R9325  0R1J-GP  [R0201H12]  158.4 141.53 0 bottom
R9326  0R1J-GP  [R0201H12]  157.84 141.53 0 bottom
R9327  0R1J-GP  [R0201H12]  160.53 141.76 0 bottom
R9328  0R1J-GP  [R0201H12]  161.09 141.76 0 bottom
R9329  0R1J-GP  [R0201H12]  161.65 141.76 0 bottom
R9330  0R1J-GP  [R0201H12]  160.61 144.75 90 top
R9331  0R1J-GP  [R0201H12]  163.12 143.29 180 top
R9332  0R1J-GP  [R0201H12]  160.61 145.82 90 top
R9333  0R1J-GP  [R0201H12]  163.76 144.87 180 top
R9334  0R1J-GP  [R0201H12]  155.69 145.79 180 bottom
R9335  0R1J-GP  [R0201H12]  156.23 145.79 180 bottom
R9336  0R1J-GP  [R0201H12]  160.61 145.28 90 top
R9337  0R1J-GP  [R0201H12]  186.15 43.84 0 top
R9338  0R1J-GP  [R0201H12]  176.05 37.34 270 top
RJ1  RJ45-8P-291-GP  [2RJ3076-078211F]  2.75 76.65 90 bottom
RN401  SRN2K2J-4-GP  [ARES8-CN24-UH20]  138 110.62 270 bottom
RN1201  SRN1KJ-7-GP  [SMD-ARES4H18]  72.08 43.45 270 top
RN1301  SRN1KJ-7-GP  [SMD-ARES4H18]  147.34 43.55 180 top
RN1601  SRN10KJ-6-GP  [ARES8-CN24-MUH20]  135.65 109.39 270 bottom
RN1602  SRN0J-6-GP  [SMD-ARES4H20]  135.65 107.42 90 bottom
RN1703  SRN10KJ-5-GP  [ARES2H18]  145.73 81.81 315 bottom
RN1704  SRN10KJ-6-GP  [ARES8-CN24-MUH20]  140.69 84.15 270 bottom
RN1801  SRN20KJ-1-GP  [SMD-ARES4H20]  136.53 90.38 270 top
RN1806  SRN15J-GP  [ARES8-CN24-MUH20]  127.21 76.58 180 top
RN1807  SRN2K2J-4-GP  [ARES8-CN24-UH20]  136.42 97.8 90 top
RN1810  SRN10KJ-5-GP  [ARES2H18]  174.36 48.66 90 top
RN1811  SRN2K2J-1-GP  [ARES2H16]  131.3 98.91 0 bottom
RN2001  SRN20KJ-1-GP  [SMD-ARES4H20]  125.68 96.06 180 top
RN2402  SRN4K7J-8-GP  [SMD-ARES4H18]  20.83 69.89 270 top
RN2403  SRN100KJ-5-GP  [ARES8-CN24H20]  61.65 29.24 0 top
RN2404  SRN100KJ-5-GP  [ARES8-CN24H20]  59.08 29.26 0 top
RN2405  SRN100KJ-6-GP  [SMD-ARES4]  21.76 73.48 90 top
RN2406  SRN100KJ-6-GP  [SMD-ARES4]  99.95 33.55 180 top
RN2407  SRN100KJ-6-GP  [SMD-ARES4]  63.73 29.26 0 top
RN2409  SRN100KJ-5-GP  [ARES8-CN24H20]  65.76 29.26 0 top
RN2410  SRN100KJ-5-GP  [ARES8-CN24H20]  70.87 29.26 0 top
RN2411  SRN100KJ-6-GP  [SMD-ARES4]  74.22 29.34 0 top
RN2412  SRN100KJ-5-GP  [ARES8-CN24H20]  68.3 29.26 0 top
RN2413  SRN2K2J-1-GP  [ARES2H16]  34.37 114.81 0 top
RN2601  SRN10KJ-5-GP  [ARES2H18]  30.52 54.08 90 top
RN2602  SRN2K2J-1-GP  [ARES2H16]  129.43 124.78 0 bottom
RN2901  SRN2K2J-1-GP  [ARES2H16]  21.2 16.68 270 top
RN3201  SRN75J-1-GP  [ARES8-CN24H22]  26.15 86.88 180 top
RN4302  SRN100J-4-GP  [ARES8-CN24H20]  138.78 36.7 270 top
RN5502  SRN100KJ-5-GP  [ARES8-CN24H20]  221.34 36.5 90 top
RN5503  SRN100J-4-GP  [ARES8-CN24H20]  223.61 36.64 270 top
RN5504  SRN33J-5-GP-U  [SMD-ARES4H18]  31.73 19.64 180 top
RN5505  SRN33J-5-GP-U  [SMD-ARES4H18]  156.75 35.93 45 top
RN6401  SRN100J-3-GP  [SMD-ARES4H18]  209.73 61.17 180 top
RN6501  SRN10KJ-5-GP  [ARES2H18]  103.51 29.14 0 top
RN6502  SRN33J-5-GP-U  [SMD-ARES4H18]  103.51 32.18 0 top
RN6503  SRN2K2J-1-GP  [ARES2H16]  107.83 31.17 0 top
RN7201  SRN2K2J-1-GP  [ARES2H16]  39.37 114.71 180 top
RN7202  SRN2K2J-1-GP  [ARES2H16]  36.38 109.64 270 top
RN9301  SRN2K2J-1-GP  [ARES2H16]  160.44 137.01 180 bottom
SPK1  ACES-CON4-29-GP  [50224-0040N-001]  9.7 1.8 180 bottom
SPR3  SPRING-63-GP  [SPR5630H142]  25.21 43.68 270 bottom
SPR4  SPRING-63-GP  [SPR5630H142]  80.97 39.83 0 bottom
SPR5  SPRING-171-GP  [SPR5128H111]  55.8 133.78 180 top
SPR6  SPRING-171-GP  [SPR5128H111]  104.37 131.19 270 top
SPR7  SPRING-171-GP  [SPR5128H111]  124.7 132.8 270 top
SPR8  SPRING-171-GP  [SPR5128H111]  68.9 74.3 0 top
SPR9  SPRING-171-GP  [SPR5128H111]  114.7 72.3 0 top
SSD1  SKT-NGFF75P-202-GP-U  [NFSM0-S6701-TSH4-U]  27.2 27.3 180 bottom
TP1  ACES-CON8-66-GP  [51574-0084N-W01]  106.7 32.3 180 bottom
TP401  TPAD14-OP-GP  [TPAD14-OP]  95.56 101.98 0 top
TP402  TPAD14-OP-GP  [TPAD14-OP]  133.51 112.82 180 bottom
TP620  TPAD14-OP-GP  [TPAD14-OP]  122.35 87.08 0 top
TP623  TPAD14-OP-GP  [TPAD14-OP]  86.39 105.16 0 top
TP640  TPAD14-OP-GP  [TPAD14-OP]  85.04 104.65 0 top
TP1702  TPAD14-OP-GP  [TPAD14-OP]  111.89 86.72 0 top
TP1705  TPAD14-OP-GP  [TPAD14-OP]  113.2 81.13 180 bottom
TP1706  TPAD14-OP-GP  [TPAD14-OP]  113 89.64 0 top
TP1708  TPAD14-OP-GP  [TPAD14-OP]  117.06 81.14 180 bottom
TP1807  TPAD14-OP-GP  [TPAD14-OP]  100.21 109.5 180 bottom
TP1808  TPAD14-OP-GP  [TPAD14-OP]  101.22 110.64 180 bottom
TP1901  TPAD14-OP-GP  [TPAD14-OP]  108.62 81.18 180 bottom
TP2201  TPAD14-OP-GP  [TPAD14-OP]  118.52 76.25 0 top
TP2202  TPAD14-OP-GP  [TPAD14-OP]  115.78 81.21 180 bottom
TP4401  TPAD28-2-GP  [TPAD28]  201 53.65 0 top
TP4411  TPAD14-OP-GP  [TPAD14-OP]  196.6 46.61 90 top
TP4601  TPAD14-OP-GP  [TPAD14-OP]  136.7 143.65 0 bottom
TP6001  TPAD14-OP-GP  [TPAD14-OP]  185.09 33.71 0 top
TP6201  TPAD14-OP-GP  [TPAD14-OP]  221.72 64.49 0 top
TP6801  TPAD14-5-GP  [TPAD14-5]  57.56 72.58 180 bottom
TP6802  TPAD14-5-GP  [TPAD14-5]  58.8 72.56 180 bottom
TP6803  TPAD14-5-GP  [TPAD14-5]  60.07 72.56 90 bottom
TP6804  TPAD14-5-GP  [TPAD14-5]  61.34 72.56 180 bottom
TP6805  TPAD14-5-GP  [TPAD14-5]  62.61 72.56 180 bottom
TP6806  TPAD14-5-GP  [TPAD14-5]  63.88 72.56 180 bottom
TP6807  TPAD14-5-GP  [TPAD14-5]  65.15 72.56 180 bottom
TP7201  TPAD14-OP-GP  [TPAD14-OP]  43.18 107.46 0 top
TP9101  TPAD14-OP-GP  [TPAD14-OP]  152.67 145.25 180 bottom
TP9102  TPAD14-OP-GP  [TPAD14-OP]  147.15 142.67 180 bottom
TP9103  TPAD14-OP-GP  [TPAD14-OP]  152.16 146.7 180 bottom
TP9104  TPAD14-OP-GP  [TPAD14-OP]  151.41 145.26 180 bottom
U2401  MEC1416-NU-D0-GP  [TQFP128-2H48]  31.35 66.29 90 top
U2402  U74LVC1G08G-AL5-R-GP-U  [SC70-5-1H44]  46.64 66.12 315 top
U2502  G524B1T11U-GP  [SOT-23-5H58]  144.61 89.1 45 bottom
U2601  NCT7718W-GP  [MSOP8-1H44]  130.1 125.07 90 top
U3101  RTL8111H-CG-1-GP  [QFN32J4-G2D85H36]  46.09 83.54 90 top
U3502  SY6288DAAC-GP  [SOT-23-5H56]  18.06 39.78 90 bottom
U3601  TPS2544RTER-GP  [QFN16-G1D8-UH32]  21.27 51.69 0 top
U4001  G2898KD1U-GP  [DFN14J32-G255D95H32]  58.8 127.95 90 bottom
U4002  G5027RD1D-GP-U  [DFN8F3-G2517H32]  122.84 116.05 90 bottom
U4003  G5027RD1D-GP-U  [DFN8F3-G2517H32]  139.45 84.51 270 top
U4004  G2898KD1U-GP  [DFN14J32-G255D95H32]  60.53 37.84 270 bottom
U4006  G5027RD1D-GP-U  [DFN8F3-G2517H32]  116.23 125.99 90 bottom
U4007  TC7SZ08FU-LJ-CT-GP  [SC70-5H44]  90.2 40.18 270 bottom
U4302  S-1004NA23I-M5T1U-GP  [SOT-23-5H52]  39.62 117.44 270 top
U5501  AP22811AW5-7-GP  [SOT-23-5H56]  211.36 51.11 0 bottom
U5502  G2898KD1U-GP  [DFN14J32-G255D95H32]  211.97 44.39 270 bottom
U5702  APL3517-AI-TRG-GP  [SOT23-2D8-312H58]  17.2 101.94 90 bottom
U5802  PS8338BQFN60GTR-A1-GP  [QFN60J9050-G7131H32]  50.7 117.83 180 top
U6101  G517F1T12U-GP  [SOT-23-5H58]  54.46 105.49 90 bottom
U6301  KLMBG4GEND-B031-GP-U  [BGA153G115130-2H40]  154.75 115.7 90 top
U7001  LNG2DMTR-GP  [LGA12G2H40]  142.37 78.41 90 top
U7101  TUSB546A-DCIRNQR-GP  [QFN40J4060-G2848H32]  22 105.79 180 top
U7102  TS3DS10224RUKR-GP  [QFN20J3-G1D8H32]  33.04 118.39 180 top
U7201  CYPD4126-24LQXIT-GP  [QFN24-G2D8-UH24]  40.58 110.41 270 top
U7202  AP2151FMG-7-GP  [DFN6G1820-G1511-UH24]  47.2 125.63 90 top
U7203  TPS70933DRVR-GP-U  [DFN6F2-G1711-UH32]  50.49 128.92 270 top
U7403  NX5P3363UKZ-1-GP  [CSP16G2D2H24]  42.38 123.3 270 top
U7418  AON7403-GP-U  [PPAK-8P-3232H36]  37.29 124.16 270 top
U7419  NX20P5090UK-GP  [CSP15G154256H24]  39.68 123.07 180 top
U9103  ST33HTPH2032AHC1-GP  [QFN32G5-G3D75-UH40]  150.72 141.75 180 bottom
USB1  SKT-USB13-428-GP-U  [SKT-USB13-160146-4-U]  5.44 55.65 90 bottom
USB2  SKT-USB13-428-GP-U  [SKT-USB13-160146-4-U]  5.44 31 90 bottom
VGABD1  ACES-CON20-37-GP-U  [50406-02071-W01]  199.7 60.8 180 bottom
WLAN1  SKT-MINI67P-26-GP  [40-42064-067212HF]  40.2 102.8 180 bottom
WWAN1  KYO-CON34-GP  [04-6809-634-310-846]  220.2 53.8 90 top
X1801  XTAL-24MHZ-135-GP  [S-OSC3-2016H28]  132.74 117.98 180 bottom
X1802  XTAL-32D768KHZ-98-GP  [SMD49-12H34]  136.4 79.94 270 top
X2401  XTAL-32D768KHZ-98-GP  [SMD49-12H34]  27.18 77 270 top
X3101  XTAL-25MHZ-182-GP  [OSC-3225-4P-4H36]  45.23 88.95 180 top
XF3201  XFORM-12P-25-GP  [XFORM12A127096H81]  33.41 84.63 270 top
XF3202  XFORM-12P-25-GP  [XFORM12A127096H81]  33.41 84.63 90 bottom

## Library data of the parts
AFTP1201 AFTP1202 AFTP2601-AFTP2604 AFTP2901-AFTP2904 AFTP3201 AFTP3202 AFTP3204-AFTP3209 AFTP3502 AFTP3503 AFTP3505-AFTP3508 AFTP4001-AFTP4003 AFTP4302-AFTP4304 AFTP4306-AFTP4315 AFTP4401-AFTP4408 AFTP4501 AFTP4502 AFTP4601-AFTP4606 AFTP5001 AFTP5503-AFTP5506 AFTP5509-AFTP5511 AFTP5514 AFTP5517-AFTP5526 AFTP5601 AFTP5602 AFTP6001-AFTP6007 AFTP6108-AFTP6115 AFTP6401-AFTP6404 AFTP6407 AFTP6408 AFTP6501 AFTP6524-AFTP6531 AFTP6537 AFTP6541-AFTP6567 AFTP6607-AFTP6610 AFTP6614 AFTP6615 AFTP6801-AFTP6803 AFTP7101 AFTP7102 AFTP7301-AFTP7304 = AFTE14P-75: tolerance: ZZ.AFT14.101
BATT1 = 88231-1001-LP: tolerance: 20.F1240.010
BIOS1 = SOIC8-1H86: tolerance: 072.25128.0D61
BIOS2 = SOIC8-1H86: tolerance: 072.25647.000D
C501 C805 C1139-C1142 C1229 C1301 C1711 C2201 C2206 C2207 C2221 C2406-C2408 C2410-C2414 C2416 C2420-C2423 C2428 C2429 C2432 C2502 C2610 C2614 C2735 C3103 C3108 C3112 C3115 C3117-C3121 C3123 C3516 C3524 C3602 C4007 C4010 C5529 C5530 C5538 C5736 C5809 C5811-C5813 C6007 C6019 C6104 C6107 C6108 C6307 C6503 C7003 C7115-C7118 C7120 C7203-C7205 C7210 C7211 C7213 C7216 C9104 C9112 C9113 C9203 EC1707 EC1712 EC6601 FC8920 PC4438 PC4449 PC4602 PC5123 = C402H22: tolerance: 78.10421.2FLDL
C801-C804 C806 C1102-C1111 C1114 C1116 C1117 C1119 C1121 C1207 C1214-C1221 C1225 C1226 C1313 C1315-C1322 C1326 C1327 C1805 C1806 C2202-C2205 C2209-C2217 C2219 C2222-C2230 C2418 C2525 C3122 C3126 C4043 C5536 C5541 C6405 C7202 C9201 C9202 EC8950-EC8953 FC8904-FC8906 PC5114 = C0201H14: tolerance: 78.10510.5SL
C807 C1112 C1113 C1115 C1118 C1122 C1128-C1135 C2208 C2220 C2231 C3518 C3519 C3526 C3527 C4035 C4036 C7403 C7404 PC1001-PC1032 PC1034 PC1036-PC1084 PC4509-PC4512 PC4514-PC4517 PC4525 PC4527 PC4529 PC5201 PC5203 PC5205 PC5206 PC5217 = C603H40: tolerance: 78.22610.5BLDL
C1120 C1123 C1136-C1138 C2501 C2601 C4006 C4008 C4009 C4012 C4013 C4015 C6105 C6317 C6318 C7119 C9106 PC5112 PC5113 PC5124 PC5302 PC5305 PC5306 = C603H36: tolerance: 78.10610.5BLDL
C1202-C1206 C1208-C1210 C1303 C1305 C1306 C1308 C1310 C2720 C2722 C2736 C2902 C7004 = C603H38: tolerance: 78.10610.5BL
C1222 C1323 = C402H22: tolerance: 78.22321.2FL
C1223 C1227 PC4507 = C603H36: tolerance: 78.47520.5BL
C1228 C1328 C6320 C6323 = C402H22: tolerance: 78.10421.L0L
C1231 C1304 C1307 C1309 C1311 C1324 C1325 C2703 C2710 C2711 C2715 C5505 C5517 C7206 = C402-TO0D2H28: tolerance: 078.10610.05FD
C1329 C2702 C7165 C7217 EC1202 EC1303 FC1102 FC1103 R1216 = C402H22: tolerance: 78.22510.5FLDL
C1701 PC5212 = C402H22: tolerance: 78.22124.2FLDL
C1702 C1703 C7215 = C402H22: tolerance: 78.22423.5FL
C1803 C1804 = C402H22: tolerance: 78.12034.1FLDL
C1807 C1808 C3116 C3125 = C402H22: tolerance: 78.15034.1FLDL
C1809 = C402H22: tolerance: 78.2R274.1FLDL
C2218 C2604 C2907 C2908 C3110 C3124 C9109 PC4421 PC4422 PC4520 = C603H36: tolerance: 78.47520.5BLDL
C2405 = C402H22: tolerance: 78.10134.1FL
C2409 C5810 PC4431 PC4613 PC4622 PC4635 PC4637 PC5213 = C402H22: tolerance: 78.10322.2FLDL
C2424 C2425 = C402H22: tolerance: 78.18034.1FLDL
C2426 C2705 C2708 C2709 PC5001 = C603H36: tolerance: 78.22523.5BLDL
C2431 C2435 PC4443 = C402H22: tolerance: 78.22224.2FL
C2503 = C603H36: tolerance: 78.47422.5BL
C2517 PC4420 PC4608 PC4625 PC4626 PC4628 PC4652 PC4654 = C402H22: tolerance: 78.22321.2FLDL
C2602 C2612 C2704 C2706 C2714 C2718 C2721 C2723 C2741 C6401 C6501 C6505 EC2201 EC6401 FC8901 FC8902 FC8907 FC8908 FC8910 FC8919 FC8975 FC8990 PC4518 = C402H22: tolerance: 78.10421.2FL
C2603 C2607 C5531 C5535 PC4441 PC4601 PC4611 PC4612 PC4623 PC4632 PC4640 = C402H22: tolerance: 78.22224.2FLDL
C2605 C4033 C4034 C6106 C7166 C7201 C7302-C7304 C7307 EC6402 EC6404 EC6405 FC4534 FC8924-FC8926 FC8930 FC8931 FC8939 FC8941-FC8943 FC8945 FC8947 FC8981 PC4406 PC4513 PC4603 PC4631 PC4633 PC5004 PC5102 PC5122 PC5127 PC5204 PC5208 PC5214 PC5303 = C402H22: tolerance: 78.10422.5FLDL
C2606 = C603H36: tolerance: 78.47134.1BL
C2613 = C402H22: tolerance: 78.10134.1FLDL
C2707 = C603H36: tolerance: 078.10613.05BD
C2713 C2717 C4005 = C603H38: tolerance: 78.10613.5BL
C2740 C6319 C6321 = C603H36: tolerance: 78.22523.L1L
C3102 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C3102
C3104 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C3104
C3107 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C3107
C3109 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C3109
C3202 = C1808H56: tolerance: 78.1013N.1AL
C3203 C4303-C4305 PC4615 PC4620 PC4644 = C402H22: tolerance: 78.10324.2FLDL
C3507 C3517 C3525 C4031 C4032 C4041 EC8933-EC8939 EC8947 EC8948 PC4607 PC4708 PC4766 PC4809 PC4812 PC4866 PC4877 PC5120 PC5301 = C402H22: tolerance: 78.10523.5FLDL
C3520 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C3520
C3521 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C3521
C3522 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C3522
C3523 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C3523
C4001 C4002 C4011 C4017 C5539 C5540 = C402H22: tolerance: 78.47124.2FL
C4004 C4014 C4306 C7305 EC4301 PC4402-PC4405 PC4407 PC4412 PC4418 PC4434 PC4437 PC4446 PC4502-PC4504 PC5002 PC5003 PC5209 PC5210 PC5216 = C805H58: tolerance: 78.10622.51LDL
C4301 C4302 C7306 = C603H36: tolerance: 078.10524.05BD
C4343 C7401 FC8971 FC8974 = C402H22: tolerance: 78.15224.2FLDL
C4344 C5513 EC2901-EC2904 EC4307 EC4312 EC6403 PC4432 PC4435 PC4442 PC4445 PC4616 PC4617 PC4619 PC4642 PC4643 PC4651 PC4706 PC4810 PC4813 PC5215 = C402H22: tolerance: 78.10224.2FLDL
C5503 C5504 C5520 C5599 PC5121 = C402H22: tolerance: 078.47510.05FD
C5512 C5516 C5528 EC1203 EC4311 EC8911 EC8912 EC8914 EC8915 EC8932 EC8956 EC8962 FC8932-FC8938 FC8940 FC8944 FC8946 FC8948-FC8955 FC8957 FC8960-FC8970 FC8972 FC8973 FC8976-FC8980 FC8982-FC8989 PC4501 PC4506 PC4508 PC4521 PC4522 PC4530-PC4532 = C402H22: tolerance: 78.10422.5FL
C5514 PC4408-PC4411 PC4413 PC4414 PC4427 PC4447 PC4448 PC5211 = C603H40: tolerance: 078.10612.05BL
C5521 = C402H22: tolerance: 78.10421.2FL; signal model: wistron_C5521
C5522 = C402H22: tolerance: 78.10421.2FL; signal model: wistron_C5522
C5523 = C402H22: tolerance: 78.10421.2FL; signal model: wistron_C5523
C5524 = C402H22: tolerance: 78.10421.2FL; signal model: wistron_C5524
C5525 = C402H22: tolerance: 78.10421.2FL; signal model: wistron_C5525
C5526 = C402H22: tolerance: 78.10421.2FL; signal model: wistron_C5526
C5724 = C402H22: tolerance: 78.10324.2FL
C5777 = C402H22: tolerance: 78.10421.2FL; signal model: wistron_C5777
C5778 = C402H22: tolerance: 78.10421.2FL; signal model: wistron_C5778
C5779 = C402H22: tolerance: 78.10421.2FL; signal model: wistron_C5779
C5780 = C402H22: tolerance: 78.10421.2FL; signal model: wistron_C5780
C5781 = C402H22: tolerance: 78.10421.2FL; signal model: wistron_C5781
C5782 = C402H22: tolerance: 78.10421.2FL; signal model: wistron_C5782
C5783 = C402H22: tolerance: 78.10421.2FL; signal model: wistron_C5783
C5784 = C402H22: tolerance: 78.10421.2FL; signal model: wistron_C5784
C5801 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C5801
C5802 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C5802
C5803 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C5803
C5804 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C5804
C5805 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C5805
C5806 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C5806
C5807 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C5807
C5808 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C5808
C5854 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C5854
C5862 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C5862
C5863 = C402H22: tolerance: 78.22523.5FL
C6008 C6018 = C402-TO0D2H28: tolerance: 78.10613.5FLDL
C6010 = C402H22: tolerance: 78.10322.2FLDL; signal model: wistron_C6010
C6011 = C402H22: tolerance: 78.10322.2FLDL; signal model: wistron_C6011
C6013 = C402H22: tolerance: 78.10322.2FLDL; signal model: wistron_C6013
C6014 = C402H22: tolerance: 78.10322.2FLDL; signal model: wistron_C6014
C6028 = C402H22: tolerance: 78.10322.2FLDL; signal model: wistron_C6028
C6029 = C402H22: tolerance: 78.10322.2FLDL; signal model: wistron_C6029
C6030 = C402H22: tolerance: 78.10322.2FLDL; signal model: wistron_C6030
C6031 = C402H22: tolerance: 78.10322.2FLDL; signal model: wistron_C6031
C6102 C6322 C6324 = C603H36: tolerance: 78.47520.L0L
C6201 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C6201
C6202 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C6202
C6302 = C402H22: tolerance: 078.22423.05FD; signal model: wistron_C6302
C6303 = C402H22: tolerance: 078.22423.05FD; signal model: wistron_C6303
C6304 C6305 C9108 EC1903 EC5503 EC5504 FC8927-FC8929 FC8956 FC8958 FC8959 PC4610 PC4624 PC4639 = C402H22: tolerance: 78.33034.1FLDL
C6306 C6308 PC4605 PC4630 PC4634 PC4653 = C402H22: tolerance: 078.47322.02FD
C6311 = C402H22: tolerance: 078.22423.05FD; signal model: wistron_C6311
C6312 = C402H22: tolerance: 078.22423.05FD; signal model: wistron_C6312
C6313 = C402H22: tolerance: 078.22423.05FD; signal model: wistron_C6313
C6314 = C402H22: tolerance: 078.22423.05FD; signal model: wistron_C6314
C6315 = C402H22: tolerance: 078.22423.05FD; signal model: wistron_C6315
C6316 = C402H22: tolerance: 078.22423.05FD; signal model: wistron_C6316
C6506-C6508 EC1801 EC1901 EC2503 EC2504 EC2601 EC2602 PC4430 = C402H22: tolerance: 78.10034.1FLDL
C7103 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C7103
C7104 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C7104
C7105 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C7105
C7106 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C7106
C7107 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C7107
C7108 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C7108
C7109 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C7109
C7110 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C7110
C7111 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C7111
C7112 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C7112
C7113 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C7113
C7114 = C402H22: tolerance: 78.10421.2FLDL; signal model: wistron_C7114
C7161 = C402H22: tolerance: 78.10422.5FLDL; signal model: wistron_C7161
C7162 = C402H22: tolerance: 78.10422.5FLDL; signal model: wistron_C7162
C7163 = C402H22: tolerance: 78.10422.5FLDL; signal model: wistron_C7163
C7164 = C402H22: tolerance: 78.10422.5FLDL; signal model: wistron_C7164
C7167 = C0201-TO0D1H16: tolerance: 078.33422.05S1; signal model: wistron_C7167
C7168 = C0201-TO0D1H16: tolerance: 078.33422.05S1; signal model: wistron_C7168
C7169 = C0201-TO0D1H16: tolerance: 078.33422.05S1; signal model: wistron_C7169
C7170 = C0201-TO0D1H16: tolerance: 078.33422.05S1; signal model: wistron_C7170
C7207 C7212 FC8903 = C402H22: tolerance: 78.10523.5FL
C7208 C7209 = C402H24: tolerance: 78.39124.2FL
C7214 = C603H32: tolerance: 78.10524.5BL
C7405 EC4302 EC4308 EC4313 EC8923 EC8924 EC8955 EC8963 PC4526 PC4533 = C402H22: tolerance: 78.10224.2FL
CPU1 = BGA1528M2446-1H52: tolerance: ZZ.00CPU.271
D1701 D4002 D4003 PD4407 PD4409 = SOD523AKH26: tolerance: 83.R2003.A8M
D1702 D2404 D5701 = SOT23-2D4-312H44: tolerance: 75.00056.07D
D2401 D2501 D2703 D5502 D5503 PD4401 PD4408 = SOT-23-9H44: tolerance: 75.00054.A7D
D2402 D4001 PD4404 = SOD323AKH44: tolerance: 83.00355.G1F
D2403 D2601 = SOD323AKH38: tolerance: 83.R5003.H8H
D2502 D6403 = SOD323-2513AKH36: tolerance: 83.R2004.J8F
D2503 D2901 D6401 = SOT-23-9H44: tolerance: 75.BAT54.07D
D4301 = D4724AKH44: tolerance: 083.00624.00AM
D4302 ED4304-ED4306 = SOT23-2D4-312H44: tolerance: 75.00099.O7D
D4304 = SOD123AK-2H43: tolerance: 83.SMF18.AAH
D4305 D4309 = SOD323AKH38: tolerance: 83.R2004.G8F
D5504 D5505 = D1608AK-UH28: tolerance: 83.R1004.D8F
D7201 D7202 = D1006-0305AK-UH22: tolerance: 083.00520.0F8F
D7401 = SOD123AK-3718-1H40: tolerance: 083.00330.008H
DBEC1 = 50696-00601-001: tolerance: 20.K0691.006
DBG1 = DM-87212-1400N-02: tolerance: ZZ.F0765.01402
DCIN1 = 50224-0080N-W02-U: tolerance: 20.F1295.008
DM1 DM2 = ADDR0206-P013A-1-U: tolerance: 062.10011.M001
EC1803 EC2501 EC2502 EC2505 EC2506 = C402H22: tolerance: 078.4R7B4.01FD
EC2701-EC2705 EC2905 EC2906 EC3513 EC4701 EC5001 EC8902 EC8904 EC8906 EC8909 EC8910 EC8913 = C402H22: tolerance: 78.10221.2FLDL
EC2907 EC2908 = C402H22: tolerance: 78.68124.2FLDL
EC4306 EC4309 EC4310 = C402H22: tolerance: 78.10034.1FL
EC6501-EC6504 = C402H22: tolerance: 78.33034.1FL
ED301 ED2403 ED2910-ED2912 ED6401 ED7307 ED7315 = SOT23-2D4-312H46: tolerance: 75.05125.07D
ED1217 ED1302 = SOT23-2D4-312H44: tolerance: 075.52215.007D
ED1701-ED1703 ED1705-ED1707 ED1801 ED1802 = SOD-523-2H26: tolerance: 83.0005V.0AF
ED3201 ED3202 ED3501 ED3503 ED5701-ED5703 ED6001 = DFN10G2510H22: tolerance: 075.01043.0073
ED3502 ED5502 ED6601 ED9202 = SOT-6H58: tolerance: 075.09904.0A7C
ED4303 = SOD882-10D6-1H20: tolerance: 83.05725.0A0
ED7301 ED7302 = SLP2510P8-1H22: tolerance: 075.00550.0071
ED7311-ED7314 = SOD882-10D6-UH22: tolerance: 083.00201.0AAF
EL3501 = L125100-4P-4H24: tolerance: 68.00396.001; signal model: wistron_EL3501
EL3502 = L125100-4P-5H24: tolerance: 68.24500.201; signal model: wistron_EL3502
EL3503 EL3505 = L125100-4P-5H24: tolerance: 68.24500.201
EL3504 = L125100-4P-5H24: tolerance: 68.24500.201; signal model: wistron_EL3504
EL3506 = L125100-4P-4H24: tolerance: 68.00396.001; signal model: wistron_EL3506
EL4301-EL4304 R6001 R6003 = 0R0805-PAD-U: tolerance: ZZ.R0805.001
EL5501 = L125100-4P-4H24: tolerance: 68.00396.001; signal model: wistron_EL5501
EL5701-EL5704 = L125100-4P-3H24: tolerance: 068.01210.2031
EL6101 = L125100-4P-4H24: tolerance: 68.00396.001
EL6601 EL6602 = L125100-4P-4H28: tolerance: 68.01012.20B
EL7105 = L125100-4P-4H24: tolerance: 68.00396.001; signal model: wistron_EL7105
EL7106 = L125100-4P-4H24: tolerance: 68.00396.001; signal model: wistron_EL7106
ER5701-ER5704 R602 R604 R2101 R6413 = R402H16: tolerance: 64.15005.6DL
F5503 = POLYSW-4633-UH43: tolerance: 69.50007.A31
F5504-F5506 F5701 F6501 = POLYSW-2114H30: tolerance: 69.48001.081
FAN1 SPK1 = 50224-0040N-001: tolerance: 20.F1639.004
FC5501-FC5506 = C402H22: tolerance: 78.3R374.1FLDL
FC8909 FC8911-FC8918 FC8921-FC8923 PC5111 PC5304 = C402H22: tolerance: 78.68034.1FLDL
FP1 = FH52-8S-D5SH: tolerance: 20.K0767.008
G1801 G6401 G6402 = CON2O-U: tolerance: ZZ.CON2O.XXX
H9 H10 H16 = HOLE335R178: tolerance: ZZ.00PAD.7F1
H11 H13 H14 H17 H18 = HOLE256R115: tolerance: ZZ.00PAD.D11
H12 = HOLE335R229: tolerance: ZZ.00PAD.7G1
H19-H22 = HOLE233R142: tolerance: ZZ.00PAD.5S1
HDA27 = QFN40J5-G3D75H36: tolerance: 071.03204.0003
HDD1 VGABD1 = 50406-02071-W01: tolerance: 020.F0320.0020
HDD2 = FFSKL05007N12C: tolerance: 020.K0222.0012
HDMI1 = SKT-HDMI23-188139-2: tolerance: 022.10025.0131
HPMIC1 = 14-00790-1A03-A: tolerance: ZZ.00SKT.020
HS3 = STF237R113H86: tolerance: 434.07K0E.0001
IOBD1 = 51530-02001-W01-U: tolerance: 20.K0637.020
JUSB1 = SKT-USB36-124102-1: tolerance: 022.10005.M022
KB1 = 50699-03001-W01: tolerance: 020.K0254.0030
KBBL1 = 50698-00401-W01-U: tolerance: 020.K0298.0004
L7101 = L402H24: tolerance: 68.00213.051
LCD1 = 300E40-1010RA-G3: tolerance: 020.F0847.0040
LED1 = LED3020-3P-19H44: tolerance: 083.1212A.0070
LED2 = LED11516AKH28: tolerance: 83.00270.F70
MESW1 = MSS3-Q-T-R: tolerance: 62.40018.641
ODD1 = 50552-01601-001: tolerance: 020.K0386.0016
PC4415 = C603H40: tolerance: 078.47522.05B1
PC4416 PC4417 PC4419 PC4424-PC4426 PC4439 PC4440 = C603H36: tolerance: 78.10522.5BLDL
PC4423 PC4436 PC4606 PC4707 PC4808 PC4811 PC5005 = C603H36: tolerance: 78.22422.2BLDL
PC4429 = C402H22: tolerance: 78.47224.2FLDL
PC4433 PC4614 PC4618 = C402H22: tolerance: 78.47124.2FLDL
PC4505 PC4519 PC4523 = C805H56: tolerance: 78.10622.51L
PC4524 = C603H36: tolerance: 78.22523.5BL
PC4604 PC4629 PC4638 PC4641 = C402H22: tolerance: 78.33124.2FLDL
PC4621 = C402H22: tolerance: 78.68124.2FL
PC4701-PC4704 PC4802-PC4805 PC4814-PC4817 = C603H40: tolerance: 78.10612.5BL
PC5103 = C402H22: tolerance: 78.10523.L2L
PC5104-PC5107 = C603H40: tolerance: 78.22610.L4L
PC5115 PC5119 = C805H56: tolerance: 78.10622.LAL
PC5116 PC5117 = C603H38: tolerance: 78.10610.L0L
PC5118 = C402H22: tolerance: 78.15224.2FL
PC5202 = C805H54: tolerance: 78.47522.51LDL
PD5101 = SOD323AKH40: tolerance: 083.04024.0AA1
PG4401 PG4402 PG4405 PG4406 PG4408 PG4527 PG4528 PG4530 PG4532 PG4707 PG4708 PG4808 PG4809 PG4813 PG4815 PG5001 PG5011 PG5103 PG5105-PG5114 PG5116 PG5122 PG5201-PG5212 PG5214 PG5224-PG5227 PG5301-PG5303 = GAP-CLOSE-PWR-3: tolerance: ZZ.CLOSE.001
PG4415 PG4419 PG4422 PG4423 = GAP-CLOSE-PWR-0805-NP-5: tolerance: ZZ.PAD01.4N1
PG5223 = GAP-CLOSE-PWR: tolerance: ZZ.CLOSE.011
PL4401 = L11510030H158: tolerance: 68.2R210.20C
PL4402 = L7066-1830-UH119: tolerance: 68.4R71A.20H
PL4501 PL4502 = L7066-1830-UH119: tolerance: 68.1R510.10K
PL4701 PL4801 PL4802 = L7366-1830H119: tolerance: 068.R1510.1171
PL4702 PL4703 PL4803 PL4804 = L20125H42: tolerance: 68.00216.191
PL5001 = L7066-1830-UH119: tolerance: 68.R4710.10M
PL5101 PL5201 = L7066-1830-UH119: tolerance: 68.1R01A.20B
PMBD1 = DF30FC-20DP-D4V-81: tolerance: 20.F1450.020
PQ4405 PQ4415 PQ4416 PQ4418 Q401 Q1702 Q2416 Q2417 Q4349 Q5801 Q6406 Q6504 Q7001 Q7404-Q7406 Q9301 = SOT-363H44: tolerance: 75.27002.F7C
PQ4408 = SOT23CBE2D4H46-U: tolerance: 84.T3906.I11
PQ4417 Q502 Q2408 Q2414 Q2505 Q2510 Q2602 Q3201 Q5701 Q6102 Q6301 Q6402 Q6503 Q7201 Q7408 Q9202 = SOT23DGS2D4H44: tolerance: 84.2N702.J31
PR4401 = R1206H24: tolerance: 64.R0205.81L
PR4402 PR4810 PR4826 = R603H22: tolerance: 64.2R205.55L
PR4403 PR5110 = R805H24: tolerance: 63.2R231.16L
PR4404 = R402H16: tolerance: 64.40235.6DL
PR4405 = R402H16: tolerance: 64.4R705.6DL
PR4406 PR4409 PR4417 PR4474 PR4497 PR4608 PR4629 PR4821-PR4824 PR5112 PR5203 PR5301 R1716 R1731 R1739 R2441 R2444 R2710 R4311 R4369 R4370 R4380 R5547 R6348 R7205 R7406 R7408 R7423-R7427 R7431 R7433 = R402H16: tolerance: 64.10035.6DL
PR4407 = R3720H40: tolerance: 64.R0105.7FL
PR4410 = R402H16: tolerance: 64.10535.60L
PR4411 PR4636 PR4658 R302 R6407 = R402H16: tolerance: 64.49905.6DL
PR4412 PR4430 PR4433 PR4462 PR4476 PR4486-PR4489 PR4498 R319 R2602 R2613 R2614 R4301 R5560 R5562 = 0R0402-PAD: tolerance: ZZ.R0402.ZZZ
PR4413 = R402H16: tolerance: 64.73215.6DL
PR4414 R2701 R2736 = 0R0805-PAD: tolerance: ZZ.R0805.ZZZ
PR4416 = R603H22: tolerance: 63.2R233.15L
PR4420 PR4441 PR4443 PR4446 R2203 = R603H22: tolerance: 63.00000.00L
PR4422-PR4425 = R402H16: tolerance: 64.1R005.6DL
PR4426 = R402H16: tolerance: 64.19635.6DL
PR4427 PR4429 R1506 R1508 R1510 R1524 = R402H16: tolerance: 64.10035.L1L
PR4431 PR4473 PR4505 PR5101 R403 R1715 R1737 R2417 R2434 R2436 R2449-R2451 R2454 R2465 R2467 R2480 R2489 R2496 R2497 R2518 R2520 R2702 R2717 R3602 R3605 R3606 R3618 R4031 R4309 R4318 R4378 R5544 R5782 R5822 R5823 R6337 R6508 R7010 R7014 R7405 R7407 R7415 R9212 = R402H16: tolerance: 63.10434.1DL
PR4432 PR4450 PR5204 R1306 R2414 R2448 R4334 R5553 R5554 R5564 R7201 R7202 R7219 R7402 R7428 = R402H16: tolerance: 64.10025.6DL
PR4434 PR4437 PR4445 PR4452 PR4453 PR4464 PR4465 PR4477 PR4480 PR4484 PR4490 PR4493 R4368 R4469-R4471 R4481 R4482 R5821 R7403 = R402H16: tolerance: 64.R0005.6DL
PR4435 PR4472 = R402H16: tolerance: 64.10035.L3L
PR4436 PR4513 PR4514 PR5114 R1841 R2567 R5818-R5820 R7011 = R402H16: tolerance: 63.10534.1DL
PR4438 PR4463 PR4495 R1708 R2051 R2067 R2125 R3104 R3203 R3601 R3607 R5545 R5550 R5551 R5561 R5563 R5565 R6201 R6322 R6327 R6408 R6409 R6412 R6502 R6505 R6506 R6601 R6602 R6608 R6610 R7114 R7116 R7118 R7175 R7176 R9101 R9121 R9130 R9149-R9152 R9211 R9301 = R402H16: tolerance: 63.R0034.1DL
PR4439 PR4478 PR4506 PR4507 PR4509 PR4511 PR4603 PR4615 PR4670 R4312 R7213 = R402H16: tolerance: 64.10015.6DL
PR4442 PR4504 PR4516 PR4601 PR4602 PR4612 PR4613 PR4623 PR4647 PR4649 PR4665-PR4668 PR4671 PR4701 PR4706 PR4707 PR4802 PR4806 PR4811 PR4812 PR5004 PR5117 PR5121 PR5122 PR5210 PR5308 R504 R701 R702 R1104 R1205 R1210 R1212 R1303 R1311 R1618 R1713 R1804 R2402 R2428 R2435 R2462 R2466 R2470 R2472 R2515 R2516 R2612 R2703-R2705 R2708 R2709 R2712 R2725 R2907 R2909 R2914 R2923-R2927 R3101 R3501 R3503 R3506 R3507 R3512 R4002 R4011 R4024 R4029 R4030 R4036 R4042 R4047 R5605 R6002 R6004 R6301 R7004 R7007 R7126-R7130 R7203 R7204 R7210 R9321 R9322 = 0R0402-PAD: tolerance: ZZ.R0402.001
PR4444 R2446 = 0R0603-PAD-1-U: tolerance: ZZ.00PAD.M21
PR4447 = R402H16: tolerance: 64.12735.6DL
PR4448 PR4449 R2711 R5552 R5555 R5764 R7214 R7401 R7429 R7430 R7432 = R402H16: tolerance: 64.20035.6DL
PR4451 = R402H16: tolerance: 64.95325.6DL
PR4475 = R402H16: tolerance: 64.68035.6DL
PR4485 = R402H16: tolerance: 64.18235.6DL
PR4491 = R402H16: tolerance: 64.71515.6DL
PR4492 = NTC-402H24-U: tolerance: 69.60028.031
PR4494 = R402H15: tolerance: 63.47434.L0L
PR4499 PR4614 PR4669 R404 R1307 R1619 R1718 R1806 R2403 R2409 R2427 R2438 R2452 R2453 R2461 R2476 R2505 R2738 R3610 R3611 R3616 R3617 R4014 R4017 R4033 R4034 R4040 R5533 R5826-R5833 R5838 R5839 R5844 R5845 R6108-R6110 R6370 R6801 R6878 R7206 = R402H15: tolerance: 63.R0034.L0L
PR4501 PR4502 PR5105 R2204 R2205 = 0R0603-PAD: tolerance: ZZ.R0603.ZZZ
PR4508 PR4512 = R402H16: tolerance: 64.20035.L0L
PR4551 = R402H16: tolerance: 64.34835.6DL
PR4604 PR4607 = R402H16: tolerance: 64.10005.L1L
PR4605 = R402H16: tolerance: 64.75R05.6DL
PR4606 = R402H16: tolerance: 64.45R35.6DL
PR4609 R1204 R1208 R1211 R1302 R1310 = R402H15: tolerance: 64.10025.L0L
PR4610 = R402H16: tolerance: 63.1R034.1DL
PR4611 PR4646 PR4650 = NTC-402H22-U: tolerance: 69.60011.201
PR4616 = R402H16: tolerance: 64.15425.6DL
PR4617 PR4654 = NTC-402H22-U: tolerance: 069.60012.0001
PR4618 PR4643 PR4652 = R402H16: tolerance: 64.11025.6DL
PR4620 = R402H16: tolerance: 64.41205.6DL
PR4621 PR4655 = R402H16: tolerance: 64.27425.6DL
PR4622 PR4809 PR4815 R2908 R2910 = R402H16: tolerance: 64.10R05.L1L
PR4624 = R402H16: tolerance: 64.49R95.L0L
PR4625 PR4641 PR4653 = R402H16: tolerance: 64.26115.6DL
PR4626 = R402H16: tolerance: 64.33015.6DL
PR4627 PR4631 PR4639 PR4659 PR4663 R503 R706-R708 R807-R810 R1604 = R402H14: tolerance: 64.10005.6DL
PR4628 = R402H16: tolerance: 64.93115.6DL
PR4630 PR4638 PR4657 = R402H16: tolerance: 64.20015.L0L
PR4632 = R402H16: tolerance: 64.30105.6DL
PR4633 = R402H16: tolerance: 64.25515.6DL
PR4637 = R402H16: tolerance: 64.17815.6DL
PR4640 = R402H16: tolerance: 64.24915.L0L
PR4642 = R402H16: tolerance: 64.52305.6DL
PR4644 = R402H16: tolerance: 64.40225.6DL
PR4645 PR4651 = R402H15: tolerance: 64.10015.L3L
PR4648 = R402H16: tolerance: 64.35705.6DL
PR4656 = R402H16: tolerance: 64.28715.6DL
PR4660 = R402H16: tolerance: 64.19115.6DL
PR4661 R4377 = R402H16: tolerance: 64.84525.6DL
PR4662 = R402H16: tolerance: 64.11825.6DL
PR4704 PR4813 PR4825 = R402H16: tolerance: 64.2R205.6DL
PR4705 PR5001 = R603H24: tolerance: 64.2R205.L0L
PR4708 PR4808 PR4816 PR5003 = R402H16: tolerance: 64.36515.6DL
PR4709 PR4805 PR4814 = R1206H28: tolerance: 63.2R232.11L
PR5102 = R402H16: tolerance: 64.64915.6DL
PR5103 = R402H16: tolerance: 64.62015.6DL
PR5104 = R402H16: tolerance: 64.10225.6DL
PR5106 = R402H16: tolerance: 64.51035.6DL
PR5108 = R402H16: tolerance: 63.10034.L0L
PR5109 R7414 = R402H16: tolerance: 63.47334.1DL
PR5119 = R402H16: tolerance: 64.29425.6DL
PR5120 = R402H16: tolerance: 64.13725.6DL
PR5201 = R402H16: tolerance: 64.88725.6DL
PR5202 = R402H16: tolerance: 64.31615.6DL
PR5304 = R402H16: tolerance: 64.18025.6DL
PR5305 R7418 = R402H16: tolerance: 64.14325.6DL
PT4701 PT4802 PT4803 = CT7343H83: tolerance: 79.33719.20C
PT4702 PT4807 = CT7343H79: tolerance: 077.23361.0001
PU4301 PU4302 PU4412 PU4413 U7418 = PPAK-8P-3232H36: tolerance: 84.07403.037
PU4401 = QFN32J4-G2D85H34: tolerance: 074.09538.0073
PU4403-PU4406 = PPAK-8P-3232H36: tolerance: 084.07380.0037
PU4501 = QFN20Z3-G1D1H36: tolerance: 074.08286.0043
PU4502 = QFN20Z3-G1D1H36: tolerance: 074.08288.0B43
PU4601 = QFN40J5-G3D6-DIFF-H34: tolerance: 074.95859.0D33
PU4701 PU4801 PU4802 = QFN31G5-G4P-9H34: tolerance: 074.05038.0A73
PU5001 = DFN8G2-G1710-U1H40: tolerance: 074.95808.0B73
PU5002 PU5003 = PPAK-8P-3232H36: tolerance: 084.07408.0037
PU5101 PU5301 = SOIC8-G3530H63: tolerance: 074.05934.003D
PU5102 = QFN32J4-G3PH32: tolerance: 074.05388.0043
PU5201 = QFN22G4-G2PH42: tolerance: 074.02262.0043
PWR1 = 196415-06031-3: tolerance: 020.K0002.0006
Q501 Q4301 Q6302 Q6401 Q6501 = SOT23DGS2D4H44: tolerance: 084.00138.0A31
Q1701 Q7407 = SOT-363H44: tolerance: 075.00138.0A7C
Q1801 = SOT-363H44: tolerance: 75.27002.F7C; signal model: wistron_Q1801
Q2507 Q4348 Q6502 Q7401 Q9201 = SOT23DGS2D4H44: tolerance: 084.03415.0031
Q2601 = SOT-363H44: tolerance: 75.27002.F7C; signal model: wistron_Q2601
Q2603 Q4302 = SOT23CBE2D4H46-U: tolerance: 84.T3904.K11
Q4304 = SOT323CBE2D2H40: tolerance: 84.05212.B11
Q4305 = SC70-2D2-312H44: tolerance: 84.00024.01K
Q5501 Q5502 = SOT23CBE2D4H44: tolerance: 84.03906.G11
Q5504 Q5505 = SOT-23-9H44: tolerance: 84.03904.I11
Q5702 = SOT-363H44: tolerance: 75.27002.F7C; signal model: wistron_Q5702
Q5703 Q6408 = SOT23CBE2D4H44: tolerance: 84.T3904.H11
Q6403-Q6405 Q6505 = SOT23CBE2D6H62: tolerance: 084.02418.0011
Q6407 = SOT-323H44: tolerance: 84.00144.K11
R301 R308 R315 R1502 R1517 R1518 R1702 R1909 R2432 R2458 R2495 R2739 R2740 R2921 R2922 R3103 R3109 R4005 R6513 R6877 R7140-R7143 R7145-R7147 R7152 R7170-R7174 = R402H16: tolerance: 63.10234.1DL
R304 R305 R601 = R402H16: tolerance: 64.49R95.6DL
R309-R314 R316-R318 = R402H16: tolerance: 63.51034.1DL
R401 R1209 R1309 = R402H16: tolerance: 64.24R95.6DL
R402 R405 R406 R1606 R1617 R1701 R1707 R1714 R1717 R1721 R1726 R1738 R1817 R1820-R1823 R1825-R1827 R1910 R1911 R1922 R2007-R2010 R2041 R2043-R2047 R2053 R2059-R2066 R2068 R2111-R2118 R2415 R2430 R2443 R2514 R2607 R4009 R4303 R5557 R6114 R6115 R6343 R6369 R6403 R6411 R6415 R6511 R6609 R6611 R7006 R7189 R7216 R9119 R9148 = R402H16: tolerance: 63.10334.1DL
R501 = R402H16: tolerance: 64.12105.6DL
R502 = R402H16: tolerance: 64.80R65.6DL
R505 R5705 R5759 R5773-R5778 = R402H16: tolerance: 64.47005.6DL
R506 R507 R7185-R7188 = R402H16: tolerance: 64.22035.6DL
R703 = R402H16: tolerance: 63.22134.1DL
R704 = R402H16: tolerance: 63.56034.1DL
R705 = R402H16: tolerance: 64.54R95.6DL
R811 R812 R815-R817 = GAP-CLOSE-PWR-0805-NP: tolerance: ZZ.PAD01.0N1
R1103 R2202 R2715 R2906 R2911 = 0R0603-PAD-U: tolerance: ZZ.R0603.001
R1206 R1305 = R402H16: tolerance: 64.2R005.6DL
R1215 R1312 = R402H16: tolerance: 64.24005.6DL
R1504 R1513 R1520-R1522 = R402H15: tolerance: 63.47234.L0L
R1512 R1516 R1551 R2506 R2519 R2521 R2912 R2913 R5517 R5518 R5805 R5807-R5816 R7190 R7211 = R402H16: tolerance: 63.47234.1DL
R1515 R4316 = R402H16: tolerance: 63.20334.1DL
R1554 = R402H16: tolerance: 64.20525.6DL
R1603 = R402H16: tolerance: 64.11305.6DL
R1609 = 0R0402-PAD: tolerance: ZZ.R0402.001; signal model: wistron_R1609
R1610 = 0R0402-PAD: tolerance: ZZ.R0402.001; signal model: wistron_R1610
R1611 = 0R0402-PAD: tolerance: ZZ.R0402.001; signal model: wistron_R1611
R1616 = 0R0402-PAD: tolerance: ZZ.R0402.001; signal model: wistron_R1616
R1719 R2517 R4308 = R402H16: tolerance: 64.47025.6DL
R1730 = R402H16: tolerance: 63.33434.1DL
R1803 = R402H16: tolerance: 64.60R45.6DL
R1805 = R402H16: tolerance: 64.33R05.6DL; signal model: wistron_R1805
R1815 R2504 = R402H16: tolerance: 63.10634.1DL
R1837 = R402H16: tolerance: 63.15434.1DL
R1839 R1840 R4305 R6117 = R402H16: tolerance: 63.33034.1DL
R1842 = R402H14: tolerance: 64.10R05.6DL; signal model: wistron_R1842
R1843 = R402H14: tolerance: 64.10R05.6DL; signal model: wistron_R1843
R1844 = R402H14: tolerance: 64.10R05.6DL; signal model: wistron_R1844
R1845 = R402H14: tolerance: 64.10R05.6DL; signal model: wistron_R1845
R1846 = R402H14: tolerance: 64.10R05.6DL; signal model: wistron_R1846
R1901 R2108 = R402H16: tolerance: 64.20005.6DL
R1908 = R402H16: tolerance: 64.33R05.6DL; signal model: wistron_R1908
R1912 R1913 = R402H16: tolerance: 64.33R05.6DL
R1920 = R402H16: tolerance: 64.33R05.6DL; signal model: wistron_R1920
R1921 = R402H16: tolerance: 64.33R05.6DL; signal model: wistron_R1921
R2048 R2049 R6507 = R402H16: tolerance: 63.51334.1DL
R2057 = R402H16: tolerance: 64.33R05.6DL; signal model: wistron_R2057
R2058 = R402H16: tolerance: 64.33R05.6DL; signal model: wistron_R2058
R2421 R2483 R6405 = R402H16: tolerance: 63.33134.1DL
R2424 R3603 R4006 R6504 = R402H16: tolerance: 64.20025.6DL
R2437 = R402H16: tolerance: 63.43034.1DL
R2442 = R402H16: tolerance: 64.15435.6DL
R2447 = 0R0402-PAD: tolerance: ZZ.R0402.001; signal model: wistron_R2447
R2455 = 0R0402-PAD: tolerance: ZZ.R0402.001; signal model: wistron_R2455
R2459 = 0R0402-PAD: tolerance: ZZ.R0402.001; signal model: wistron_R2459
R2460 = 0R0402-PAD: tolerance: ZZ.R0402.001; signal model: wistron_R2460
R2501 = R402H16: tolerance: 64.33R05.6DL; signal model: wistron_R2501
R2502 = R402H16: tolerance: 64.33R05.6DL; signal model: wistron_R2502
R2503 = R402H16: tolerance: 64.33R05.6DL; signal model: wistron_R2503
R2507 = R402H16: tolerance: 64.33R05.6DL; signal model: wistron_R2507
R2508 = R402H16: tolerance: 64.33R05.6DL; signal model: wistron_R2508
R2509 = R402H16: tolerance: 64.33R05.6DL; signal model: wistron_R2509
R2510 = R402H16: tolerance: 64.33R05.6DL; signal model: wistron_R2510
R2511 = R402H16: tolerance: 64.33R05.6DL; signal model: wistron_R2511
R2512 = R402H16: tolerance: 64.33R05.6DL; signal model: wistron_R2512
R2513 = R402H16: tolerance: 64.33R05.6DL; signal model: wistron_R2513
R2601 R2615 R2616 R9302-R9305 R9308 R9309 R9312-R9314 R9316-R9320 R9323-R9338 = R0201H12: tolerance: 63.R003C.1IL
R2603 R2604 = R402H16: tolerance: 64.75015.6DL
R2608 = R402H16: tolerance: 64.27025.6DL
R2610 = NTC-603H38: tolerance: 69.60035.041
R2724 = R402H16: tolerance: 63.33034.1DL; signal model: wistron_R2724
R2735 = R402H16: tolerance: 63.22234.L0L
R3102 = R402H16: tolerance: 64.24915.6DL
R3113 = R402H16: tolerance: 63.15334.1DL
R3202 = R402H16: tolerance: 63.51134.1DL
R3502 = 0R0402-PAD: tolerance: ZZ.R0402.001; signal model: wistron_R3502
