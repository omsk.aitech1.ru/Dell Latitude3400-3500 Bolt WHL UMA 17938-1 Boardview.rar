# Allegro board 17938-1.1228WZS1107.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_WAKE#: length 340.6
  TOP w0.102: R2428.1 136.94,76.57 136.61,76.25 134.39,76.25 133.67,76.97 133.46,76.97 131.96,78.48 131.96,78.49 v1(131.94,78.5) 131.94,80.85 133.31,82.22 135.77,82.22 136.43,82.88 v1(136.71,82.88)
  L3 w0.102: v1(136.71,82.88) 136.27,83.31 133.92,83.31 130.47,86.76 127.85,86.76 127.78,86.69 126.14,86.69 125.38,85.93 124.97,85.93 124.23,86.67 121.99,86.67 121.76,86.43 121.47,86.43 120.37,85.33 119.67,85.33 119.34,85 116.43,85 114.79,86.64 114.79,86.92 114.55,87.16 114.17,87.16 112.65,88.67 v1(112.55,88.67)
  L4 w0.102: v1(41.26,76.08) 41.26,76.04 38.38,73.16 27.73,73.16 26.27,71.71 25.13,71.71 21.59,68.17 21.59,68.07 20.91,67.39 20.91,66.49 20.83,66.41 20.83,65.28 19.84,64.29 19.84,63.29 18.47,61.92 18.47,61.36 17.24,60.13 17.24,58.31 16.86,57.93 16.86,52.54 16.28,51.96 16.28,45.33 15.02,44.07 15.02,40.85 16.73,39.14 16.73,38.86 17.07,38.52 17.07,35.19 17.36,34.9 17.36,31.23 22.19,26.39 27.33,26.39 28.66,27.72 32.52,27.72 38.79,33.99 51.41,33.99 54.77,37.34 54.77,38.84 56.21,40.28 64.75,40.28 65.01,40.54 67.01,40.54 67.02,40.53 72.95,40.53 72.96,40.52 73.81,40.52 73.82,40.53 81.14,40.53 81.94,41.32 82.74,41.32 83.37,40.69 90.46,40.69 90.72,40.96 93.74,40.96 94.37,41.59 95.8,41.59 96.05,41.84 97.9,41.84 98.47,42.41 100.02,42.41 100.26,42.65 101.02,42.65 101.7,43.33 102.06,43.33 102.09,43.31 102.34,43.06 102.34,43.05 102.66,42.74 107.36,42.74 109.13,44.51 121.95,44.51 124.61,41.85 132.17,41.85 132.33,41.69 149.22,41.69 151.19,39.73 155.93,39.73 156.23,40.02 156.23,40.68 156.54,41 157.64,41 160.71,44.07 160.71,50.21 150.94,59.98 150.14,59.98 149.18,60.94 149.18,63.04 146.81,65.4 146.81,66.33 142.23,70.9 133.33,75.96 133,76.3 133,76.81 132.59,77.22 131.9,77.22 131.65,77.47 131.65,77.83 131.96,78.13 131.96,78.49 v1(131.94,78.5)
  BOTTOM w0.102: RN1704.6 139.69,83.9 139.23,83.44 139.22,83.44 138.23,82.45 137.14,82.45 v1(136.71,82.88) ; v1(112.55,88.67) 112.16,88.28 CPU1.BU30 ; D1702.3 55.08,83.61 v2(55.08,79.79) 53.84,78.55 51.88,78.55 50.63,77.29 49.52,77.29 49.16,76.93 44.24,76.93 43.53,77.64 42.62,77.64 42.62,77.65 42.1,77.65 42.1,77.64 41.5,77.64 41.12,77.27 41.12,76.43 41.26,76.29 v1(41.26,76.08)
PCIE_LAN_WAKE#: length 20
  TOP w0.102: v1(49.88,83.32) 49.88,83.38 49.91,83.41 R3103.1 49.58,83.74 U3101.21
  BOTTOM w0.102: v1(49.88,83.32) 50.13,83.57 v2(50.13,84.19) 50.13,89.26 50.46,89.59 50.9,89.59 51.62,88.86 52.06,88.86 53.7,87.22 53.7,83.42 D1702.1 53.1,81.64 D2404.1
PCIE_RCOMPN: length 3.9
  TOP w0.152: R1604.1 115.62,104.73 116.64,104.73 116.87,104.5 116.87,103.2 117.13,102.94 v1(117.27,102.94)
  BOTTOM w0.305: CPU1.CE6 v1(117.27,102.94)
PCIE_RCOMPP: length 3.7
  TOP w0.152: v1(117.3,103.62) 117.3,104.62 116.82,105.11 115.74,105.11 R1604.2
  BOTTOM w0.305: v1(117.3,103.62) 117.01,103.92 CPU1.CE5
PCIE_WAKE#: length 40.3
  TOP w0.089: U2401.4 23.72,71.28 v1(22.01,71.28) 21.84,71.28 20.31,72.81 R2495.2
  L3 w0.089: v1(25.99,74.97) 24.06,73.03 22,73.03 21.63,72.67 21.63,72.64 21.63,72.64 21.63,72.2 21.63,72.2 21.63,71.66 v1(22.01,71.28)
  BOTTOM w0.089: D2404.3 51.4,78.98 50.37,77.95 49.2,77.95 48.81,77.55 44.51,77.55 43.7,78.37 42.92,78.37 42.53,78.76 42.18,78.76 42.17,78.75 41.24,78.75 v2(40.93,78.45) 40.64,78.45 40.54,78.34 40.54,78.34 39.85,77.66 39.85,77.66 38.16,75.97 37.94,75.97 37.92,75.95 27.6,75.95 27.41,75.75 27.39,75.75 27.27,75.64 26.66,75.64 v1(25.99,74.97)
PD4403_A: length 3.7
  TOP w0.102: PD4404.A 153.65,104.14 153.44,104.34 v2(153.04,104.34) 152.82,104.13 152.34,104.13 151.88,104.58 PQ4408.B
PD4403_K: length 190.3
  TOP w0.089: v1(157.41,33.81) 156.82,33.81 v2(156.77,33.76) 156.78,33.75 PR4452.2 ; PD4404.K 153.65,100.26 PR4477.2 154.13,100.15 154.28,100.31 154.28,101.54 153.21,102.62 v1(153.06,102.62)
  L3 w0.089: v1(157.41,33.81) 157.41,34.18 160.94,37.71 164.82,37.71 166.14,36.38 167.37,36.38 168.47,37.49 170.32,37.49 171.14,36.67 181.8,36.67 183.78,34.69 185.82,34.69 188.85,37.72 188.85,37.82 189.86,38.83 192.81,38.83 193.05,38.6 196.28,38.6 196.47,38.41 200.73,38.41 200.87,38.55 207.34,38.55 207.73,38.95 212.82,38.95 216.01,42.13 216.9,42.13 218.82,44.05 218.82,47.75 219.63,48.57 219.93,48.57 221.69,50.32 221.69,62.67 219.89,64.47 219.89,64.52 217.28,67.13 209.83,67.13 208.92,66.22 189.11,66.22 186.9,68.44 183.15,68.44 182.13,67.41 178.39,67.41 177.56,68.25 175.67,68.25 175.54,68.37 175.48,68.37 174.49,69.36 173.81,69.36 171.56,71.61 171.56,72.73 163.23,81.05 163.23,82.74 162.4,83.57 162.4,84.82 161.97,85.25 161.97,86.64 161.27,87.34 161.26,87.34 161.01,87.59 161.01,87.59 152.94,95.67 152.94,98.56 153.41,99.04 153.41,102.27 v1(153.06,102.62)
PD_SWD_CLK: length 2
  TOP w0.14: U7201.1 42.56,108.94 42.82,108.68 42.82,107.82 TP7201.1
PD_VBUS_C_CTRL1: length 21
  TOP w0.102: v1(37.66,110.35) 37.94,110.35 38.26,110.66 U7201.15 ; v1(28.96,109.53) 29.24,109.25 29.24,108.3 29.76,107.77 30.18,107.77 30.42,107.53 Q7406.5 30.41,106.19 v2(30.01,105.79)
  L3 w0.102: v1(28.96,109.53) 28.96,109.53 29.11,109.53 29.48,109.16 35.55,109.16 35.74,108.97 35.74,108.84 36.45,108.13 36.81,108.13 37.24,108.56 37.24,109.92 v1(37.66,110.35)
  BOTTOM w0.102: Q7405.2 26.39,107.9 26.67,108.18 27.59,108.18 27.71,108.31 27.71,108.74 27.99,109.02 28.28,109.02 28.61,109.35 28.68,109.35 28.86,109.53 28.95,109.53 v1(28.96,109.53)
PD_VBUS_C_CTRL1_A: length 1.8
  BOTTOM w0.102: Q7404.3 25.62,108.5 25.74,108.37 Q7405.1
PD_VBUS_C_CTRL1_R: length 5.7
  BOTTOM w0.102: Q7405.5 26.39,104.63 R7429.1 25.74,104.56 Q7405.6 25.44,105.68 25.07,106.05 25.07,107.35 R7426.2
PD_VBUS_C_EN_A: length 18.4
  TOP w0.102: Q7407.5 30.05,114.36 29.48,114.94 R7432.1 29.24,115.14 v2(28.53,115.14) 28.25,114.86 28.25,114.51 v1(28.29,114.47) 28.31,114.45 29.09,114.45 29.4,114.14 Q7407.6
  BOTTOM w0.102: Q7405.3 27.04,106.77 26.88,106.61 25.5,106.61 25.28,106.83 25.28,108.48 25.26,108.5 25.26,108.88 R7425.2 24.62,109.75 24.9,110.03 27.16,110.03 27.27,110.15 27.27,111.93 27.56,112.22 27.8,112.22 27.9,112.32 27.9,112.56 28.08,112.74 28.08,114.27 v1(28.29,114.47)
PD_VBUS_C_EN_B: length 42.8
  TOP w0.102: v1(53.27,125.12) 53.48,124.91 R7433.2 ; R7427.2 38.36,120.68 38.81,121.13 38.92,121.13 39.17,121.39 39.53,121.39 40.18,122.04 U7419.A3 40.84,122.07 v1(40.9,122.12) ; v1(30.25,115.16) 30.25,115.63 v2(30.34,115.72) 30.37,115.75 30.37,115.77 30.4,115.8 30.58,115.8 31.16,115.23 31.16,113.87 31.17,113.86 31.17,112.82 30.7,112.36 Q7407.3
  L3 w0.102: v1(30.25,115.16) 30.63,115.54 30.98,115.54 33.23,117.78 37.46,117.78 37.94,118.26 37.94,120.31 38.43,120.8 39.3,120.8 40.62,122.12 v1(40.9,122.12)
  BOTTOM w0.102: R7422.1 27.36,115.16 v1(30.25,115.16) ; v1(53.27,125.12) 53.27,125.68 52.07,126.87 47.95,126.87 44.79,123.72 44.79,123.18 44.38,122.76 42.73,122.76 42.09,122.12 v1(40.9,122.12)
PD_VBUS_DISCHG: length 9.6
  TOP w0.102: U7201.12 38.64,112.39 38,111.75 v2(36.81,111.75) 36.11,111.75 35.5,111.14 35.5,110.58 35.04,110.12 R7415.1 33.05,109.73 33.59,109.18 Q7408.G
PD_VBUS_DISCHG_N1: length 62.6
  TOP w0.254: v1(33.84,107.82) 33.57,107.55 Q7408.D 33.57,106.07 v2(33.6,106.03) ; v1(35.05,132.77) 35.17,132.89 35.17,133.03 35.18,133.04 35.18,133.61 35.54,133.96 38.41,133.96 38.76,134.31 41.55,134.31 43.23,132.63 43.23,132.57 43.46,132.34 43.46,130.96 44.3,130.13 R7410.2
  L4 w0.254: v1(35.05,132.77) 35.05,132.2 34.52,131.67 32.41,131.67 28.91,128.17 28.91,125.33 27.79,124.21 27.79,121.21 26.37,119.79 26.37,116.41 27.54,115.24 27.54,114.38 26.7,113.54 26.7,111.28 26.39,110.97 26.39,103.66 28.27,101.78 30.62,101.78 33.84,105 v1(33.84,107.82)
PD_VCCD: length 3
  TOP w0.254: C7202.1 42.02,107.53 v2(41.3,106.8) 40.78,107.32 40.78,107.99 40.83,108.04 U7201.22
PD_XRES: length 3.5
  TOP w0.102: U7201.7 41.83,113.1 42.07,113.35 v2(42.07,113.41) 42.07,113.48 41.94,113.62 41.94,114.45 R7211.1 42.27,114.46 C7213.1
PDB_R: length 2.9
  TOP w0.089: 30.06,15.96 29.67,15.57 HDA27.40
  TOP w0.102: 30.06,15.96 30.34,16.23 31.37,16.23 31.68,16.54 R2712.2
PECI_CPU: length 86.2
  TOP w0.254: v1(47.13,71.97) 47.13,71.98 45.06,71.98 44.59,72.45 43.22,72.45 42.53,73.14 R2437.2 ; v1(53.88,76.3) v2(53.88,75.74)
  L3 w0.254: v1(53.88,76.3) 53.77,76.41 53.05,76.41 52.94,76.3 52.56,75.92 52.56,75.25 50,72.7 49.12,72.7 48.38,71.96 47.15,71.96 47.14,71.97 v1(47.13,71.97)
  L4 w0.254: v1(53.88,76.3) 54.47,76.3 55.43,77.26 55.43,78.06 62.52,85.15 62.52,88.88 65,91.37 65,96.5 65.58,97.08 66.55,97.08 68.08,95.56 76.41,95.56 76.77,95.92 90.29,95.92 92.57,98.21 93.94,98.21 95.11,99.38 95.11,100.12 95.1,100.13 95.1,102.11 95.63,102.64 95.63,103.95 95.99,104.31 95.99,105.33 95.96,105.36 95.96,108.04 96.55,108.63 98.01,108.63 98.52,108.12 v1(98.52,107.16)
  BOTTOM w0.14: v1(98.52,107.16) 98.5,107.15 CPU1.AR1
PEQ: length 5.1
  TOP w0.102: U5802.8 v1(49.7,114.61)
  BOTTOM w0.102: R5816.2 52.77,114.33 R5805.2 52.04,115.1 51.75,114.81 51.62,114.68 49.78,114.68 v1(49.7,114.61)
PIRQA#: length 35
  TOP w0.102: R2053.2 114.66,79.92 114.66,84.08 115.98,85.4 115.98,86.47 v1(116.21,86.7) ; R9152.2 137.41,87.78 v2(135.69,87.78) 133.99,87.78 132.94,86.73 v1(131.53,86.73)
  L3 w0.089: v1(116.21,86.7) 116.9,86.01 117.61,86.01
  L3 w0.102: v1(131.53,86.73) 131.09,87.17 127.68,87.17 127.62,87.11 121.86,87.11 121.6,86.84 121.59,86.84 121.58,86.83 120.91,86.83 120.31,86.23 119.61,86.23 119.47,86.37 118.78,86.37 118.43,86.01 117.61,86.01
  BOTTOM w0.102: CPU1.CC32 v1(116.21,86.7)
PLTRST#_CPU: length 470.2
  TOP w0.089: v1(24.61,30.32) 24.17,30.32 21.16,27.31 v1(21.16,24.06) ; v1(49.45,82.65) 49.43,82.67 49.05,82.67 48.96,82.76 48.95,82.76 48.79,82.92 48.55,82.92 48.54,82.94 U3101.19 ; v1(163.27,61.93) 163.58,62.23 163.58,63.07 159.72,66.93 158.22,66.93 148.8,76.35 146.54,76.35 146.3,76.11 145.26,76.11 144.76,75.6 132.2,75.6 131.11,76.69 130.86,76.69 129.73,77.83 129.73,78.07 128.54,79.26 127.95,79.26 126.87,79.41 126.22,79.41 125.69,78.88 125.69,75.96 125.68,75.96 125.68,75.74 125.35,75.41 124.06,75.41 123.69,75.78 114.23,75.78 v1(112.11,77.91) ; R6370.2 148.77,105.61 149.52,104.86 150.49,104.86 152.44,106.81 156,106.81 157.79,108.6 157.79,110.51 159.35,112.07 159.35,112.59 159.72,112.96 159.72,118.37 159.92,118.57 v1(159.92,118.77) ; WWAN1.19 218.37,54.55 218.51,54.7 220.01,54.7 220.51,55.19 220.51,56.62 219.29,57.84 219.29,59.48 219.51,59.7 219.51,60.2 219.36,60.34 219.36,64.47 219.7,64.8 v1(220.67,64.8) ; v1(43.17,102.87) 43.59,102.45 43.59,101.88 AFTP6108.1
  L3 w0.089: v1(220.67,64.8) 220.67,64.92 217.67,67.92 209.77,67.92 208.6,66.76 189.37,66.76 187.12,69.01 182.97,69.01 181.91,67.95 178.62,67.95 177.78,68.78 176.91,68.78 174.87,70.83 174.16,70.83 v1(174.13,70.85) 174.07,70.92 174.07,71.95 164.47,81.55 164.47,83.3 163.62,84.15 163.62,84.83 163.62,84.83 163.62,85.32 163.17,85.77 163.17,86.51 163.39,86.74 163.39,88.28 160.49,91.18 159.4,91.18 158.47,92.11 158.47,93.19 154.78,96.88 154.78,97.28 154.69,97.37 154.69,104.16 156.19,105.65 156.19,106.46 157.79,108.06 157.79,110.16 158.99,111.37 158.99,111.8 158.99,112.59 159.29,112.88 159.29,113.21 159.44,113.36 159.44,116.57 159.54,116.67 159.7,116.83 160.18,117.31 160.18,118.52 v1(159.92,118.77) 159.92,119.17 159.37,119.72 159.37,130.73 163.67,135.03 163.67,137.66 162.08,139.25 160.98,139.25 160.34,138.61 158.8,138.61 156.53,140.89 v1(156.16,140.89) ; v1(42.48,91.89) 41.51,90.91 41.51,82.68 42.34,81.84 42.34,80.53 43.03,79.85 43.03,78.94 v1(43,78.91) 43,78.35 42.37,77.73 42.37,76.71 v1(42.27,76.61) 42.16,76.5 40.99,76.5 37.62,73.13 29.71,73.13 29.19,72.6 29.19,72.05 26.9,69.76 25.43,69.76 24.05,68.38 24.05,68.07 23.14,67.16 23.14,65.15 23.14,65.15 23.14,65 22.89,64.75 22.74,64.75 22.39,64.4 22.39,63.94 22.14,63.69 21.68,63.69 21.53,63.54 21.53,63.33 21.28,63.08 21.07,63.08 20.81,62.82 20.81,62.67 20.56,62.42 20.56,61.29 20.54,61.27 20.54,60.92 20.56,60.9 20.56,60.75 20.57,60.75 20.57,59.88 20.68,59.78 20.68,57.76 20.95,57.49 20.95,56.13 21.1,55.97 21.1,52.47 21.7,51.87 21.7,50.78 20.81,49.89 20.81,44.96 22.02,43.75 22.02,42.52 23.85,40.69 23.85,39.96 23.77,39.88 23.77,38.46 22.63,37.32 22.63,37.32 22.49,37.17 22.49,35.75 22.74,35.5 23.43,35.5 23.68,35.26 23.68,31.26 v1(24.61,30.32)
  L4 w0.089: v1(43.17,102.87) 43.59,102.45 43.59,102.03 43.34,101.78 43.34,97.21 44.03,96.51 44.03,92.35 44.17,92.2 44.17,91.62 44.02,91.46 42.94,91.46 42.93,91.47 42.9,91.47 v1(42.48,91.89)
  BOTTOM w0.089: R1713.1 109.24,78.22 108.97,77.96 108.68,77.96 104.98,74.22 78.86,74.22 76.78,76.3 55.83,76.3 54.78,75.26 53.3,75.26 51.83,76.73 50.01,76.73 49.64,76.36 45.27,76.36 45.13,76.22 42.65,76.22 v1(42.27,76.61) ; R1713.1 109.49,78.52 110.28,77.74 111.95,77.74 v1(112.11,77.91) ; R1713.1 109.24,78.7 108.68,79.26 R1715.1 ; v1(156.16,140.89) 155.08,139.81 ED1701.2 ; ED1701.2 155.68,138.79 155.68,138.31 155.68,138.23 R2616.1 ; ED1701.2 154.87,139.17 C1701.1 153.65,139.54 152.61,139.54 152.47,139.4 U9103.17 ; v1(43.17,102.87) 43.41,102.87 43.7,103.16 WLAN1.52 ; v1(163.27,61.93) 163.81,62.46 163.81,62.92 166.36,65.47 166.36,67.91 170.92,72.47 173.28,72.47 174.26,71.49 174.26,70.98 v1(174.13,70.85) ; v1(43,78.91) 43.44,78.91 44.62,77.73 48.73,77.73 49.13,78.13 50.08,78.13 50.88,78.92 50.88,79.82 50.86,79.83 50.86,82.22 50.43,82.65 v1(49.45,82.65) ; SSD1.50 24.2,24.25 23.34,23.39 21.48,23.39 21.16,23.72 v1(21.16,24.06)
PLTRST#_CPU_D: length 7.8
  TOP w0.102: Q6302.G 151.33,108.94 150.5,109.78 147.88,109.78 R6369.2 v2(146.4,109.06) 146.4,108.57 146.63,108.33 Q6301.D
PLTRST#_CPU_G: length 2.8
  TOP w0.102: Q6301.G 147.91,106.06 R6370.1 147.91,105.6 148.7,104.81 v2(148.73,104.81)
PM_LAN_ENABLE: length 1.6
  BOTTOM w0.102: U4001.5 60.16,127.55 60.58,127.13 60.58,126.85 R2466.1
PM_RSMRST#: length 288.4
  TOP w0.102: v1(111.42,83.25) 111.1,83.57 111.1,86.3 111.16,86.37 111.16,87.46 v1(110.74,87.87) ; 18.14,62.74 18.14,62.38 18.13,62.37 18.13,62.33 17.92,62.12 17.92,61.94 17.93,61.93 v1(17.93,61.87) ; 18.14,62.74 Q1701.3 ; 18.14,62.74 18.34,62.53 19.13,62.53 R1702.1
  L2SGND w0.102: v1(17.93,61.87) 17.9,61.84 17.9,59.12 17.59,58.82 17.59,50.96 18.19,50.37 18.19,45.77 18.2,45.75 18.2,45.66 18.21,45.65 18.21,45.52 20.87,42.86 20.87,41.16 21.85,40.18 21.85,38.28 22.56,37.57 24.5,37.57 24.86,37.21 25.45,37.21 25.99,36.67 25.99,35.59 25.42,35.03 25.42,33.15 26.79,31.78 26.79,30.72 27.05,30.46 27.54,30.46 v1(27.97,30.89)
  L3 w0.102: v1(110.74,87.87) 111.2,87.41 111.2,87.07 111.35,86.93 111.35,86.77 113.11,85.01 113.11,85.01 113.15,84.98 115.42,84.98 116.25,84.15 119.68,84.15 120.03,84.49 124.22,84.49 124.63,84.09 125.45,84.09 127.97,81.57 133.8,81.57 133.95,81.42 138.35,81.42 138.76,81.01 138.76,80.88 139.86,79.78 v1(140.23,79.78) ; v1(27.97,30.89) 29.17,32.09 32.07,32.09 32.53,32.55 56.88,32.55 58.32,34 61.26,34 62.64,35.39 71.18,35.39 71.2,35.41 71.24,35.41 75.29,39.46 84.75,39.46 85.01,39.71 97.55,39.71 100.01,42.18 102.12,42.18 102.47,42.53 105.68,42.53 106.3,43.15 107.56,43.15 108.85,44.45 121.31,44.45 123.48,42.28 126.2,42.28 127.14,41.33 127.14,40.84 v1(127.1,40.8)
  L4 w0.102: v1(140.23,79.78) 139.6,79.15 139.6,78.66 139.46,78.53 139.46,77.55 139.33,77.41 139.33,76.88 139.75,76.46 140.61,76.46 149.6,67.46 149.6,66.51 152.5,63.62 152.5,63.16 158.59,57.06 158.75,57.06 165.51,50.31 165.51,43.48 162.18,40.15 162.18,39.42 161.36,38.6 160.12,38.6 159.72,38.2 156.62,38.2 155.47,37.05 154.68,37.05 153.92,37.8 151.09,37.8 148.96,39.93 127.97,39.93 v1(127.1,40.8)
  BOTTOM w0.076: 111.48,83.31 111.48,83.49 111.23,83.74 111.23,84.11 111.12,84.31 CPU1.BR36
  BOTTOM w0.102: v1(110.74,87.87) 110.74,87.85 110.68,88.06 CPU1.BP30 ; 111.48,83.31 v1(111.42,83.25) ; v1(140.23,79.78) 140.69,79.78 v2(140.82,79.91) 140.88,79.91 141.24,80.27 142.04,80.27 142.75,80.98 142.75,81.49 143.11,81.85 143.82,81.85 143.93,81.74 RN1703.4 145.24,81.79 145.24,82.14 145.24,82.37 145.8,82.93 Q1702.2
PM_RSMRST#_M: length 3.8
  BOTTOM w0.102: Q1702.5 145.8,85.73 R1737.2 147.02,86.39 147.3,86.11 v2(147.3,85.65) 146.9,85.25 Q1702.6
PMBD_SCL_R: length 12.8
  TOP w0.14: Q9301.6 159.52,141.55 v1(159.57,141.59) 159.46,141.7 159.46,141.88 v2(159.82,142.24)
  BOTTOM w0.14: 159.57,141.44 159.57,141.2 159.74,141.02 161.52,141.02 161.9,140.64 161.9,139.64 161.64,139.38 161.4,139.38 161.31,139.29 161.29,139.29 160.77,138.78 RN9301.4 ; 159.57,141.44 158.9,140.77 158.38,140.77 157.98,140.37 R9321.2 ; 159.57,141.44 v1(159.57,141.59) 160.17,142.19 PMBD1.9
PMBD_SDA_R: length 14.4
  TOP w0.14: v1(160.36,146.69) 159.33,145.67 159.33,143.97 158.8,143.43 158.8,140.33 v1(158.82,140.31) ; v1(161.45,139.83) 160.82,139.2 Q9301.3
  BOTTOM w0.14: PMBD1.10 160.17,146.5 v1(160.36,146.69) ; R9322.2 160.73,139.19 160.1,138.56 RN9301.3 ; R9322.2 161.2,139.57 v1(161.45,139.83) ; R9322.2 160.3,139.57 v2(159.74,140.13) 159.56,140.31 v1(158.82,140.31)
POWER_SW_IN#: length 15
  TOP w0.102: U2401.127 25.55,74.5 25.56,74.5 25.56,75.13 25.28,75.41 25.14,75.41 24.36,76.18 24.36,76.18 C2426.1 22.66,77.88 22.28,77.88 19.64,75.23 19.64,74.65 v2(19.21,74.22) 18.23,73.24 18.23,73.07 R2451.1 18.24,71.76 18.84,71.76 R2432.2
PQ3802_1: length 11.9
  TOP w0.305: v1(20.16,93.59) 19.94,93.59 19.46,94.07 v2(19.46,94.13) 19.46,94.59 19.99,95.12 R4302.1 19.99,96.47 Q4302.B
  TOP w0.381: R4309.2 26.06,95.99 v1(26.55,95.51)
  L4 w0.635: v1(20.16,93.59) 20.16,93.87 20.5,94.21 23.98,94.21 25.28,95.51 v1(26.55,95.51)
PQ4348_D: length 14
  TOP w0.305: v1(37.67,127.84) 37.98,127.53 v2(37.98,127.33)
  TOP w0.508: R4368.2 37.47,128.04 v1(37.67,127.84) ; v1(29.73,127.08) 29.73,127.29 29.72,127.3 29.72,127.51 R4469.1 ; Q4348.D 30.71,125.35 v1(30.71,125.43)
  L4 w0.508: v1(37.67,127.84) 37.47,128.04 30.27,128.04 29.73,127.49 29.73,127.08 ; v1(30.71,125.43) 30.64,125.43 29.73,126.33 29.73,127.08 ; 29.73,127.08 v1(29.73,127.08)
PQ4405_2: length 205.1
  TOP w0.089: v1(208.14,38.11) 208.25,38.22 208.25,39.64 208.14,39.75 PR4462.1 207.44,40.13 207.44,41.31 207.66,41.54 208.03,41.54 208.3,41.81 208.4,41.91 208.4,44.41 208.46,44.47 208.46,46.13 208,46.6 PR4463.1 ; v1(145.77,146.46) 145.57,146.46 145.44,146.33 145.44,145.53 v2(145.51,145.47) PQ4405.2
  L3 w0.089: v1(145.77,146.46) 146.28,146.97 151.03,146.97 153.02,144.97 160.36,144.97 161.26,144.07 161.26,141.53 161.53,141.26 161.91,141.26 162.49,140.68 162.49,139.09 163.88,137.7 163.88,134.99 159.55,130.65 159.55,119.79 160.36,118.98 160.36,117.24 159.77,116.65 159.62,116.5 159.62,113.28 159.47,113.13 159.47,112.81 159.28,112.62 159.17,112.51 159.17,111.72 159.17,111.29 158.96,111.09 157.99,110.11 157.99,108 156.37,106.38 156.37,105.58 154.87,104.08 154.87,97.44 154.96,97.35 154.96,96.96 158.67,93.25 158.67,92.19 159.49,91.37 160.55,91.37 163.57,88.35 163.57,86.66 163.35,86.44 163.35,85.84 163.81,85.38 163.81,84.23 164.66,83.37 164.66,81.61 174.27,72 174.27,71.71 177.02,68.96 177.85,68.96 178.46,68.36 178.46,68.36 178.67,68.15 181.84,68.15 182.88,69.18 187.21,69.18 189.39,67.01 208.57,67.01 209.66,68.1 217.98,68.1 222.22,63.86 222.22,50.03 222.22,50.03 222.22,49.88 222.22,49.58 220.98,48.35 220.98,48.34 220.67,48.03 219.85,48.03 219.35,47.53 219.35,42.81 217.37,40.83 215.47,40.83 213.28,38.64 213.28,38.64 213.04,38.4 208.43,38.4 v1(208.14,38.11)
PQ4405_3: length 4
  TOP w0.102: PR4476.1 144.18,146.26 143.95,146.03 143.95,145.58 v2(143.96,145.58) 143.96,145.58 144.37,145.17 144.88,145.17 145.25,144.82 PQ4405.3
PQ4405_5: length 4.9
  TOP w0.102: PC4438.1 149.02,145.47 PQ4405.5 147.96,145.47 147.28,144.79 147.28,144.57 146.64,143.92 PR4474.2 146.08,143.82 145.9,143.99 v2(145.58,143.99)
PQ4405_6: length 2.9
  TOP w0.102: PQ4405.6 149.29,146.12 PC4438.2 149.38,146.03 PR4450.1 150.75,146.66 v2(150.75,146.81)
PQ4408_C: length 135.1
  TOP w0.089: PQ4408.C 151.08,103.13 v1(151.97,103.13) 152.25,102.85 v2(152.25,102.57) ; PR4475.1 208.06,45.84 208.23,45.68 208.23,41.99 207.95,41.71 207.9,41.71 207.9,41.71 207.59,41.71 207.26,41.38 207.26,39.11 207.4,38.97 207.73,38.97 PR4462.2 207.82,38.52 207.47,38.17 v1(207.47,37.45)
  L4 w0.089: v1(151.97,103.13) 152.64,102.46 152.64,102.44 153.97,101.11 153.97,96.77 157.51,93.23 157.51,92.28 159.44,90.35 160.11,90.35 162.77,87.69 162.77,86.99 162.32,86.53 162.32,82.91 162.37,82.86 162.37,81.1 173.63,69.84 174.3,69.84 176.91,67.24 178.59,67.24 184,61.82 187.57,61.82 189.62,63.87 200.48,63.87 201.33,63.01 208.99,63.01 209.39,63.41 216.99,63.41 218.33,62.07 218.33,49.52 217.62,48.81 217.62,45.51 214.08,41.97 212.29,41.97 210.93,40.61 210.93,39.99 209.5,38.56 209.19,38.56 208.08,37.45 v1(207.47,37.45)
PQ4408_E: length 9.6
  TOP w0.102: PQ4408.E v2(149.98,106.45) 149.98,107.1 150.65,107.77 PR4436.1 154.08,107.77 154.21,107.65 155.68,107.65 156.11,108.08 156.11,108.88 156.31,109.08 PR4473.2
PQ4417_D: length 3.2
  TOP w0.102: PR4431.2 13.5,127.91 12.49,127.91 12.32,127.74 PR4498.2 11.67,127.47 PQ4417.D
PQ4417_G: length 1.5
  TOP w0.102: PQ4417.G 13.14,129.09 PR4430.1
PQ4418_2: length 3.7
  TOP w0.102: PR4498.1 13.18,126.84 PR4499.1 12.77,126.43 12.77,125.72 12.6,125.55 11.83,125.55 11.66,125.73 PQ4418.2
PQ4418_3: length 3
  TOP w0.102: PQ4418.3 11.01,125.79 11.48,125.32 13.24,125.32 PR4433.1
PQ4418_5: length 3
  TOP w0.102: PQ4418.5 11.66,124.22 11.2,123.77 10.89,123.77 10.61,123.49 PC4449.1 9.86,123.01 PR4497.2
PQ4418_6: length 2.5
  TOP w0.102: PQ4418.6 12.31,124.19 11.97,123.85 11.97,123.24 PR4432.1 PC4449.2
PRIM_PWRGD: length 1.2
  TOP w0.102: R4030.1 22.61,60.89 U2401.30
PROCHOT: length 36.9
  TOP w0.102: U2401.83 39.66,67.29 40.49,68.12 40.49,68.3 40.74,68.56 42.75,68.56 R2417.1 43.74,68.28 44.89,68.28 45.12,68.51 46.26,68.51 46.51,68.75 46.51,69.6 47.81,70.89 47.81,72.95 47.7,73.05 47.7,73.08 v1(47.69,73.1) ; v1(51.5,90.59) 51.29,90.81 50.3,90.81 v2(50.14,90.96) 49.54,91.57 Q2408.G
  L3 w0.102: v1(51.5,90.59) 51.98,90.59 52.63,89.95 52.63,81.31 50.23,78.91 50.23,77.39 48.83,76 48.83,74.94 47.99,74.09 47.8,74.09 47.55,73.84 47.55,73.32 47.69,73.18 v1(47.69,73.1)
PROCHOT#_CPU: length 544.4
  TOP w0.089: v1(23.19,97.97) 23.49,97.97 23.91,98.39 v2(26.56,98.39) 26.63,98.46 39.09,98.46 40.56,96.98 47.42,96.98 48.03,96.37 48.03,95.46 49.78,93.7 Q2408.D 50.19,91.59 50.76,91.03 51.81,91.03 51.89,91.11 v1(51.9,91.11) ; v1(136.4,146.38) 137.19,146.38 138.01,145.56 PR4603.2 138.53,145.56 138.68,145.71 ED2403.2 139.9,145.64 141.4,145.64 142.24,146.48 PR4476.2 ; PR4433.2 13.31,123.88 v1(13.13,123.7)
  L3 w0.089: v1(21.14,62.36) 21.14,62.36 21.14,62.39 23.73,64.98 23.73,66.48 26.83,69.58 26.97,69.58 28.53,71.15 29.89,71.15 v1(30.39,71.65) ; v1(65.69,100.31) 61.57,96.19 61.57,93.85 60.68,92.97 59.03,92.97 57.18,94.82 54.28,94.82 51.95,92.48 51.95,91.16 51.9,91.11 v1(51.9,91.11) 51.9,90.96 52.82,90.03 52.82,81.23 50.42,78.83 50.42,77.31 49.03,75.92 49.03,74.85 47.98,73.81 v1(47.98,73.66) ; v1(209.49,43.97) 209.49,43.93 209.48,43.93 209.48,43.31 209.73,43.06 210.09,43.06 210.34,43.31 210.34,43.33 210.93,43.93 210.93,45.77 219.33,54.17 219.33,61.54 217.35,63.51 209.24,63.51 208.93,63.2 205.46,63.2 204.16,64.5 190.68,64.5 187.88,61.7 184,61.7 181,64.7 176.93,64.7 174.15,67.48 v1(174.15,68.07) ; v1(23.19,97.97) 22.34,97.97 18.59,101.73 16.82,101.73 14.51,104.04 14.51,108.43 13.97,108.97 13.97,119.4 11.69,121.68 11.69,122.58 12.35,123.25 12.63,123.25 13.08,123.7 v1(13.13,123.7)
  L4 w0.089: v1(128.6,129.41) 128.64,129.46 128.64,129.94 129.16,130.46 129.9,130.46 130.2,130.15 130.2,128.73 129.59,128.11 119.59,128.11 118.23,126.76 112.74,126.76 111.89,125.91 110.51,125.91 108.91,124.3 105.41,124.3 104.84,124.87 72.32,124.87 70.95,123.5 60.13,123.5 59.92,123.71 56.29,123.71 56.01,123.71 55.3,122.99 55.3,119.97 56.51,118.76 56.51,117.54 57.07,116.98 57.07,114.37 56.01,113.32 56.01,111.13 56.01,111.12 56.01,102.94 v1(54.79,101.72)
  BOTTOM w0.089: v1(54.79,101.72) 55.11,102.04 55.97,102.04 56.42,102.49 57.63,102.49 R302.1 58.84,101.28 61.13,101.28 62.06,100.36 64.29,100.36 R301.2 65.08,99.7 v1(65.69,100.31) ; v1(30.39,71.65) 30.89,72.15 31.35,72.15 31.83,71.66 35.32,71.66 35.39,71.72 45.39,71.72 47.32,73.66 v1(47.98,73.66) ; v1(128.6,129.41) 128.6,129.47 128.56,129.51 128.56,130.73 126.43,132.86 126.43,132.91 126.42,132.92 126.42,134.71 125.12,136.01 125.12,136.74 125.38,137 125.38,137.99 125.57,138.18 125.57,142.48 126.56,143.48 126.56,143.5 127.3,144.24 127.54,144.24 130.32,147.02 135.99,147.02 136.4,146.61 v1(136.4,146.38) PR4607.1 ; PQ4416.3 208.43,46.71 208.81,46.33 209.29,46.33 209.81,45.81 209.81,45.06 209.8,45.05 209.8,44.27 v1(209.49,43.97) ; v1(174.15,68.07) 173.95,67.87 169.91,67.87 168.03,65.99 168.03,64.78 165.72,62.47 165.72,61.69 161.32,57.29 156.5,57.29 155.77,56.56 148.75,56.56 148.42,56.89 146.44,56.89 145.88,57.45 110.31,57.45 108.89,56.04 57.74,56.04 55.78,54.09 43.07,54.09 42.73,53.75 37.71,53.75 36.88,52.92 27.5,52.92 27,53.42 27,55.47 26.74,55.74 26.73,55.74 26.22,56.25 26.22,61.57 25.41,62.37 24.93,62.37 24.8,62.24 23.83,62.24 23.24,61.65 22.25,61.65 21.54,62.36 v1(21.14,62.36)
PROCHOT#_CPU_R: length 39.9
  BOTTOM w0.102: R302.2 58.22,105.37 59.27,106.41 v2(61.37,106.41) 62.78,106.41 64.66,104.53 66.28,104.53 66.65,104.91 69.68,104.91 74.12,109.35 87.02,109.35 89,107.37 89,105.26 CPU1.Y4
PROJECT_ID0: length 3.3
  TOP w0.102: R2113.2 120.64,90.37 R2114.1 119.79,91.13 119.05,91.88 v1(118.93,91.88)
  BOTTOM w0.102: CPU1.CH23 v1(118.93,91.88)
PROJECT_ID1: length 13.7
  L3 w0.102: v1(131.04,93.42) 130.17,94.3 123.87,94.3 123.29,94.87 120.35,94.87 v1(120.2,95.02)
  BOTTOM w0.102: v1(120.2,95.02) 120.16,95.15 120.05,95.21 CPU1.CK19 ; v1(131.04,93.42) 131.45,93.02 R2112.1 131.32,92.58 R2111.2
PROJECT_ID2: length 9.9
  TOP w0.102: R2118.1 125.33,97.66 R2117.2 123.45,97.54 121.44,95.53 118.64,95.53 118.15,96.02 v1(118.15,96.04)
  BOTTOM w0.102: CPU1.CG17 v1(118.15,96.04)
PROJECT_ID3: length 8.5
  BOTTOM w0.076: 123.72,93.98 123.59,94.11 123.59,94.2 123.36,94.43 123.02,94.43 122.82,94.23 122.36,94.23 122.29,94.29 121.76,94.29 CPU1.CN20
  BOTTOM w0.102: R2115.2 128.25,92.59 R2116.1 127.38,92.7 127.38,93.37 v2(127.18,93.57) 127.18,93.6 127.05,93.73 123.98,93.73 123.72,93.98
PS_ID: length 83.9
  TOP w0.203: 20.32,59.87 20.45,59.74 24.52,59.74 24.67,59.89 25.84,59.89 26.35,59.37 U2401.36
  TOP w0.254: R4305.2 25.05,94.62 R4304.2 25.1,93.6 v1(25.05,93.55) 25.05,93.45 24.18,92.58 D4302.3 24.18,91.7 v2(23.83,91.35) ; v1(14.07,65.86) 15.32,64.62 15.32,62.69 15.98,62.03 16.89,62.03 17.13,61.79 17.13,61.63 17.63,61.13 18.24,61.13 18.32,61.22 19.89,61.22 20.11,61 20.11,60.08 20.32,59.87
  L3 w0.254: v1(14.07,65.86) 14.07,65.96 15.17,67.05 15.17,68.48 15.84,69.15 15.84,69.51 15.9,69.57 15.9,69.6 16.55,70.25 16.72,70.25 17.42,70.95 17.42,72.24 17.63,72.46 17.63,72.8 19.24,74.4 19.24,75.12 21.92,77.8 27.58,77.8 27.7,77.67 27.7,77.67 28.48,76.89 29.69,76.89 30.07,76.51 31.06,76.51 31.12,76.57 35.5,76.57 35.82,76.89 37.63,76.89 37.91,77.14 38.31,77.54 38.31,77.96 38.23,78.04 38.23,79.74 39.04,80.55 39.04,90.83 37.31,92.56 26.44,92.56 25.45,93.55 v1(25.05,93.55)
PS_ID_R: length 45.7
  TOP w0.102: AFTP4304.1 18.85,124.78 18.49,124.42 ED4303.1 19.23,124.09 EC4311.1 19.3,123.49 v1(19.18,123.37) ; v1(26.55,96.32) 26.3,96.32 R4309.1 25.44,97.17 Q4301.D
  L4 w0.102: v1(26.55,96.32) 26.06,96.32 20.58,101.8 20.58,104.93 19.31,106.2 18.56,106.2 16.89,107.86 16.89,110.97 18.35,112.43 18.35,112.72 17.4,113.67 17.4,116.87 19.13,118.59 21.09,118.59 21.95,119.46 21.95,122.91 21.49,123.37 v1(19.18,123.37)
  BOTTOM w0.102: v1(19.18,123.37) 19.48,123.37 20.2,124.08 DCIN1.4
PS_ID_R1: length 3.3
  TOP w0.102: R4305.1 24.86,95.48 v2(24.9,95.52) 24.9,95.94 24.06,96.78 Q4301.S
PSID_DISABLE#_R_C: length 4.4
  TOP w0.102: R4303.2 19.02,98.69 Q4302.C 22.07,98.69 v2(22.18,98.8) 22.3,98.68 Q4301.G
PTP_DIS#: length 173.2
  TOP w0.089: AFTP6526.1 v1(105.01,34.6) ; v1(37.84,70.37) 38.12,70.09 U2401.90
  L3 w0.089: v1(105.01,34.6) 104.66,34.94 104.15,34.94 102.18,32.97 92.69,32.97 92.01,32.29 90.87,32.29 89.78,31.21 77.89,31.21 74.42,27.73 56.51,27.73 56,27.22 40.2,27.22 37.9,24.92 23.7,24.92 17.95,30.67 17.95,40.27 17.44,40.78 17.44,42.74 16.61,43.58 16.61,51.87 17.21,52.47 17.21,57.31 16.42,58.09 16.2,58.09 15.67,58.63 15.67,60.26 15.36,60.57 15.36,61.52 15.42,61.57 16.57,62.73 16.57,64.63 16.66,64.71 16.66,64.79 16.97,65.1 16.97,66.24 17.4,66.67 17.82,66.67 18.07,66.92 18.07,67.57 18.07,67.58 18.07,69.19 18.62,69.74 19.19,69.74 21.06,71.61 21.06,71.96 21.06,71.97 21.06,72.9 21.82,73.67 22.62,73.67 23.34,74.39 23.34,74.74 23,75.09 21.33,75.09 v1(20.72,74.48)
  BOTTOM w0.089: v1(37.84,70.37) 37.84,70.38 36.85,71.37 35.54,71.37 35.46,71.3 31.98,71.3 31.9,71.22 30.05,71.22 29.98,71.3 27.82,71.3 27.53,71.59 27.53,73.06 26.8,73.79 25.51,73.79 24.95,73.24 22.69,73.24 22.42,73.51 21.51,73.51 20.72,74.3 v1(20.72,74.48) ; v1(105.01,34.6) 105.24,34.82 108.13,34.82 108.2,34.89 TP1.3
PU4348_G: length 10.5
  TOP w0.254: R4369.1 30.41,122.05 v1(29.87,122.05) ; v1(31.27,127.05) 31.52,126.8 Q4348.G 32.35,126.88 R4370.2 31.52,127.71 R4469.2
  L3 w0.254: v1(29.87,122.05) 29.11,122.81 29.11,124.86 30.19,125.93 30.2,125.93 30.87,126.6 30.87,126.62 30.99,126.74 30.99,126.77 v1(31.27,127.05)
PULSAR_38P4M_REFCLK: length 109.5
  L4 w0.127: v1(56.9,101.65) 57.33,102.09 57.33,109.13 57.56,109.36 57.56,110.82 66.89,120.14 72.32,120.14 73.17,120.99 115.39,120.99 116.38,119.99 118.05,119.99 118.3,120.24 118.3,121.21 119.37,122.28 121.39,122.28 122.79,123.69 125.15,123.69 125.97,122.86 125.97,122.17 127.84,120.3 134.34,120.3 134.44,120.19 v1(134.5,120.19)
  BOTTOM w0.14: v1(134.5,120.19) 134.93,120.19 R1804.2 ; v1(56.9,101.65) 55.98,100.74 53.72,100.74 51.38,103.08 51.26,103.37 51.18,103.49 51.18,103.51 50.97,103.73 50.77,103.86 50.55,103.95 50.32,104 50.08,104 49.85,103.95 49.63,103.86 49.43,103.73 49.01,103.3 47.6,103.3 46.7,104.21 WLAN1.64
PURE_HW_SHUTDOWN#: length 5.9
  BOTTOM w0.14: C2610.1 141.13,116.91 R4014.2 ; C2610.1 141.14,116.84 140.71,116.4 140.67,116.4 140.12,115.85 v2(139.93,115.85) ; C2610.1 141.4,116.64 R2615.1 141.56,115.98 142.27,115.98 D4001.K Q2602.D
PWR_1D05V_BST: length 3.5
  BOTTOM w0.305: v2(113.73,138.4) 114.23,138.4 PC5204.1 115.06,138.77 115.77,139.48 116.19,139.48 116.23,139.53 PU5201.20
PWR_1D05V_EN: length 4.4
  BOTTOM w0.254: PR5210.2 117.1,144.4 v2(117.38,144.12) 117.38,143.92 PC5215.1 116.67,142.98 117.12,142.65 117.35,142.65 117.7,142.3 117.7,142.27 117.9,142.08 PU5201.2
PWR_1D05V_FB: length 4.4
  BOTTOM w0.305: PU5201.5 119.4,142.14 119.61,142.35 119.61,142.8 v2(119.21,143.21) 119.81,143.82 PC5212.2 119.79,144.07 PR5202.2 118.32,144.07 PR5204.1
PWR_1D05V_FB_A: length 21.6
  L3 w0.381: v1(113.13,136.83) 113.13,139.71 113.85,140.42 v1(113.85,142.42)
  BOTTOM w0.305: v1(113.13,136.83) 113.76,136.21 v2(113.78,136.21) 113.78,130.76 113.62,130.6 PG5223.1 ; PC5212.1 119.79,144.93 PR5202.1 118.77,145.21 114.27,145.21 113.85,144.79 v1(113.85,142.42)
PWR_1D05V_PFM#: length 2.6
  TOP w0.254: v2(118.15,144.08) 118.39,143.84 PR5203.1 118.39,142.88 118.24,142.73 v1(118.24,142.45)
  BOTTOM w0.254: v1(118.24,142.45) 118.36,142.33 118.36,141.89 118.4,141.86 PU5201.3
PWR_1D05V_PH:
  vias: v2(115.56,138.3)
PWR_1D05V_SS: length 3.5
  TOP w0.254: v2(116.31,144.07) 116.31,144.02 116.77,143.56 PC5213.1 116.77,142.8 117.07,142.5 117.07,141.77 v1(116.86,141.56)
  BOTTOM w0.254: PU5201.22 116.72,141.36 116.86,141.5 v1(116.86,141.56)
PWR_1D05V_TON: length 2.2
  BOTTOM w0.102: v2(120.6,143.59) 120.5,143.49 PR5201.2 119.9,142.09 PU5201.6
PWR_1D8V: length 1.4
  BOTTOM w0.508: v3(69.17,39.12) 68.28,40.01 PC5306.1
  vias: v2(68.21,39.46) v2(81.75,29.62) v2(93.01,38.5) v3(91.64,38.74)
PWR_1D8V_EN: length 10.7
  TOP w0.102: v1(97.07,32.21) 97.06,32.22 97.06,32.79 PC5303.1 96.83,36.27 v2(97.8,37.24) 97.8,38.37 97.77,38.39 PR5308.2
  BOTTOM w0.102: v1(97.07,32.21) 97.07,32.3 97.29,32.51 97.29,34.37 97.8,34.88 PU5301.8
PWR_1D8V_FB: length 7.6
  TOP w0.305: 91.11,35.92 91.11,36.69 PC5304.2 90.92,36.87 PR5304.2 ; 91.11,35.92 91,36.03 v2(89.81,36.03) 89.56,35.78 89.56,35.48 v1(89.56,35.41) ; 91.11,35.92 PR5305.1
  BOTTOM w0.381: PU5301.2 90.18,36.15 89.56,35.53 v1(89.56,35.41)
PWR_1D8V_FB_A:
  vias: v2(90.96,38.78)
PWR_1D8V_PG: length 220.4
  TOP w0.102: v2(128.23,130.71) 128.19,130.76 v1(127.51,130.76)
  L3 w0.102: v1(115.9,143.59) 116.11,143.38 119.03,143.38 120.72,141.7 122.19,141.7 125.4,138.48 126.1,138.48 126.93,137.65 126.93,135.18 126.55,134.8 126.55,133.13 126.54,133.13 126.54,132.77 126.55,132.77 126.55,131.61 127.4,130.76 v1(127.51,130.76)
  L4 w0.089: 173.36,69.16 174.14,69.16 176.67,66.64 177.25,66.64 177.54,66.35 v1(177.54,65.74)
  L4 w0.102: 173.36,69.16 161.07,81.45 161.07,83.49 161.5,83.91 161.5,86.79 151.08,97.21 151.08,99.65 148.81,101.91 148.81,106.11 144.62,110.3 144.62,112.3 143.43,113.49 143.43,117.08 131.73,128.79 131.73,129.7 130.29,131.14 127.89,131.14 v1(127.51,130.76)
  BOTTOM w0.102: v1(177.54,65.74) 177.03,65.22 174.21,65.22 173.51,65.92 171.02,65.92 170.43,65.33 170.43,63.38 170.36,63.31 168.58,61.5 168.58,59.91 163.42,54.74 157.54,54.74 156.71,53.92 147.64,53.92 147.21,54.35 145.31,54.35 144.84,54.82 111.23,54.82 111.23,54.82 111.07,54.82 110.2,53.96 109.9,53.96 109.85,53.91 104.33,53.91 102.14,51.72 102.14,46.22 102.63,45.72 102.63,44.8 102.09,44.25 102.09,43.51 104.57,41.02 104.57,40.12 104.32,39.87 103.96,39.87 103.69,40.14 103.16,40.14 102.67,39.65 101.65,39.65 100.71,38.72 100.71,35.64 100.41,35.33 99.7,35.33 PR5301.2 98.78,36.15 PU5301.7 ; PR5210.1 115.67,143.82 v1(115.9,143.59)
PWR_1D8V_VIN:
  vias: v2(94.25,33.74)
PWR_2D5V:
  vias: v2(165.51,120.22)
PWR_2D5V_EN: length 5.2
  BOTTOM w0.254: v2(161.04,111.51) PU5101.8 162.13,109.95 161.61,109.43 161.61,108.76 161.7,108.76 PR5109.1 162.16,108.21 PR5117.1
PWR_2D5V_FB: length 4.2
  BOTTOM w0.254: PR5120.1 162.94,117.35 v2(162.94,118.16)
  BOTTOM w0.381: PU5101.2 163.4,116.36 163.02,116.74 PR5120.1 PC5111.2 PR5119.2
PWR_2D5V_PG: length 3.9
  BOTTOM w0.102: PR5112.2 163.4,109.29 PU5101.7 ; PR5112.2 162.55,109.08 v2(162.32,109.31) ; PR5112.2 163.18,109.01 PG5122.1
PWR_3D3V_BOOT: length 3
  BOTTOM w0.254: PU4501.1 66.13,135.17
  BOTTOM w0.508: 66.13,135.17 65.76,135.54 65.43,135.54 v2(65.42,135.53) 65.41,135.54 PR4501.1
PWR_3D3V_BOOT_A: length 3.5
  BOTTOM w0.508: v2(61.95,135.87) 62.68,135.87 PR4501.2 63.01,134.92 63.54,134.39 PC4506.1
PWR_3D3V_EN: length 4.6
  BOTTOM w0.102: v2(72.34,139.7) 71.96,139.7 PR4509.2 PR4508.1 71.45,137.72 PC4508.1 71.02,137.64 70.35,136.97 PU4501.11
PWR_3D3V_EN1: length 187.2
  TOP w0.102: v1(70.77,136.73) 70.77,136.87 70.1,137.54 v2(69.87,137.54) 69.75,137.42 PR4514.1
  L3 w0.089: v1(29.75,29.44) 29.36,29.83 28.4,29.83
  L3 w0.102: 28.4,29.83 24.49,29.83 22.27,32.06 22.27,37.23 22.99,37.95 22.99,37.97 23.57,38.56 23.57,39.35 22.99,39.93 22.99,40.98 21.62,42.35 21.62,43.39 19.64,45.37 19.64,49.29 20.48,50.12 20.48,51.07 20.48,52.07 20.66,52.25 20.66,52.27 20.7,52.31 20.7,55.81 20.55,55.96 20.55,57.32 20.28,57.59 20.28,59.61 20.17,59.72 20.17,60.58 20.16,60.59 20.16,60.74 20.14,60.76 20.14,61.44 20.16,61.46 20.16,63.73 20.18,63.74 21.79,65.36 21.79,66.26 22.2,66.66 22.2,68.06 22.45,68.31 22.71,68.31 25.52,71.12 26.2,71.12 27.16,72.08 27.16,72.47 28.24,73.55 37.26,73.55 40.95,77.23 40.95,91.68 42.24,92.97 43.53,92.97 44.64,91.86 v1(44.64,91.85) ; v1(42.55,117.68) 43.95,119.08 43.95,119.79 45.6,121.44 45.6,123.55 49.06,127.01 53.64,127.01 55.55,125.1 58.97,125.1 59.55,125.68 59.55,129.8 59.9,130.15 59.9,132.52 64.97,137.59 69.57,137.59 70.43,136.73 v1(70.77,136.73)
  L4 w0.102: v1(31.89,40.37) 31.89,40.85 32.62,41.58 33.23,41.58 35.12,39.68 35.12,38.99 35.2,38.92 35.2,38.56 35.11,38.47 35.11,38.2 34.22,37.3 34.22,36.58 33.35,35.71 33.35,33.62 30.64,30.91 30.64,29.73 30.35,29.44 v1(29.75,29.44) ; v1(42.55,117.68) 42.73,117.5 45.35,117.5 46.36,116.5 46.36,112.19 45.15,110.98 45.15,107.32 44.63,106.8 44.63,102.6 43.54,101.51 43.54,97.28 44.23,96.59 44.23,96.57 44.24,96.56 44.24,92.88 44.64,92.48 v1(44.64,91.85)
  BOTTOM w0.102: PC4532.1 70.9,136.86 v1(70.77,136.73) 70.56,136.52 PU4501.12 ; v1(31.89,40.37) 31.71,40.54 PR4516.2
PWR_3D3V_FB: length 2
  BOTTOM w0.203: v2(70.85,136.01) 70.84,136.03 70.7,136.03 70.66,136.07 PU4501.13
  BOTTOM w0.381: PC4533.1 71.43,136.01 v2(70.85,136.01)
PWR_3D3V_FB2:
  vias: v2(73.26,136.32)
PWR_3D3V_LDO:
  vias: v2(71.7,134.09)
PWR_3D3V_PH: length 5.7
  TOP w0.305: v2(67.67,134.42) v1(67.05,134.42)
  L4 w0.508: v1(67.05,134.42) 67.55,134.92 v1(67.55,138.35)
  BOTTOM w0.254: v1(67.55,138.35) 67.55,138.32 67.56,138.32 PU4501.6
PWR_3D3V_VOUT: length 17.4
  L3 w0.508: v1(70.79,135.18) 71.1,134.88 v1(71.1,132.01)
  BOTTOM w0.254: v1(70.79,135.18) 70.35,135.62 PU4501.14
  BOTTOM w0.508: PR4506.1 71.65,135.04 70.93,135.04 v1(70.79,135.18) ; PG4530.1 69.62,121.38 70.56,122.32 70.56,125.63 71.7,126.77 v2(71.7,130.06) 71.7,131.4 v1(71.1,132.01)
PWR_5V_BOOT: length 2.2
  TOP w0.305: v2(43.13,34.3) 42.96,34.3 v1(42.64,34.62)
  TOP w0.508: PR4502.1 42.3,34.96 v1(42.64,34.62)
  BOTTOM w0.254: PU4502.1 42.49,34.77 v1(42.64,34.62)
PWR_5V_BOOT_A: length 2
  TOP w0.305: PC4521.1 39.51,34.58 38.8,34.58 v2(38.68,34.46)
  TOP w0.508: PR4502.2 40.29,34.96 39.98,34.65 PC4521.1
PWR_5V_EN: length 6.1
  BOTTOM w0.102: PU4502.11 39.85,37.37 39.61,37.61 39.25,37.61 39.24,37.62 38.86,37.62 PR4512.1 37.58,38.8 36.41,38.8 PC4530.1 36.21,39 PR4511.2 v2(36.21,40.42)
PWR_5V_EN1: length 8.2
  BOTTOM w0.254: PU4502.12 40.73,37.81 40.67,37.88 40.67,37.93 40.52,38.08 v2(38.92,38.08) 38.92,38.3 38.53,38.69 38.53,38.69 38.39,38.84 38.38,38.84 38.03,39.19 PC4531.1 37.25,39.27 PR4513.1 37.01,39.24 36.69,39.56 36.69,39.88 36.69,39.88 36.69,40.62 36.3,41.01 PR4504.2
PWR_5V_FB: length 4.2
  TOP w0.203: v2(40.85,37.75) 40.85,38.23 v1(40.97,38.35)
  BOTTOM w0.254: PU4502.13 41.18,38.12 40.97,38.34 v1(40.97,38.35) 40.96,38.35 40.84,38.46 39.88,38.46 PC4526.1
  BOTTOM w0.381: PC4526.1 39.37,38.96 39.09,38.96 PR4551.1
PWR_5V_FB_A: length 0.9
  BOTTOM w0.381: PR4507.1 40.21,39.63 PC4526.2
PWR_5V_LDO: length 5.6
  BOTTOM w0.102: PG4528.1 39.79,40.95 40.01,40.73 v2(40.01,40.69) 40.05,40.69 40.4,40.34 40.72,40.34 41.16,39.89 41.16,39.75 PC4520.1
  BOTTOM w0.254: PU4502.15 42.08,37.94 42.17,38.03 42.17,38.64 41.4,39.41 PC4520.1
PWR_5V_PH: length 7
  TOP w0.305: v1(43.61,35.31) v2(44.18,35.31)
  TOP w0.508: v1(38.96,35.13) 39.39,35.56 PC4521.2
  L4 w0.508: v1(38.96,35.13) 39.13,35.31 v1(43.61,35.31)
  BOTTOM w0.254: PU4502.6 39.03,35.17 38.99,35.13 v1(38.96,35.13)
PWR_5V_VOUT: length 32.9
  TOP w0.254: v1(41.61,38.41) 42.04,37.97 v2(42.22,37.97)
  L4 w0.254: v1(56.57,41.59) 56.57,41.38 56.01,40.82 52.45,40.82 51.57,41.7 37.04,41.7 36.83,41.49 36.83,40.82 37.13,40.52 37.13,39.82 37.21,39.75 37.21,39.18 38.22,38.17 38.37,38.17 38.49,38.05 40.49,38.05 40.72,37.82 41.35,37.82 41.61,38.08 v1(41.61,38.41)
  BOTTOM w0.254: v1(56.57,41.59) 56.57,41.21 PG4527.1 ; PU4502.14 41.63,38.38 v1(41.61,38.41) 41.61,38.48 41.21,38.88 40.5,38.88 PR4507.2
PWR_BD_DET#: length 126.1
  TOP w0.089: AFTP6408.1 212.54,60.75 v1(212.54,60.15) 212.38,60 211.71,60 210.97,60.74 R2061.2 210.92,60.34 211.21,60.04 211.21,59.08 211.58,58.7 211.58,58.69 211.83,58.44 211.84,58.44 212.3,57.99 212.3,57.61 211.97,57.28 211.03,57.28 210.85,57.1 208.12,57.1 207.86,57.35 207.14,57.35 206.45,56.67 204.6,56.67 204.04,57.23 200.36,57.23 v1(199.88,57.71)
  L3 w0.089: v1(126.9,97.74) 128.1,98.93 128.1,100.35 128.95,101.2 133.45,101.2 138.14,96.5 138.9,96.5 146.05,89.36 146.05,88.69 152.46,82.27 152.46,80.17 160.59,72.04 160.59,71.45 164.37,67.68 164.37,67.66 164.4,67.62 164.4,67.09 164.4,67.08 164.4,66.73 173.01,58.12 176.26,58.12 177.5,56.88 178.6,56.88 180.31,56.88 180.42,56.77 180.82,56.37 190.52,56.37 192.32,58.17 199.42,58.17 v1(199.88,57.71)
  BOTTOM w0.089: v1(212.54,60.15) 213.03,59.66 213.03,58.29 213.64,57.68 213.64,57.39 213.95,57.07 PWR1.6 ; CPU1.CR14 122.72,98.32 123.61,98.32 123.93,98.65 124.61,98.65 124.63,98.63 124.65,98.63 125.11,98.18 126.21,98.18 126.65,97.74 v1(126.9,97.74)
PWR_CHG_ACIN: length 4.1
  TOP w0.254: v1(206.02,49.8) 205.67,49.8 205.04,50.42 ; 205.04,50.42 PR4484.2 v2(206.38,51.53) ; 205.04,50.42 PR4485.1
  BOTTOM w0.203: PU4401.19 205.82,49.64 205.98,49.8 v1(206.02,49.8)
PWR_CHG_ACOK: length 420.7
  TOP w0.102: v1(13.79,123.67) 13.79,126.58 PR4499.2 ; v1(25,102.17) 29.15,102.17 v2(30.36,100.97) 30.71,100.62 39.79,100.62 40.2,100.2 45.38,100.2 46.61,98.97 50.05,98.97 52.02,97 52.02,93.06 52.02,93.05 52.02,91.95 52.36,91.62 52.36,85.45 51.46,84.56 v1(51.27,84.56) ; v1(206.37,47.5) 206.64,47.5 207.06,47.08 207.06,46.82 PR4463.2 207.43,47.05 PR4426.1 207.93,48.15 208.04,48.15 208.4,48.51 PR4429.2
  L3 w0.102: v1(25,102.17) 24.62,102.55 23.66,102.55 23.32,102.21 23.32,101.55 22.48,100.71 19.96,100.71 18.69,101.98 16.84,101.98 14.79,104.04 14.79,108.57 14.18,109.18 14.18,119.48 11.99,121.67 11.99,122.56 12.45,123.01 12.7,123.01 12.93,123.24 13.36,123.24 v1(13.79,123.67)
  L4 w0.102: v1(12.51,43) 12.31,42.8 12.31,41.48 13.89,39.9 14.52,39.9 15.3,39.12 15.3,35.56 15.41,35.44 15.41,31.8 21.8,25.42 28.18,25.42 28.72,25.95 32.43,25.95 36.08,29.6 41.91,29.6 42.72,30.42 53.06,30.42 53.6,30.96 73.99,30.96 76.73,33.71 100.5,33.71 101.51,32.7 104.62,32.7 111.83,39.92 111.83,40.81 112.76,41.74 119.6,41.74 120.13,41.21 120.13,40.59 121.38,39.34 122.11,39.34 124.54,36.92 127.45,36.92 129.09,35.28 129.98,35.28 131.41,33.85 133.57,33.85 134.57,32.84 144.08,32.84 145.2,31.73 170.08,31.73 170.72,32.36 172.31,32.36 172.75,31.93 172.75,31.92 173.15,31.52 181.97,31.52 183.03,32.59 186.28,32.59 188.95,35.26 188.95,36 189.94,36.98 190.48,36.98 190.69,37.19 190.69,37.22 190.77,37.3 190.77,37.33 190.79,37.35 190.79,38.71 191.9,39.82 191.9,40.12 192.32,40.54 193.07,40.54 193.08,40.55 193.69,40.55 197.7,40.55 198.2,41.05 199.68,41.05 201.35,42.71 201.35,43.07 202.05,43.77 204.74,43.77 205.82,44.84 205.82,46.95 v1(206.37,47.5)
  BOTTOM w0.102: PG4408.1 205.81,46.88 206.37,47.44 v1(206.37,47.5) 206.24,47.64 PU4401.24 ; v1(12.51,43) 12.46,43.05 12.43,43.05 12.42,43.06 10.11,43.06 9.39,43.78 9.39,44.87 9.81,45.29 9.81,46.61 10.16,46.96 10.88,46.96 11.11,47.19 11.51,47.54 11.61,47.65 11.73,47.76 13.36,47.76 14.23,48.63 14.23,50.01 13.63,50.62 13.63,51.1 14.41,51.89 16.49,51.89 16.7,52.1 17.4,52.1 17.52,51.98 20.07,51.98 21.2,53.11 21.2,53.75 23.44,56 23.95,56 23.99,55.96 24.56,55.96 25,56.39 25,57.75 24.1,58.65 23.52,58.65 22.69,59.49 20.49,59.49 19.67,58.67 18.83,58.67 18.71,58.78 18.71,58.78 18.62,58.88 18.05,58.88 18.04,58.88 18.01,58.88 17.27,59.62 17.27,60.25 17.06,60.46 16.94,60.46 16.81,60.58 15.61,60.58 13.98,62.21 13.98,62.46 10.87,65.56 10.87,66.52 11.48,67.13 12.46,67.13 13.46,68.12 13.92,68.12 15.6,69.8 15.6,71.26 16.96,72.62 17.98,72.62 20.49,75.13 20.95,75.13 20.97,75.1 20.98,75.1 21.36,74.73 21.36,74.19 21.66,73.89 22.58,73.89 22.81,73.66 24.74,73.66 25.62,74.53 26.17,74.53 26.47,74.84 26.47,75.14 26.72,75.4 27.44,75.4 27.74,75.7 38.39,75.7 40.69,78 41.86,78 42.02,77.85 43.64,77.85 44.34,77.15 48.97,77.15 49.37,77.55 50.53,77.55 52.15,79.17 52.15,83.68 v1(51.27,84.56)
PWR_CHG_ADP/ACIN: length 4.7
  TOP w0.254: v1(204.85,52.12) 204.66,52.32 PR4437.1 205.24,53.98 v2(205.24,54.2) 205.06,54.38 PR4434.1
  BOTTOM w0.203: PU4401.16 204.64,51.2 204.85,51.41 v1(204.85,52.12)
PWR_CHG_AIN: length 24.4
  TOP w0.254: v1(195.38,43.06) 195.38,42.7 v2(195.15,42.47) ; v1(206.91,53.47) 206.91,53.41 206.39,52.88 PR4404.1
  L3 w0.254: v1(195.38,43.06) 198.24,45.92 200.65,45.92 201.85,47.13 203.66,47.13 203.69,47.14 204.54,47.14 205.62,48.22 205.62,48.9 205.93,49.21 206.82,49.21 207.11,49.5 207.11,53.26 v1(206.91,53.47)
  BOTTOM w0.254: PR4465.2 193.53,43.64 193.53,42.74 193.81,42.46 PD4408.3 194.78,42.46 v1(195.38,43.06)
PWR_CHG_AIN_R: length 5.6
  TOP w0.254: PR4406.1 203.84,51.54 PC4420.2 ; PR4437.2 203.79,52.9 204.04,52.66 v2(204.04,52.45) 203.92,52.33 PC4420.2 ; PC4420.2 204.22,51.62 PR4484.1 205.38,51.89 205.38,52.55 PR4404.2
PWR_CHG_AMON: length 3.3
  BOTTOM w0.203: PU4401.29 203.04,46.68 202.38,46.02 202.38,45.36 PR4412.2 202.75,44.98 202.92,44.98 203.05,44.85 203.05,44.85 203.22,44.68 v2(203.22,44.49)
PWR_CHG_ASGATE: length 1.2
  TOP w0.254: TP4401.1 201.31,53.96 PR4490.2
PWR_CHG_ASGATE22:
  vias: v2(198.1,52.43)
PWR_CHG_ASGATE/NTC: length 4.5
  TOP w0.254: PR4491.2 202.83,52.15 203.24,52.15 203.28,52.19 v1(203.32,52.19) 203.32,52.48 202.8,53 v2(202.8,53.04) 202.96,53.2 PR4490.1
  BOTTOM w0.203: v1(203.32,52.19) 203.32,52.11 203.44,51.99 PU4401.13
PWR_CHG_BATGONE: length 2.5
  TOP w0.254: v1(205.05,46.4) 205.73,46.4 PR4409.1 205.72,46.55 PC4430.1
  BOTTOM w0.254: v1(205.05,46.4) 205.05,46.84 204.8,47.08 PU4401.25
PWR_CHG_BGATE: length 31.4
  TOP w0.305: v1(177.55,34.47) 177.96,34.47 v2(178.21,34.22)
  TOP w0.356: PC4429.1 176.98,34.47 v1(177.55,34.47)
  L5SGND w0.381: v1(199.86,42.92) 199.02,42.92 197.01,44.93 191.19,44.93 189.12,42.86 184.88,42.86 178.39,36.37 178.39,35.31 v1(177.55,34.47)
  BOTTOM w0.508: v1(177.55,34.47) 177.29,34.73 PU4412.4 ; v1(199.86,42.92) 199.62,43.16 PR4443.1
PWR_CHG_BGATE/HG2: length 4.3
  BOTTOM w0.203: PU4401.32 201.55,46.79 201.47,46.79 201.2,46.52 200.75,46.52 PC4445.2
  BOTTOM w0.254: v2(198.53,45.01) 199.54,45.01 PR4443.2
  BOTTOM w0.508: PR4443.2 199.63,45.27 200.22,45.87 200.22,45.89 200.27,45.93 PC4445.2
PWR_CHG_BGATE_22: length 5.7
  BOTTOM w0.305: PR4464.1 194.1,45.8 193.56,45.25 193.36,45.25 v2(193.35,45.25) 192.35,45.25 PD4409.K 191.29,44.56 191.29,42.73 PR4495.1
PWR_CHG_BGATE_22_R: length 21.3
  TOP w0.305: v1(177.56,35.66) 177.56,35.32 v2(177.37,35.13)
  TOP w0.356: PC4443.2 177.6,35.69 v1(177.56,35.66)
  TOP w0.381: PC4443.2 176.99,36.68 PR4494.1
  L5SGND w0.254: v1(189.16,44.2) 188.65,43.69 184.48,43.69 177.56,36.77 v1(177.56,35.66)
  BOTTOM w0.406: PU4413.4 177.94,36.03 v1(177.56,35.66)
  BOTTOM w0.508: PR4495.2 190.53,43.75 190.12,44.14 190.05,44.2 v1(189.16,44.2)
PWR_CHG_BOOT1: length 5.5
  BOTTOM w0.203: PU4401.12 203.04,51.71 202.8,51.95 v2(202.8,52.5) 202.3,53 201.4,53 200.99,53.41
  BOTTOM w0.508: PR4402.2 200.99,54.65 200.99,53.41
PWR_CHG_BOOT2: length 3
  BOTTOM w0.203: 199.83,48.51 200.25,48.51 200.57,48.84 PU4401.4
  BOTTOM w0.508: PC4423.1 198.93,48.19 199.26,48.19 199.54,48.48 v2(199.69,48.48) 199.79,48.48 199.83,48.51
PWR_CHG_BT1_R: length 1.2
  BOTTOM w0.508: PR4402.1 PC4436.2
PWR_CHG_BT2_R: length 1.2
  BOTTOM w0.508: PR4444.2 197.34,48.46 PC4423.2
PWR_CHG_CMRSC: length 5.3
  TOP w0.254: PR4439.2 199.06,53.65 199.24,53.82 199.57,53.82 v2(199.62,53.77) 199.77,53.62 PC4442.1 199.77,51.45 200.33,50.9 200.33,49.83 PR4438.1
PWR_CHG_COMP: length 9.5
  TOP w0.254: v1(202.87,45.83) 202.87,45.82 202.92,45.77 202.92,45.58 202.21,44.86 201.27,44.86 200.69,45.44 v2(197.49,45.44) 197.28,45.44 PR4411.1 196.73,44.12 PC4433.1
  BOTTOM w0.203: PU4401.28 203.44,46.44 202.87,45.88 202.87,45.84 v1(202.87,45.83)
PWR_CHG_COMP_R: length 1.7
  TOP w0.254: PR4411.2 195.81,44.93 PC4431.1 194.62,45.42 v2(194.62,45.7)
PWR_CHG_CSIN: length 14.8
  TOP w0.254: v1(205.62,58.3) 205.16,58.3 204.43,59.03 ; PR4489.2 203.68,59.31 204.15,59.31 204.43,59.03 ; 204.43,59.03 v2(204.5,59.1)
  BOTTOM w0.203: 203.97,51.74 203.84,51.62 PU4401.14
  BOTTOM w0.254: v1(205.62,58.3) 205.62,57.97 205.03,57.38 202.91,57.38 202.39,56.86 202.39,56.12 202.49,56.02 202.91,55.6 202.95,55.6 203.27,55.28 203.27,53.82 PC4415.1 ; PC4415.1 201.93,53.75 PC4417.2 ; PC4415.1 203.97,52.99 203.97,51.74
PWR_CHG_CSIN_R: length 9.5
  TOP w0.254: v1(186.09,59.99) 186.37,59.71 192.76,59.71 ; PR4423.1 194.02,59.71 192.76,59.71 ; 192.76,59.71 v2(192.76,59.84)
  BOTTOM w0.254: v1(186.09,59.99) 186.09,59.01 PG4402.2
PWR_CHG_CSIN_RR: length 7.9
  TOP w0.254: 199.65,59.33 196.65,59.33 196.27,59.71 195.29,59.71 PR4423.2 ; 199.65,59.33 v2(199.65,59.41) ; 199.65,59.33 201.97,59.33 202.15,59.52 PR4489.1
PWR_CHG_CSIP: length 17.6
  TOP w0.254: v2(204.84,57.91) 204.92,58 ; 204.92,58 203.99,58.93 203.67,58.93 PR4488.2 ; 204.92,58 205.16,57.76 205.92,57.76 206.3,58.14 v1(206.3,58.35)
  BOTTOM w0.203: PU4401.15 204.24,51.48
  BOTTOM w0.254: PC4415.2 203.65,54.62 203.65,55.44 203.11,55.98 203.07,55.98 202.77,56.28 202.77,56.7 203.07,57 205.19,57 206.3,58.11 v1(206.3,58.35) ; PC4415.2 204.52,53.62 205.59,52.55 PC4416.2 ; PC4415.2 204.35,53.57 204.35,51.58 204.24,51.48
PWR_CHG_CSIP_R: length 10.5
  TOP w0.254: 191.24,59.33 185.96,59.33 185.38,59.91 v1(185.38,60.01) ; 191.24,59.33 194.02,59.33 PR4422.1 ; 191.24,59.33 v2(191.24,59.26)
  BOTTOM w0.254: PG4401.2 185.38,59.11 v1(185.38,60.01)
PWR_CHG_CSIP_RR: length 7.9
  TOP w0.254: v2(201.17,58.88) 201.17,58.95 ; 201.17,58.95 196.49,58.95 196.11,59.33 195.29,59.33 PR4422.2 ; 201.17,58.95 201.93,58.95 202.15,58.73 PR4488.1
PWR_CHG_CSON: length 12.4
  TOP w0.254: 193.87,44.13 193.17,44.83 PR4487.1 ; 193.87,44.13 v2(193.93,44.2) ; 193.87,44.13 194.71,43.29 v1(194.71,43.2)
  BOTTOM w0.203: PU4401.1 200.96,47.64 200.65,47.33 200.65,47.16 199.25,45.75 198.41,45.75 198.32,45.66
  BOTTOM w0.254: v1(194.71,43.2) 194.85,43.34 194.91,43.34 195.51,43.94 195.51,44.63 195.75,44.87 196.05,44.87 PC4426.2 196.48,44.97 197,44.97 PC4425.2 197.47,44.38 198.16,45.27 198.16,45.5 198.32,45.66
PWR_CHG_CSON_R: length 19.2
  TOP w0.254: v2(185.28,42.69) 185.35,42.63 ; 185.35,42.63 185.09,42.36 185.09,42.03 v1(185.02,41.96) ; 185.35,42.63 185.63,42.9 187.07,42.9 PR4425.1
  L3 w0.254: v1(172.04,41.61) 172.04,41.45 173.77,39.72 181.95,39.72 184.32,42.09 184.89,42.09 v1(185.02,41.96)
  BOTTOM w0.254: PG4406.2 171.26,40.84 v1(172.04,41.61)
PWR_CHG_CSON_RR: length 5.4
  TOP w0.254: PR4487.2 191.92,44.62 191.13,44.62 ; v2(191.13,44.71) 191.13,44.62 ; 191.13,44.62 190.71,44.62 190.23,45.1 188.77,45.1 188.19,44.52 188.19,44.03 187.92,43.76
PWR_CHG_CSOP: length 12.3
  TOP w0.254: PR4486.1 193.42,44.04 194.05,43.41 v1(194.05,43.22) 193.95,43.13 v2(193.32,43.13)
  BOTTOM w0.203: 198.05,45.93 198.07,45.95 198.14,45.95 198.18,45.99 198.22,45.99 198.28,46.06 199.12,46.06 200.35,47.28 200.35,47.46 200.93,48.04 PU4401.2
  BOTTOM w0.254: 198.05,45.93 197.77,45.65 197.64,45.65 PC4425.1 196.86,45.35 196.61,45.35 PC4424.2 196.09,45.75 195.13,44.79 195.13,44.1 194.76,43.73 194.5,43.73 194.05,43.28 v1(194.05,43.22)
PWR_CHG_CSOP_R: length 18.3
  TOP w0.254: 186.47,42.52 187.8,42.52 PR4424.1 ; 186.47,42.52 v2(186.47,42.39) ; 186.47,42.52 185.8,42.52 185.63,42.34 v1(185.63,42.17)
  L3 w0.254: v1(185.63,42.17) 185.63,42.19 185.35,42.47 184.16,42.47 181.79,40.1 173.93,40.1 172.7,41.33 v1(172.7,41.59)
  BOTTOM w0.254: PG4405.2 172.75,41.54 v1(172.7,41.59)
