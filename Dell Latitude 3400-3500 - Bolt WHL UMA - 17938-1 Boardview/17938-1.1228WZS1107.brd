# Allegro board 17938-1.1228WZS1107.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CPU_DP2_CTRL_CLK: length 23.8
  L4 w0.127: v1(121.87,110.97) 122.53,110.97 123.2,111.64 132.61,111.64 132.84,111.4 133.89,111.4 133.97,111.32 v1(134.04,111.32)
  BOTTOM w0.089: CPU1.CH4 118.75,105.18 118.75,105.42 118.82,105.49 118.82,105.79 118.75,105.86 118.75,107.46 120.58,109.28 120.58,109.55
  BOTTOM w0.14: v1(134.04,111.32) 136.22,111.32 v2(136.32,111.43) 136.59,111.43 137.15,110.87 RN401.7 ; v1(121.87,110.97) 120.58,109.68 120.58,109.55
CPU_DP2_CTRL_DATA: length 23.4
  L4 w0.127: v1(134.52,111.79) 134.41,111.89 122.82,111.89 v1(122.35,111.43)
  BOTTOM w0.089: CPU1.CH3 118.56,107.51 120.35,109.3 120.35,109.55
  BOTTOM w0.14: v1(122.35,111.43) 121.73,111.43 120.35,110.05 120.35,109.55 ; v1(134.52,111.79) 135.09,111.79 v2(135.16,111.86) 135.24,111.94 136.63,111.94 137.11,111.46 RN401.8
CPU_DP2_HPD: length 32.1
  BOTTOM w0.076: CPU1.CM6 121.17,103.26 121.38,103.26 121.44,103.28 121.74,103.28 121.8,103.26 122.03,103.26 122.09,103.28 122.39,103.28 122.58,103.21 123.94,103.21 124.03,103.3
  BOTTOM w0.102: 124.03,103.3 124.55,103.3 124.83,103.03 124.83,102.89 125.08,102.64 125.77,102.64 127.27,104.14 130.72,104.14 131.71,105.13 132.95,105.13 133.23,105.41 133.23,105.59 133.45,105.82 133.45,111.36 136.19,114.1 R404.1 R403.2 136.52,112.69 136.83,112.37 v2(137.62,112.37) 137.93,112.07 139.2,112.07 R405.2 139.33,112.39 139.33,114.12 138.87,114.58 Q401.6
CPU_DP_HPD_MUX: length 1.8
  TOP w0.102: R7206.1 38.61,112.98 38.74,112.85 39.63,112.85 39.83,112.65 U7201.11
CPU_DP_HPD_R: length 40.4
  TOP w0.089: U5802.48 v1(47.7,120.97) ; v1(37.82,112.2) 37.65,112.37 R7206.2 37.65,113.87 R7202.2 ; v1(28.12,111.16) v2(27.4,111.16) 27.14,110.91 R7219.1 26.08,110.46 25.09,110.46 R7118.2 24.91,110.73 v1(24.69,110.95)
  L3 w0.089: v1(47.7,120.97) 47.7,119.96 46.01,118.27 46.01,117.65 44.26,115.9 44.26,115.4 43.56,114.7 42.44,114.7 40.1,112.36 38.04,112.36 37.91,112.23 37.85,112.23 v1(37.82,112.2)
  L4 w0.089: v1(24.69,110.95) 23.69,109.96 20.63,109.96 19.62,108.95 19.62,108.93 19.42,108.74 v1(19.32,108.74)
  BOTTOM w0.089: v1(28.12,111.16) 28.24,111.28 36.79,111.28 37.71,112.2 v1(37.82,112.2) ; R7176.2 18.77,107.68 18.88,107.57 19.41,107.57 19.66,107.82 19.66,108.17 19.32,108.51 v1(19.32,108.74)
CPU_POPIRCOMP: length 1.4
  TOP w0.305: R304.1 110.73,90.08 v1(110.73,89.94)
  BOTTOM w0.305: CPU1.BP27 v1(110.73,89.94)
CPU_SMB_SCL_THM: length 12.4
  TOP w0.14: U2601.8 128.95,124.1 129.38,123.66 v1(129.38,123.12) ; v1(127.04,116.57) 127.43,116.19 Q2601.4
  L3 w0.127: v1(127.04,116.57) 129.33,118.86 129.33,123.06 v1(129.38,123.12)
  BOTTOM w0.14: v1(127.04,116.57) v2(127.44,116.97) ; v1(129.38,123.12) 129.09,123.4 RN2602.4
CPU_SMB_SDA_THM: length 11.5
  TOP w0.14: U2601.7 129.07,124.75 129.97,123.85 129.97,123.29 v1(130.05,123.21) ; v1(130.05,118.14) 130.05,118.67 v2(129.97,118.75) 129.3,118.75 129.17,118.62 Q2601.1
  L3 w0.127: v1(130.05,123.21) v1(130.05,118.14)
  BOTTOM w0.14: RN2602.3 129.76,123.5 v1(130.05,123.21)
CPVDD: length 7.1
  TOP w0.203: v2(29.13,10.39) 28.9,10.62 28.68,10.62 28.33,10.97 HDA27.29
  TOP w0.381: C2704.1 30.99,7.75 30.36,7.12 R2709.2
  TOP w0.508: C2704.1 31.6,8.33 C2705.2 31.6,8.86 31.05,9.4 31.05,9.43 30.89,9.59 30.89,9.61 30.58,9.91 29.61,9.91 v2(29.13,10.39)
CPVEE: length 3.4
  TOP w0.203: v2(27.89,10.34) 27.53,10.7 HDA27.27
  TOP w0.305: C2709.1 28.55,9.15 28.55,9.68 v2(27.89,10.34)
CRT_AUX_CPU_N: length 189.3
  TOP w0.127: v1(58.48,121.13) 58.48,121.13 58.59,121.02 58.59,119.81 58.29,119.52 58.11,119.52 R5822.2 57.58,119.48 57.28,119.48 R5825.1
  L4 w0.114: v1(58.48,121.13) 58.5,121.13 58.52,121.11 58.52,121.11 58.83,120.8 58.83,120.73 59.09,120.47 60.79,120.47 61.35,121.03 66.89,121.03 72.07,121.03 72.79,121.74 116.25,121.74 116.61,122.1 116.61,123.23 117,123.62 121.34,123.62 122.45,124.73 132.06,124.73 140.8,116 140.8,110.36 141.25,109.91 141.25,108.56 144.71,105.11 144.71,100.39 158.69,86.41 158.69,80.69 176.08,63.3 176.84,63.3 180.92,59.22 187.54,59.22 190.23,61.91 198.8,61.91 198.98,61.73 198.98,61.51 v1(198.56,61.09)
  BOTTOM w0.127: v1(198.56,61.09) 198.74,60.9 198.74,60.72 198.08,60.06 198.08,59.78 197.95,59.65 VGABD1.14 ; R5831.1 58.48,121.04 v1(58.48,121.13)
CRT_AUX_CPU_N_R: length 6.4
  TOP w0.127: v1(59.13,118.77) 59.35,118.55 59.35,118.55 59.55,118.34 59.55,116.69 59.4,116.54 59.21,116.54 59.03,116.72 v2(59.03,117.74) 58.8,117.97 58.44,117.97 58.28,117.81 R5845.1
  BOTTOM w0.127: v1(59.13,118.77) 58.65,119.25 R5831.2
CRT_AUX_CPU_P: length 189.6
  TOP w0.127: 58.83,120.42 58.83,119.71 58.39,119.28 58.12,119.28 R5823.2 57.28,119.03 R5824.1 ; 58.83,120.42 58.83,120.85 59.11,121.13 v1(59.13,121.13) ; 58.83,120.42 v2(58.98,120.42)
  L4 w0.114: v1(59.13,121.13) 59.06,121.06 59.06,120.82 59.18,120.7 60.69,120.7 61.26,121.26 66.98,121.26 71.97,121.26 72.69,121.97 116.16,121.97 116.38,122.19 116.38,123.33 116.9,123.85 121.25,123.85 122.36,124.96 132.16,124.96 141.02,116.1 141.02,110.46 141.48,110 141.48,108.66 144.94,105.2 144.94,100.49 158.92,86.5 158.92,80.78 176.18,63.53 176.94,63.53 181.02,59.45 187.45,59.45 190.14,62.14 198.9,62.14 199.21,61.83 v1(199.21,61.09)
  BOTTOM w0.127: v1(199.21,61.09) 199.21,60.85 198.32,59.96 198.32,59.78 198.45,59.65 VGABD1.13 ; v1(59.13,121.13) 59.12,121.09 R5830.1
CRT_AUX_CPU_P_R: length 6.3
  TOP w0.127: v1(59.79,118.73) 59.79,116.82 59.92,116.69 59.92,115.11 59.47,114.66 v2(59.17,114.66) R5844.1
  BOTTOM w0.127: v1(59.79,118.73) 59.79,118.74 59.44,119.09 R5830.2
CRT_DDI_TX_N0: length 197.5
  TOP w0.127: 57.08,123.46 56.35,124.18 53.16,124.18 52.76,124.59 51.76,124.59 51.63,124.46 51.63,123.69 R5826.1 ; 57.08,123.46 v2(56.98,123.36) ; 57.08,123.46 57.67,122.87 v1(57.67,122.33)
  L4 w0.114: v1(202.24,61.09) 202.03,61.29 202.03,61.79 200.33,63.5 189.78,63.5 187.7,61.42 183.85,61.42 180.43,64.85 176.68,64.85 160.29,81.24 160.29,87.07 146.39,100.97 146.39,106.44 143.31,109.52 143.31,111.38 142.25,112.43 142.25,116.62 132.5,126.38 119.28,126.38 118.47,125.57 113.14,125.57 112.18,124.62 111.46,124.62 110.11,123.26 104.82,123.26 104.36,123.72 72.72,123.72 71.56,122.56 59.57,122.56 59.36,122.77 57.86,122.77 57.67,122.57 v1(57.67,122.33)
  BOTTOM w0.127: v1(202.24,61.09) 202.03,60.89 202.03,60.55 201.33,59.85 201.33,59.66 201.45,59.54 VGABD1.7
CRT_DDI_TX_N1: length 190.9
  TOP w0.127: v1(56.77,121.92) 56.51,121.92 56.38,122.04 56.38,122.33 56.27,122.44 55.98,122.44 ; 55.98,122.44 55.44,122.44 R5843.1 ; 55.98,122.44 v2(55.98,122.3)
  L4 w0.114: v1(200.82,61.09) 200.65,61.09 200.26,61.48 200.26,62 199.44,62.82 189.96,62.82 187.93,60.79 183.55,60.79 180.13,64.21 176.38,64.21 159.61,80.99 159.61,86.79 145.66,100.73 145.66,105.79 142.09,109.36 142.09,110.36 141.63,110.81 141.63,116.38 132.44,125.57 119.42,125.57 118.4,124.55 116.08,124.55 115.33,123.8 112.46,123.8 111.24,122.58 72.44,122.58 71.75,121.9 57.46,121.9 56.85,121.29 56.65,121.29 56.47,121.47 56.47,121.79 56.59,121.92 v1(56.77,121.92)
  BOTTOM w0.127: v1(200.82,61.09) 199.69,59.96 199.69,59.72 199.95,59.46 VGABD1.10
CRT_DDI_TX_P0: length 197.5
  TOP w0.127: v2(56.01,124.58) 56.01,124.43 ; 56.01,124.43 56.45,124.43 58.35,122.53 v1(58.35,122.33) ; 56.01,124.43 53.26,124.43 52.86,124.83 51.66,124.83 51.39,124.56 51.39,123.6 R5827.1
  L4 w0.114: v1(58.35,122.33) 58.56,122.54 59.26,122.54 59.47,122.33 71.65,122.33 72.81,123.5 104.26,123.5 104.73,123.03 110.2,123.03 111.56,124.39 112.27,124.39 113.23,125.34 118.57,125.34 119.37,126.15 132.4,126.15 142.03,116.53 142.03,112.34 143.08,111.28 143.08,109.42 146.16,106.34 146.16,100.88 160.06,86.98 160.06,81.14 176.59,64.62 180.33,64.62 183.75,61.2 187.8,61.2 189.87,63.27 200.23,63.27 201.81,61.69 201.81,61.22 201.68,61.09 v1(201.45,61.09)
  BOTTOM w0.127: v1(201.45,61.09) 201.67,61.09 201.79,60.96 201.79,60.65 201.09,59.95 201.09,59.63 200.95,59.5 VGABD1.8
CRT_DDI_TX_P1: length 190.4
  TOP w0.127: R5842.1 55.26,122.68 v1(56.77,122.68)
  L4 w0.114: v1(56.77,122.68) 56.24,122.15 56.24,121.37 56.55,121.06 56.94,121.06 57.55,121.67 71.85,121.67 72.53,122.35 111.33,122.35 112.55,123.57 115.42,123.57 116.17,124.32 118.5,124.32 119.52,125.34 132.34,125.34 141.4,116.28 141.4,110.72 141.86,110.26 141.86,109.27 145.43,105.7 145.43,100.64 159.38,86.69 159.38,80.89 176.29,63.98 180.03,63.98 183.46,60.56 188.02,60.56 190.05,62.59 199.35,62.59 200.03,61.91 v1(200.03,61.09)
  BOTTOM w0.127: VGABD1.11 199.45,60.06 200.03,60.64 v1(200.03,61.09)
CRT_DP_HPD: length 5.1
  TOP w0.102: U5802.38 51.7,121.12 v1(51.65,121.17)
  BOTTOM w0.102: v1(51.65,121.17) 51.54,121.29 51.54,122.45 v2(52.56,123.47) 52.61,123.51 R5605.2
CRT_DP_HPD_R: length 280.8
  TOP w0.089: v1(197.13,61.09) 197.92,60.3 AFTP5602.1
  L4 w0.089: v1(50.63,125.12) 50.6,125.15 50.6,126.44 52.25,128.09 52.81,128.09 59.77,135.05 62.07,135.05 75.85,148.83 95.49,148.83 97.08,147.25 104.95,147.25 106.38,148.67 106.93,148.67 119.94,148.67 122.02,146.58 127.81,146.58 131.6,150.38 163.77,150.38 167.05,147.1 167.05,125.39 165.45,123.79 165.45,119.2 166,118.65 166,109.17 165.11,108.28 163.98,108.28 163.41,107.72 162.64,107.72 158.47,103.55 158.47,98.12 167.41,89.19 167.41,81.8 167.41,81.69 179.2,69.9 179.37,69.9 180.61,68.66 186.2,68.66 186.67,68.51 187.06,68.34 187.41,68.1 188.18,67.34 188.39,67.13 188.39,66.99 189.19,66.19 189.29,66.19 189.44,66.35 209.32,66.35 209.68,66.7 210.98,66.7 211.21,66.47 v1(211.21,66.13)
  BOTTOM w0.089: VGABD1.18 195.95,59.83 197.13,61.01 v1(197.13,61.09) 197.13,61.5 197.55,61.91 197.55,62.18 197.55,62.19 197.55,63.44 199.39,65.28 210.33,65.28 211.18,66.13 v1(211.21,66.13) ; v1(50.63,125.12) 51.98,125.12 52.44,125.58 R5605.1
CTL1: length 4.5
  TOP w0.102: R3601.2 17.66,54.11 18.15,54.6 v2(18.28,54.6) 18.38,54.5 18.38,54.32 19.23,53.47 19.23,52.22 19.51,51.94 U3601.6
CTL2: length 3.3
  TOP w0.102: U3601.7 19.5,51.44 19,51.94 19,53.04 v2(18.82,53.21) 18.49,53.21 18.36,53.08 R3606.2
CTL3: length 2.4
  TOP w0.102: U3601.8 v2(18.82,50.94) 18.82,51.16 18.5,51.48 R3602.2
DAT_ITE8010: length 2.2
  TOP w0.14: R2455.1 216.33,51.18 v2(216.61,51.46) 216.7,51.55 WWAN1.13
DAT_TP_SIO: length 162.3
  TOP w0.127: v1(36.83,65.97) 36.83,65.96 37.32,65.47 38.13,65.47 38.35,65.69 U2401.79
  TOP w0.14: RN6502.2 103.83,30.93 EC6501.1 103.81,30.51 v1(103.58,30.29) 103.84,30.03 RN6501.3 104.08,29.34 v2(104.71,29.34)
  L3 w0.127: v1(102.19,34.53) 102.16,34.51 102.16,34.01 101.84,33.69 94.32,33.69 94.08,33.45 93.83,33.45 92.56,33.45 91.81,32.7 90.56,32.7 89.47,31.62 83.42,31.62 82.91,32.13 78.21,32.13 74.22,28.14 56.21,28.14 55.76,27.69 40.09,27.69 37.73,25.33 23.87,25.33 18.37,30.84 18.37,40.44 17.85,40.95 17.85,42.99 17.02,43.82 17.02,43.94 17.02,44.23 17.02,44.23 17.02,46.29 17.02,46.63 17.02,51.58 17.48,52.04 17.48,52.16 17.62,52.3 17.62,57.14 17.62,57.28 17.62,57.48 17.04,58.06 17.04,59.45 17.04,59.67 17.22,59.85 17.22,60.22 16.96,60.48 16.93,60.48 16.81,60.6 16.81,62.36 17,62.55 17,64.46 17.08,64.54 17.08,64.54 18.27,65.73 18.27,66.25 18.3,66.28 18.3,66.48 18.56,66.74 18.75,66.74 19.12,67.1 19.12,68.19 v1(18.8,68.5)
  BOTTOM w0.14: v1(36.83,65.97) 36.2,65.33 35.88,65.33 35.86,65.31 32.72,65.31 32.7,65.33 32.68,65.33 31.01,67 31.01,67.13 30.46,67.68 29.06,67.68 28.85,67.89 27.01,67.89 26.33,68.57 25.29,68.57 24.94,68.93 24.56,68.93 24.4,68.77 22.27,68.77 22.21,68.71 21.64,68.71 21.29,69.06 20.98,69.06 20.51,69.53 19.97,69.53 19.62,69.18 19.62,68.82 19.3,68.5 v1(18.8,68.5) ; v1(103.58,30.29) 103.58,31.9 102.19,33.3 v1(102.19,34.53)
DBC_EN_R: length 5.2
  TOP w0.102: AFTP5522.1 215.5,41.36 215.9,40.95 215.9,40.42 215.95,40.36 215.95,40.36 R5504.2 216.4,39.84 217.12,39.84 217.65,40.38 217.65,40.42 v1(217.69,40.46)
  BOTTOM w0.102: v1(217.69,40.46) 217.78,40.55 LCD1.34
DBC_PANEL_EN: length 154.8
  TOP w0.102: R5504.1 216.64,40.77 216.96,40.45 v1(216.96,40.34) ; v1(205.57,33.91) 206.22,34.56 206.22,35.75 207.04,36.57 207.04,38.51 206.78,38.76 v2(206.78,39.12) 206.78,39.48 207.01,39.71 207.01,41.16 207.06,41.21 207.06,41.47 207.34,41.75 207.34,42.32 207.36,42.33 207.36,43.93 207.09,44.2 207.09,44.64 206.67,45.06 205.61,45.06 205.44,45.24 204.65,45.24 v1(204.52,45.37)
  L2SGND w0.102: v1(145.25,80.63) 145.67,80.21 145.67,79.7 145.95,79.43 146.18,79.43 150.29,75.32 152.51,75.32 152.53,75.33 153.01,75.33 157.18,71.16 157.18,69.46 172.1,54.54 176.05,54.54 176.78,55.26 179.96,55.26 179.96,55.26 198.07,55.26 199.48,53.85 203.8,53.85 204.9,52.76 206.88,52.76 208.19,51.44 208.19,49.54 208.48,49.25 208.48,48.4 207.3,47.22 207.3,46.82 207.3,46.81 207.3,45.62 206.75,45.07 205.76,45.07 205.75,45.06 205.5,45.06 205.34,45.22 204.66,45.22 v1(204.52,45.37)
  L3 w0.102: v1(114.38,88.03) 115.29,87.12 115.29,86.4 116.44,85.25 116.9,85.25 117.36,85.71 118.46,85.71 118.8,86.05 119.38,86.05 119.53,85.9 120.48,85.9 121.21,86.63 121.68,86.63 121.95,86.89 127.7,86.89 127.77,86.97 130.56,86.97 132.2,85.32 134.98,85.32 136.48,83.82 141.25,83.82 143.91,81.15 143.93,81.15 144.33,80.75 145.13,80.75 145.24,80.63 v1(145.25,80.63)
  L4 w0.102: v1(205.57,33.91) 206.62,33.91 209.67,36.96 214.53,36.96 216.96,39.39 v1(216.96,40.34)
  BOTTOM w0.102: CPU1.CA31 114.78,87.63 v1(114.38,88.03) ; v1(145.25,80.63) 145.37,80.51 145.37,79.6 R2043.2
DC_IN_OFF: length 2.3
  TOP w0.254: R4470.2 29.29,121.6 Q4349.6 30.22,121.4 R4369.2
DCBATOUT: length 50.5
  TOP w0.508: v1(204.58,36.97) 204.58,38.6 204.35,38.84 204.35,40.38 203.1,41.63 202.61,41.63 202.16,42.08 200.04,42.08 199.44,41.48 197.35,41.48 v1(197.09,41.73)
  L5SGND w0.508: v1(181.17,35.33) 181.17,37.81 184.69,41.33 185.7,41.33 186.19,41.81 189.42,41.81 189.52,41.91 191.56,43.95 191.6,43.95 191.61,43.96 195.52,43.96 197.09,42.39 v1(197.09,41.73)
  BOTTOM w0.254: PC4522.1 38.61,33.88 38.56,33.88 38.32,34.12 37.18,34.12 35.83,35.47 35.83,38.78 35.35,39.26 PR4511.1
  BOTTOM w0.508: PD4401.2 197.22,40.91 197.22,41.13 197.22,41.6 197.09,41.73 v1(197.09,41.73) ; F5503.2 209.56,40.72 206.84,38 206.81,38 206.73,37.92 205.09,37.92 204.58,37.42 v1(204.58,36.97)
  vias: v1(179.26,35.31) v1(179.26,34.67) v1(179.9,35.31) v1(179.9,34.67) v1(180.53,35.33) v1(180.53,34.7) v1(181.17,34.7) v1(184.48,39.24) v1(184.5,38.6) v1(184.51,37.95) v2(40.9,32.8) v2(65.81,137.59) v2(83.31,148.03) v2(99.52,146.61) v2(122.83,145.88) v2(126.78,38.37) v2(144.54,103.8) v2(148.99,124.43) v2(163.9,123.42) v2(164.95,142.1) v2(170.33,63.94) v2(172.91,39.35) v2(175.66,52.59) v2(180.98,33.81) v3(78.08,29.53) v3(78.11,28.67) v3(79,29.53) v3(79,28.67) v3(88.95,29.78) v3(89.87,29.78) v3(90.78,29.78) v3(91.49,30.33) v3(105.41,31.17) v3(124.01,35.31) v3(124.84,35.31) v3(125.71,35.33) v3(126.6,35.28) v3(153.08,40.94) v3(153.95,40.95) v3(162.84,123.19) v3(162.87,126.65) v3(162.87,125.81) v3(162.87,124.97) v3(162.87,124.13) v3(167.06,40.48) v3(167.89,40.6) v3(171.5,64.25) v3(172.07,63.63) v3(172.66,63.03) v3(173.27,62.42) v3(173.89,61.85) v3(176.81,52.5) v3(177.78,53.16) v3(177.75,52.33) v3(178.72,53.11) v3(178.67,52.27)
DCBATOUT_C1: length 67.3
  TOP w0.102: v1(162.24,143.48) v2(161.79,143.03)
  L2SGND w0.089: v1(162.24,143.48) 162.23,143.48 161.55,143.48 160.89,142.82 158.38,142.82 157.42,143.79 156.9,143.79 156.59,143.47 156.59,143.17 156.16,142.75 155.03,142.75 154.31,143.47 153.5,143.47 152.69,144.28 149.59,144.28 147.86,142.55 147.07,142.55 146.98,142.46 144.16,142.46 143.28,143.33 137.72,143.33 136.92,144.14 130.48,144.14 129.05,142.72 120.28,142.72 118.02,144.98 110.29,144.98 109.43,144.12 108,144.12 106.95,143.07 104.74,143.07 v1(104.63,142.95)
  BOTTOM w0.089: v1(104.63,142.95) 104.62,142.96 R9316.2
  BOTTOM w0.102: v1(162.24,143.48) 162.11,143.62 161.87,143.62 161.77,143.51 PMBD1.1 161.77,142.16 R9329.2
DCBATOUT_C6: length 80.3
  L2SGND w0.089: v1(157.02,144.44) 156.35,145.12 149.4,145.12 147.58,145.12 147.41,144.95 140.29,144.95 140.28,144.94 130.13,144.94 128.71,143.52 120.59,143.52 118.34,145.77 108.99,145.77 106.87,143.64 98.58,143.64 97.71,144.51 85.97,144.51 85.6,144.89 v1(85.6,144.93)
  BOTTOM w0.102: v1(85.6,144.93) 85.52,145.01 85.52,145.52 R9309.2 ; PMBD1.16 158.97,145.19 158.87,145.09 157.87,145.09 157.23,144.44 v1(157.02,144.44) 156.91,144.55 v2(156.91,145.05) 156.45,145.51 R9335.2
DCBATOUT_C7: length 213.7
  TOP w0.089: R9319.2 118,36.06 118,37.99 117.16,38.84 111.03,38.84 108.94,40.92 v2(108.94,41.18) 108.57,41.56 106.07,41.56 105.01,42.62 103.17,42.62 101.84,43.95 100.84,43.95 100.7,44.1 v1(100.7,44.67)
  L4 w0.089: v1(175.09,69.9) 175.04,69.86 174.57,69.86 174.39,70.04 173.71,70.04 163.3,80.44 163.3,82.75 162.51,83.54 162.51,86.43 163,86.93 163,87.78 160.09,90.69 159.36,90.69 157.76,92.29 157.76,93.27 154.79,96.24 154.79,105.84 155.54,106.59 156.45,106.59 156.54,106.68
  L4 w0.102: v1(158.86,144.2) 158.42,144.64 157.96,144.64 157.59,144.27 157.59,141.64 157.47,141.52 157.47,137.05 160.02,134.5 160.02,127.8 161.01,126.82 161.01,118.35 162.61,116.75 162.61,112.75 156.54,106.68
  BOTTOM w0.089: v1(175.09,69.9) 174.93,69.75 174.93,68.72 176.24,67.41 176.24,66.38 175.94,66.08 174.51,66.08 173.89,66.7 170.51,66.7 169.57,65.76 169.57,63.95 167.88,62.26 167.52,61.89 167.52,60.22 165.66,58.36 164.93,58.36 162.16,55.6 157.18,55.6 156.36,54.77 148,54.77 147.56,55.21 145.66,55.21 145.2,55.68 110.68,55.68 109.79,54.79 109.63,54.79 109.53,54.69 103.9,54.69 101.21,52 101.21,46.07 100.7,45.55 v1(100.7,44.67)
  BOTTOM w0.102: R9326.2 157.84,142.05 157.98,142.2 158.5,142.2 158.97,142.66 PMBD1.15 158.97,144.09 v1(158.86,144.2)
DCBATOUT_C8: length 53.4
  L2SGND w0.102: v1(109.4,145.04) 109.75,145.38 118.18,145.38 120.43,143.13 128.87,143.13 130.29,144.55 147.6,144.55 147.78,144.73 152.85,144.73 153.67,143.92 154.43,143.92 154.69,143.66 155.55,143.66 v1(155.99,143.22)
  BOTTOM w0.102: R9320.2 108.54,145.04 v1(109.4,145.04) ; R9324.2 155.99,143.49 v1(155.99,143.22) 155.99,142.98 156.3,142.66 v2(156.56,142.66) 156.72,142.83 157.98,142.83 PMBD1.19
DCBATOUT_LCD: length 201.7
  TOP w0.203: D5504.A C5528.1 146.1,130.58 146.1,129.83 145.78,129.51 145.78,128.59 146.16,128.22 148.56,128.22 149.08,128.73 150.06,128.73 150.42,129.08 150.42,130.39 150.67,130.64 151.09,130.64 152,131.56 152,131.66 153.14,132.8 153.14,135.1 152.91,135.34 152.91,135.85 153.64,136.59 153.64,137.41 153.85,137.62 162.17,137.62 163.75,139.2 163.75,139.68 v1(163.3,140.13)
  TOP w0.305: v1(211.75,40.45) 211.91,40.29 213.01,40.29 AFTP5526.1 213.72,40.99 213.72,41.57 ; 213.72,41.57 214.91,40.37 AFTP5525.1 ; 213.72,41.57 R9303.1 ; C5512.1 217.35,36.84 v1(217.75,37.25) 217.57,37.25 217.2,37.62 C5513.1
  L4 w0.089: v1(211.75,40.45) 212.25,39.94 212.88,39.94 213.38,40.44 213.59,40.44 216.07,42.92 217.15,42.92 218.5,44.27 218.5,48.37 219.18,49.05 219.18,56.62 220.54,57.98 220.54,60.91 217.13,64.32 209.55,64.32 209.24,64.63 202.41,64.63 v1(201.81,64.03)
  L5SGND w0.102: v1(201.81,64.03) 201.35,64.49 189.21,64.49 187.16,62.45 184.29,62.45 177.38,69.36 176.88,69.36 164.65,81.59 164.65,86.49 162.72,88.42 162.72,90.42 158.47,94.66 158.47,103.51 160.07,105.11 160.07,111.63 159.72,111.99 159.72,114.4 159.86,114.55 159.86,114.55 162.57,117.26 162.57,120.47 164.06,121.96 164.06,139.45 163.38,140.13 v1(163.3,140.13)
  BOTTOM w0.102: v1(211.75,40.45) 212.07,40.13 212.07,39.17 212.87,38.36 213.11,38.36 214.41,37.06 215.18,37.06 R5556.2
  BOTTOM w0.305: FC8974.1 214.59,42.9 215.36,42.13 C5514.1
DCBATOUT_LCD_C: length 168.6
  TOP w0.102: v1(162.93,146.19) 163.2,145.92 v2(163.5,145.92) 163.76,145.67 R9333.2 ; v1(212.61,40.82) 212.62,40.83 212.82,40.83 213.14,41.15 R9303.2
  L4 w0.089: 161.26,130.26 163.59,127.93 163.59,118.86 164.32,118.13 164.32,111.61 157.33,104.62 157.33,96 159.87,93.46 160.31,93.46 165.32,88.45 165.32,81.13 176.27,70.18 176.27,69.94 178.59,67.62 178.75,67.62 184.16,62.2 187.42,62.2 189.46,64.25 200.91,64.25 201.56,63.6 203.28,63.6 203.96,64.28 209.03,64.28 209.4,63.91 217.03,63.91 219.52,61.42 219.52,59.48 218.84,58.8 218.84,49.21 218.16,48.53 218.16,45.49 213.68,41.01 212.81,41.01 v1(212.61,40.82)
  L4 w0.102: v1(162.93,146.19) 162.55,145.81 162.1,145.81 161.25,144.97 161.25,143.74 159.98,142.47 159.98,141.79 160,141.77 160,141.41 159.98,141.4 159.98,140.73 160.34,140.37 160.34,137.69 161.26,136.77 161.26,130.26
  BOTTOM w0.102: v1(162.93,146.19) 162.93,146.22 162.47,146.68 161.77,146.68 161.37,146.27 PMBD1.4
DCBATOUT_LCD_PG: length 2
  TOP w0.102: Q5505.1 144.31,126.81 v2(144.3,126.8) 144.28,126.78 R5546.2
DCBATOUT_LCD_PWRGD: length 5.9
  TOP w0.102: R5554.1 143.71,130.42 v2(143.71,131.12) 143.71,131.9 144.08,132.27 D5504.K 145.37,132.32 145.37,133.39 C5531.1 144.41,133.59 R5555.1
DCBATOUT_LCD_R: length 6.6
  TOP w0.305: R9302.1 211.61,42.04 v2(211.61,41.46) 211.61,41.43 v1(212,41.04)
  BOTTOM w0.089: R5556.1 215.32,38.71 213.02,38.71 212.45,39.28 212.45,40.35 212,40.8 v1(212,41.04)
DCBATOUT_LCD_R_C: length 167.8
  TOP w0.102: R9302.2 212.37,41.76 v1(212.62,41.52) ; v1(162.29,146.24) 162.29,146.28 v2(161.8,146.77) 161.61,146.58 161.61,146.25 161.18,145.82 R9332.2
  L4 w0.089: v1(212.62,41.52) 213.9,41.52 217.97,45.59 217.97,48.67 218.65,49.35 218.65,58.94 219.33,59.62 219.33,61.34 217.07,63.6 209.3,63.6 208.9,63.2 201.48,63.2 200.63,64.06 189.54,64.06 187.49,62.01 184.08,62.01 178.67,67.43 178.51,67.43 176.08,69.86 176.08,70.1 165.13,81.05 165.13,88.37 160.23,93.27 159.79,93.27 157.14,95.92 157.14,104.91 164.13,111.91 164.13,117.83 162.16,119.8 162.16,127.15 162.03,127.28
  L4 w0.102: 162.03,127.28 160.85,128.46 160.85,136.66 159.77,137.75 159.77,137.76 159.28,138.25 159.15,138.25 158.28,139.12 158.28,141.19 158.42,141.33 158.42,141.76 160.41,143.75 160.71,143.75 160.97,144 160.97,144.3 160.99,144.32 160.99,144.99 162.24,146.24 v1(162.29,146.24)
  BOTTOM w0.102: PMBD1.2 161.77,146.12 161.89,146.24 v1(162.29,146.24)
DDR4_DRAMRST#: length 103.8
  TOP w0.216: v2(53.1,45.36) v1(53.1,44.78) ; C501.1 55.63,45.12 v1(55.58,45.07)
  L3 w0.203: v1(130.61,41.23) 130.49,41.23 127.85,43.87 124.1,43.87 121.98,45.98 107.91,45.98 107.06,45.13 103.51,45.13 102.16,46.48 100.31,46.48 98.97,45.14 98.23,45.14 96.28,43.19 92.37,43.19 92.15,43.41 81.89,43.41 81.66,43.19 54.68,43.19 v1(53.1,44.78)
  BOTTOM w0.216: ED1217.2 ED1217.1 58.42,40.82 58.26,40.99 58.26,41.32 57.79,41.79 57.3,41.79 57.16,41.93 57.16,42.41 57.08,42.5 DM1.108 57.08,44.05 56.05,45.07 v1(55.58,45.07) 54.28,45.07 54.28,45.08 53.39,45.08 v1(53.1,44.78) ; ED1302.2 127.83,38.72 128.13,39.03 129.17,39.03 ED1302.1 129.9,39.14 129.9,39.7 R504.2 130.73,41.1 130.61,41.21 v1(130.61,41.23) 130.61,41.53 130.88,41.79 133.03,41.79 133.28,42.04 DM2.108
DMIC_CLK_EDP: length 228.6
  TOP w0.14: v1(157.28,37.31) 158.22,36.37 158.22,35.76 157.58,35.13 157.09,35.13 RN5505.1 ; AFTP5510.1 33.02,31.12 33.02,30.29 v1(33,30.27) 33.02,30.25 33.02,30.05 32.76,29.79 32.76,27.96 32.11,27.3 32.11,22.86 32.31,22.66 32.31,21.36 31.4,20.45 RN5504.2 ; v1(220.12,46.89) 219.69,46.46 219.69,45.65 218.95,44.91 216.99,44.91 216.9,44.81 216.76,44.81 215.95,44 215.94,44 EC5504.1 215.11,43.24 v1(215.11,44.39)
  L3 w0.127: v1(215.11,44.39) 215.11,44.42 215.58,44.9 215.95,44.9 216.21,44.64 216.21,44.27 215.95,44 215.74,44 213.99,42.25 211.82,42.25 211.62,42.25 209.67,40.3 205.69,40.3 204.1,41.89 201.61,41.89 201.13,41.41 197.96,41.41 197.83,41.28 194.89,41.28 194.73,41.44 192.69,41.44 191.09,39.84 189.31,39.84 187.33,37.86 185.46,37.86 184.82,37.23 183,37.23 182.32,37.9 172.55,37.9 171.26,39.19 169.27,39.19 168.6,38.53 158.5,38.53 v1(157.28,37.31) 156.87,36.91 156.87,35.71 155.66,34.49 149.48,34.49 145.76,38.22 126.6,38.22 124.44,40.38 121.12,40.38 120.61,40.89 120.61,41.56 119.84,42.33 110,42.33 108.47,40.8 107.1,40.8 106.5,40.2 106.5,39.32 106.22,39.04 105.41,39.04 104.4,38.03 103.66,38.03 102.96,37.33 102.05,37.33 100.47,35.75 99.94,35.75 99.93,35.75 93.35,35.75 93.02,35.42 91.67,35.42 90.95,34.7 80.66,34.7 79.87,35.5 78.3,35.5 73.56,30.76 42.14,30.76 41.31,29.93 34.33,29.93 34.22,29.83 33.44,29.83 v1(33,30.27)
  BOTTOM w0.14: v1(220.12,46.89) 220.09,46.86 219.61,46.86 219.3,46.55 LCD1.22
DMIC_DATA_EDP: length 222.2
  TOP w0.14: v1(215.77,44.45) 216.58,45.26 EC5503.1 216.74,45.19 218.82,45.19 219.41,45.77 219.41,46.84 v1(220.09,47.52) ; v1(156.57,37.34) 157.3,36.61 RN5505.2 ; AFTP5509.1 34.65,31.22 v1(33.7,30.28) 33.68,30.25 33.62,30.25 33.04,29.67 33.04,27.84 32.39,27.19 32.39,23.01 32.59,22.81 32.59,21.21 32.05,20.67 RN5504.1
  L3 w0.127: v1(33.7,30.28) 34.78,30.28 34.87,30.19 41.21,30.19 42.04,31.01 73.46,31.01 78.19,35.75 79.97,35.75 80.77,34.96 90.85,34.96 91.57,35.68 92.91,35.68 93.24,36 99.83,36 99.83,36.01 100.37,36.01 101.95,37.58 102.86,37.58 103.77,38.5 103.77,38.67 105.08,39.97 105.67,39.97 106.75,41.05 108.37,41.05 109.89,42.58 119.95,42.58 120.86,41.66 120.86,40.99 121.23,40.63 124.54,40.63 126.7,38.47 145.89,38.47 149.61,34.75 155.55,34.75 156.57,35.76 v1(156.57,37.34) 156.57,37.56 157.79,38.78 168.5,38.78 169.16,39.45 171.43,39.45 172.72,38.16 182.42,38.16 183.09,37.49 184.72,37.49 185.35,38.12 187.23,38.12 189.21,40.1 190.98,40.1 192.59,41.7 196.02,41.7 196.55,42.23 197.5,42.23 198.07,41.67 201.03,41.67 201.5,42.14 204,42.14 204.21,42.14 205.8,40.55 209.56,40.55 211.52,42.51 211.93,42.51 213.86,42.51 215.77,44.42 v1(215.77,44.45)
  BOTTOM w0.14: v1(220.09,47.52) 220.04,47.47 219.81,47.47 219.39,47.05 LCD1.21
DMIC_PCH_CLK: length 87.6
  TOP w0.14: v2(124.78,91.36) 125.09,91.05 v1(125.09,90.86) ; v1(154.94,37.77) 154.94,37.28 RN5505.4
  L4 w0.127: v1(154.94,37.77) 154.94,37.86 155.78,38.69 159.51,38.69 160.1,39.28 161.2,39.28 161.67,39.76 161.67,40.4 165.01,43.74 165.01,50.1 158.55,56.57 158.39,56.57 151.93,63.02 151.93,63.48 149.11,66.31 149.11,67.26 140.41,75.96 139.55,75.96 138.83,76.68 138.83,77.62 138.94,77.73 138.94,78.71 139.1,78.87 139.1,82.06 138.94,82.22 138.94,83.18 138.15,83.97 137.48,83.97 133.47,87.98 131.32,87.98 129.07,90.23 126.13,90.23 125.94,90.43 125.53,90.43 v1(125.09,90.86)
  BOTTOM w0.089: CPU1.CP24 122.15,91.89 122.17,91.89 122.25,91.81 124.03,91.81 124.88,90.96 124.99,90.96 v1(125.09,90.86)
DMIC_PCH_DATA: length 87.4
  TOP w0.14: 156.66,36.49 156.03,37.11 v2(155.78,37.11) 155.58,37.31 v1(155.58,37.77)
  L4 w0.127: v1(155.58,37.77) 156.25,38.44 159.62,38.44 160.15,38.97 161.24,38.97 161.94,39.66 161.94,40.25 165.27,43.58 165.27,50.21 158.65,56.82 158.49,56.82 152.18,63.13 152.18,63.59 149.36,66.41 149.36,67.36 140.51,76.21 139.65,76.21 139.09,76.78 139.09,77.51 139.2,77.62 139.2,78.61 139.35,78.76 139.35,82.16 139.2,82.32 139.2,83.28 138.25,84.22 138.04,84.22 137.59,84.22 133.58,88.24 131.43,88.24 129.17,90.49 126.32,90.49 v1(125.94,90.87)
  BOTTOM w0.076: CPU1.CN24 121.45,92.39 121.98,92.39 122.11,92.36 122.39,92.36 122.48,92.38 122.72,92.38 122.85,92.25 124.19,92.25 ; v1(125.94,90.87) 125.94,90.94 125.94,90.97 125.27,91.74
  BOTTOM w0.089: 125.27,91.74 124.19,92.25
DMIC_SCL_CODEC: length 4.6
  TOP w0.14: v1(29.06,17.65) 29.06,18.04 28.76,18.34 R2738.1 ; RN5504.3 31.4,18.41 v1(31.42,18.39)
  L3 w0.127: v1(29.06,17.65) 29.07,17.64 29.25,17.64 30,18.39 v1(31.42,18.39)
DMIC_SCL_CODEC_R: length 1.4
  TOP w0.14: HDA27.3 27.93,16.8 28.37,17.24 R2738.2
DMIC_SDA_CODEC: length 6.6
  TOP w0.14: RN5504.4 v1(32.05,18.09) 32.34,18.09 v2(32.77,17.65) ; v1(29.09,17) 28.81,17 28.33,16.51 HDA27.2
  L3 w0.127: v1(29.09,17) 29.24,17 30.19,17.95 31.91,17.95 v1(32.05,18.09)
DOCK_USB_EN_A: length 16.7
  TOP w0.102: U7201.18 38.25,109.16 37.99,108.9 v1(37.92,108.9) ; U7102.16 v1(31.6,119.67)
  L4 w0.102: v1(35.53,119.05) 35.6,118.98 35.6,114.64 36.99,113.26 36.99,111.61 36.83,111.46 36.83,111 36.99,110.85 36.99,109.84 v1(37.92,108.9)
  BOTTOM w0.102: v1(31.6,119.67) 34.91,119.67 v1(35.53,119.05)
DOCK_USB_EN_B: length 11.9
  TOP w0.102: U7201.13 38.26,111.66 38.08,111.47 37.6,111.47 v1(37.34,111.22) ; v1(36.2,119.05) 35.77,119.48 35.08,119.48 34.79,119.19 U7102.10
  L4 w0.102: v1(36.2,119.05) 35.99,118.85 35.99,114.89 37.19,113.69 37.19,111.37 v1(37.34,111.22)
DP2_AUX_C_N: length 8.1
  TOP w0.127: R7104.2 R7101.2 25.41,113.34 22.04,109.97 ; U7101.25 21.8,109 21.88,109.07 21.88,109.8 22.04,109.97 ; v2(21.92,110.08) 22.04,109.97
DP2_AUX_C_P: length 8.1
  TOP w0.127: v2(25.05,112.37) 24.92,112.5 ; 24.92,112.5 25.51,113.09 25.92,113.09 26.02,113 26.02,112.72 26.22,112.52 R7102.2 27.18,112.52 R7103.2 ; 24.92,112.5 22.12,109.7 22.12,109.06 22.2,108.98 U7101.24
DP2_AUX_CPU_N: length 42.1
  TOP w0.127: v1(59.39,115.94) 59.13,116.03 58.53,116.03 R5845.2
  BOTTOM w0.076: CPU1.AD4 91.96,105.54 91.96,105.74 91.86,106 91.84,106.05 91.84,108.26 92.21,108.63 92.21,109.07 92.24,109.1 92.24,109.12
  BOTTOM w0.127: 61.42,115.77 61.75,115.77 61.96,115.57 71.74,115.57 74.68,112.63 89.88,112.63 92.24,110.26 92.24,109.12 ; 61.42,115.77 v2(61.42,115.93) ; 61.42,115.77 60.68,115.77 60.52,115.94 v1(59.39,115.94)
DP2_AUX_CPU_P: length 42.3
  TOP w0.127: C5862.1 58.59,115.79 58.9,115.79 58.98,115.71 58.98,115.42 59.1,115.3 v1(59.39,115.3)
  BOTTOM w0.076: CPU1.AD3 91.66,105.92 91.66,108.33 92.03,108.7 92.03,109.07 92,109.1 92,109.12
  BOTTOM w0.127: 92,109.12 92,110.16 89.78,112.38 74.58,112.38 71.64,115.32 67.95,115.32 ; 67.95,115.32 61.86,115.32 61.65,115.53 60.58,115.53 60.42,115.7 60.12,115.7 60,115.57 60,114.98 59.91,114.89 59.54,114.89 59.39,115.03 v1(59.39,115.3) ; 67.95,115.32 v2(67.95,115.16)
DP2_DDI_TX_C_N2: length 0.8
  TOP w0.127: R5856.1 52.63,112.45 C5806.2
DP2_DDI_TX_C_N2_R: length 2.4
  TOP w0.127: R5856.2 52.35,113.95 52.35,114.13 52,114.49 51.75,114.49 51.62,114.62 51.62,114.8 51.7,114.88 U5802.13
DP2_DDI_TX_C_N3: length 0.8
  TOP w0.127: R5858.1 54.16,112.45 C5808.2
DP2_DDI_TX_C_N3_R: length 2.6
  TOP w0.127: U5802.16 52.9,114.88 52.82,114.8 52.82,114.62 53.35,114.09 53.74,114.09 R5858.2
DP2_DDI_TX_C_P2: length 0.8
  TOP w0.127: R5855.1 51.87,112.45 C5805.2
DP2_DDI_TX_C_P2_R: length 2.4
  TOP w0.127: R5855.2 52.11,113.91 52.11,114.03 51.9,114.25 51.65,114.25 51.38,114.52 51.38,114.8 51.3,114.88 U5802.12
DP2_DDI_TX_C_P3: length 0.8
  TOP w0.127: C5807.2 53.39,112.45 R5857.1
DP2_DDI_TX_C_P3_R: length 2.2
  TOP w0.127: U5802.15 52.5,114.88 52.58,114.8 52.58,114.52 53.39,113.7 R5857.2
DP2_DDI_TX_N0: length 55.2
  TOP w0.127: v1(47.34,109.92) 47.79,110.36 47.79,110.76 47.38,111.17 C5804.1
  BOTTOM w0.076: CPU1.AC4 90.81,105.35 90.81,105.61 90.73,105.79 90.72,105.8 90.72,106.11 90.72,106.12 90.74,106.18 90.74,106.4 90.71,106.49 90.68,106.57 90.68,106.82 90.87,107 90.87,107.01 90.88,107.03 90.88,107.62 90.86,107.64
  BOTTOM w0.127: 59.36,110.92 55.82,107.38 49.69,107.38 47.93,109.14 47.93,109.71 47.73,109.92 v1(47.34,109.92) ; 59.36,110.92 v2(59.46,110.82) ; 59.36,110.92 61.74,113.3 70.88,113.3 73.09,111.09 88.28,111.09 90.63,108.74 90.63,107.98 90.86,107.75 90.86,107.64
DP2_DDI_TX_N1: length 54.7
  TOP w0.127: C5802.1 50.31,110.92 50.31,110.6 49.93,110.22 49.66,110.22 49.53,110.1 49.53,109.77 49.37,109.6 49.03,109.6 48.86,109.74 v1(48.83,109.83)
  BOTTOM w0.076: CPU1.AC1 91.3,106.77 91.3,108.62 91.36,108.69 91.36,109.07 91.33,109.1 91.33,109.12
  BOTTOM w0.127: 91.33,109.12 91.33,109.61 89.21,111.74 73.43,111.74 71.14,114.03 61.05,114.03 60.3,113.28 ; v2(60.4,113.18) 60.3,113.28 ; 60.3,113.28 55.05,108.03 50.7,108.03 50.06,108.67 50.06,109.82 49.65,110.22 49.23,110.22 v1(48.83,109.83)
DP2_DDI_TX_N2: length 58.7
  TOP w0.127: v1(51.55,110.3) 51.79,110.3 52.35,110.86 52.67,110.86 52.94,111.13 C5806.1
  BOTTOM w0.076: 92.72,107.7 92.7,107.69 92.66,107.69 92.54,107.56 92.54,107.03 92.7,106.86 92.7,106.48 92.68,106.4 92.68,106.18 92.7,106.12 92.7,106.11 92.7,105.82 92.65,105.7 92.55,105.24 CPU1.AE4
  BOTTOM w0.127: v1(51.55,110.3) 51.79,110.3 52.86,111.37 55.83,111.37 57.35,112.89 57.35,114.3 57.89,114.85 57.89,116.78 58.55,117.44 62.22,117.44 62.68,116.98 65.32,116.98 ; 65.32,116.98 72.32,116.98 75.38,113.92 90.84,113.92 93.64,111.12 93.64,108.62 92.72,107.7 ; 65.32,116.98 v2(65.32,117.12)
DP2_DDI_TX_N3: length 52.9
  TOP w0.127: v1(53.66,110.53) 54.35,111.23 C5808.1
  BOTTOM w0.076: CPU1.AE1 92.2,106.69 92.19,106.69 92.19,107.87 92.45,108.12 92.49,108.12 92.5,108.13
  BOTTOM w0.127: 58.64,113.39 58.64,113.02 55.52,109.9 53.81,109.9 53.51,110.21 53.51,110.39 v1(53.66,110.53) ; 58.64,113.39 58.64,116.3 59.03,116.69 61.95,116.69 62.43,116.21 72.14,116.21 75.08,113.27 90.4,113.27 92.99,110.68 92.99,108.62 92.5,108.13 ; 58.64,113.39 v2(58.5,113.39)
DP2_DDI_TX_P0: length 54.8
  TOP w0.127: v1(47.34,110.55) 47.11,110.55 46.57,111.09 C5803.1
  BOTTOM w0.076: CPU1.AC3 90.99,105.48 90.99,105.72 90.93,105.78 90.89,105.86 90.89,106.07 90.92,106.15 90.92,106.43 90.86,106.6 90.86,106.74 91.06,106.94 91.06,107.62 91.1,107.66
  BOTTOM w0.127: 56.74,108.64 v2(56.65,108.74) ; 56.74,108.64 55.72,107.62 49.79,107.62 48.17,109.24 48.17,109.81 47.89,110.1 47.89,110.5 47.76,110.63 47.52,110.63 v1(47.34,110.55) ; 56.74,108.64 61.64,113.54 70.98,113.54 73.19,111.33 88.38,111.33 90.87,108.84 90.87,108.08 91.1,107.85 91.1,107.66
DP2_DDI_TX_P1: length 54.6
  TOP w0.127: C5801.1 50.07,110.92 50.07,110.7 49.83,110.47 v1(48.83,110.47)
  BOTTOM w0.076: CPU1.AC2 91.48,106.67 91.48,108.55 91.54,108.61 91.54,109.07 91.57,109.1 91.57,109.12
  BOTTOM w0.127: 63.43,114.27 60.95,114.27 54.95,108.27 50.8,108.27 50.3,108.77 50.3,109.92 49.75,110.47 v1(48.83,110.47) ; 63.43,114.27 71.24,114.27 73.53,111.98 89.31,111.98 91.57,109.72 91.57,109.12 ; 63.43,114.27 v2(63.43,114.44)
DP2_DDI_TX_P2: length 58.8
  TOP w0.127: v1(50.83,110.39) 51.18,110.75 51.9,110.75 52.17,111.02 C5805.1
  BOTTOM w0.076: CPU1.AE3 92.27,105.54 92.47,105.74 92.47,105.74 92.52,105.85 92.53,105.86 92.53,106.07 92.5,106.15 92.5,106.43 92.53,106.51 92.53,106.79 92.36,106.96 92.36,107.64 92.48,107.76 92.48,107.76 92.55,107.83 92.55,107.87
  BOTTOM w0.127: v1(50.83,110.39) 51.39,109.83 51.9,109.83 52.07,110.01 52.07,110.24 52.96,111.13 55.3,111.13 ; 55.3,111.13 v2(55.3,111) ; 55.3,111.13 55.93,111.13 57.59,112.79 57.59,114.2 58.13,114.75 58.13,116.68 58.65,117.2 62.12,117.2 62.58,116.74 72.22,116.74 75.28,113.68 90.74,113.68 93.4,111.02 93.4,108.72 92.55,107.87
DP2_DDI_TX_P3: length 53.5
  TOP w0.127: C5807.1 53.7,111.2 53.02,110.53 v1(53.02,110.49)
  BOTTOM w0.076: 92.33,108.31 92.32,108.29 92.32,108.25 92.02,107.94 92.02,106.5 CPU1.AE2
  BOTTOM w0.127: 54.33,109.66 53.71,109.66 53.02,110.36 v1(53.02,110.49) ; 54.33,109.66 55.62,109.66 58.88,112.92 58.88,116.2 59.13,116.45 61.85,116.45 62.33,115.97 72.04,115.97 74.98,113.03 90.3,113.03 92.75,110.58 92.75,108.72 92.33,108.31 ; 54.33,109.66 v2(54.33,109.5)
DP2_DDI_TX_R_N0: length 1.3
  TOP w0.127: C5804.2 47.04,112.38 47.04,112.76 47.23,112.96 R5859.1
DP2_DDI_TX_R_N0_R: length 3.1
  TOP w0.127: R5859.2 48.31,113.07 48.48,113.23 48.76,113.23 49.22,113.7 49.22,114.8 49.3,114.88 U5802.7
DP2_DDI_TX_R_N1: length 0.7
  TOP w0.127: C5802.2 50.57,112.1 R5861.1
DP2_DDI_TX_R_N1_R: length 2
  TOP w0.127: U5802.10 50.5,114.88 50.44,114.82 50.44,114.37 50.32,114.26 50.32,113.94 R5861.2
DP2_DDI_TX_R_P0: length 2.1
  TOP w0.127: R5854.1 47.36,113.72 47.03,113.39 47.03,113.09 46.8,112.86 46.8,112.31 C5803.2
DP2_DDI_TX_R_P0_R: length 2.7
  TOP w0.127: R5854.2 48.31,113.64 48.48,113.47 48.66,113.47 48.98,113.8 48.98,114.8 48.9,114.88 U5802.6
DP2_DDI_TX_R_P1: length 0.7
  TOP w0.127: R5860.1 49.81,112.1 C5801.2
DP2_DDI_TX_R_P1_R: length 2
  TOP w0.127: U5802.9 50.1,114.88 50.2,114.78 50.2,114.47 50.08,114.36 50.08,113.96 R5860.2
DP2_DDI_TX_RE_C_N0: length 1.7
  TOP w0.127: R7178.2 25.22,103.57 24.76,103.57 24.33,103.99 U7101.10
DP2_DDI_TX_RE_C_N1: length 1.6
  TOP w0.127: U7101.13 24.3,105.19 24.37,105.12 25.2,105.12 R7180.2
DP2_DDI_TX_RE_C_N2: length 1.7
  TOP w0.127: U7101.16 24.41,106.39 24.45,106.35 24.82,106.35 24.98,106.51 25.01,106.51 R7182.2
DP2_DDI_TX_RE_C_N3: length 1.5
  TOP w0.127: R7184.2 25.07,108.44 24.22,107.59 U7101.19
DP2_DDI_TX_RE_C_P0: length 1.7
  TOP w0.127: U7101.9 24.39,103.59 24.66,103.33 25.04,103.33 R7177.2
DP2_DDI_TX_RE_C_P1: length 1.6
  TOP w0.127: U7101.12 24.4,104.79 24.49,104.88 25.04,104.88 R7179.2
DP2_DDI_TX_RE_C_P2: length 1.6
  TOP w0.127: U7101.15 24.23,105.99 24.35,106.11 24.92,106.11 25.08,106.26 25.26,106.26 R7181.2
DP2_DDI_TX_RE_C_P3: length 1.3
  TOP w0.127: R7183.2 24.74,107.67 24.26,107.19 U7101.18
DP2_DEMUX_OUT2_D0N: length 2.8
  TOP w0.127: U5802.39 51.3,120.66 51.18,120.78 51.18,121.38 51.73,121.92 51.73,122.34 R5841.2
DP2_DEMUX_OUT2_D0N_R: length 17.4
  TOP w0.127: R5826.2 52.08,124.02 v1(52.08,124.14) ; v1(48.14,111.86) 48.19,111.81 R5832.1
  L3 w0.114: v1(48.14,111.86) 48.06,111.94 47.5,111.94 47.02,112.42 47.02,113.56 46.71,113.86 46.71,115.75 50.5,119.54 50.5,121.88 51.31,122.69 51.31,123.88 51.57,124.14 v1(52.08,124.14)
DP2_DEMUX_OUT2_D0P: length 2.8
  TOP w0.127: U5802.40 50.9,120.7 50.94,120.75 50.94,121.48 51.49,122.02 51.49,122.24 R5840.2
DP2_DEMUX_OUT2_D0P_R: length 17.2
  TOP w0.127: R5827.2 50.64,123.64 v1(50.64,124.18) ; 45.72,111.23 45.72,112.32 v1(45.72,112.32)
  L3 w0.114: v1(45.72,112.32) 46.51,112.32 46.79,112.6 46.79,113.46 46.48,113.77 46.48,115.85 50.27,119.64 50.27,121.97 51.08,122.78 51.08,124.05 50.96,124.18 v1(50.64,124.18)
DP2_DEMUX_OUT2_D1N: length 3.8
  TOP w0.127: R5843.2 53.94,122.38 53.49,122.38 53.18,122.06 52.73,122.06 52.44,121.77 52.44,120.74 52.5,120.68 U5802.36
DP2_DEMUX_OUT2_D1N_R: length 16.7
  TOP w0.127: R5839.1 51.41,111.71 v1(51.21,111.91) ; v1(52.94,121.6) 53.6,121.6 53.95,121.25 R5829.2
  L3 w0.114: v1(52.94,121.6) 53.35,121.6 53.49,121.74 53.49,121.92 53.37,122.05 52.68,122.05 52.67,122.04 52.63,122.04 52.37,121.78 52.37,120.58 52.53,120.42 52.53,117.44 50.4,115.31 50.4,112.07 50.55,111.91 v1(51.21,111.91)
DP2_DEMUX_OUT2_D1P: length 4.3
  TOP w0.127: 52.2,121.62 52.2,120.75 52.1,120.65 52.1,120.39 U5802.37 ; 52.2,121.62 52.2,121.87 52.63,122.3 53.08,122.3 53.39,122.62 53.99,122.62 R5842.2 ; 52.2,121.62 v2(52.05,121.62)
DP2_DEMUX_OUT2_D1P_R: length 16.3
  TOP w0.127: R5838.1 48.97,111.74 v1(49.13,111.89) ; v1(52.79,122.75) 52.92,122.75 53.65,123.47 v2(53.65,123.63) 55.01,123.63 R5828.2
  L3 w0.114: v1(49.13,111.89) 49.61,111.89 50.17,112.45 50.17,115.4 52.3,117.54 52.3,120.33 52.14,120.49 52.14,121.88 52.53,122.27 52.57,122.27 52.78,122.48 52.78,122.74 v1(52.79,122.75)
DP2_HPD_CPU: length 200.2
  TOP w0.089: v1(156.82,120.5) 156.39,120.93 149.36,120.93 v1(148.8,120.37) ; U5802.3 47.7,114.85 47.19,114.34 v1(47.18,114.34) ; v1(162.49,141.38) 162.49,139.74 v1(161.46,138.71)
  L3 w0.089: v1(161.46,138.71) 156.82,134.07 v1(156.82,120.5) ; v1(47.18,114.34) 47.18,114.48 48.62,115.92 48.62,117.14 49.95,118.47 50.93,118.47 51.34,118.88 51.34,120.04 50.87,120.51 50.87,121.72 51.68,122.54 51.68,122.75 52.8,123.87 60.8,123.87 62.72,125.79 62.72,128.06 62.19,128.59 62.19,134.23 65.09,137.13 69.31,137.13 70.33,136.1 71.03,136.1 72.98,138.06 72.98,143.5 79.16,149.67 98.59,149.67 99.31,148.95 103.23,148.95 104.94,150.67 119.19,150.67 122.26,147.59 138.29,147.59 139.83,146.05 140.29,146.05 141.48,147.24 151,147.24 153.07,145.18 160.46,145.18 161.7,143.94 161.7,142.36 162.04,142.02 162.04,142.02 162.49,141.56 v1(162.49,141.38)
  BOTTOM w0.089: Q401.5 137.77,113.93 137.6,114.1 R404.2 137.38,114.53 138.43,115.58 v2(138.43,115.88) 138.43,116.23 138.03,116.63 138.03,118.06 139.01,119.03 143.31,119.03 144.65,120.37 v1(148.8,120.37)
DPEQ0_A1: length 3.7
  TOP w0.102: v1(24.77,105.63) 24.65,105.63 24.62,105.59 U7101.14
  BOTTOM w0.102: R7171.2 25.19,103.83 25.19,105.2 v1(24.77,105.63) 24.4,105.26 R7172.1
DPEQ1: length 4.9
  TOP w0.102: v1(19.92,101.73) 19.82,101.63 R7147.2 19.95,101.12 20.43,101.6 20.43,101.88 21,102.45 U7101.2
  BOTTOM w0.102: R7170.1 20.61,102.22 20.61,101.99 v2(20.48,101.86) 20.35,101.73 v1(19.92,101.73)
EC_D_INHIB: length 56.5
  TOP w0.102: R6404.1 38.97,75.18 U2401.96 38.31,72.49 37.45,71.64 36.32,71.64 35.32,70.64 35.32,69.61 36.58,68.36 36.58,66.75 36.45,66.63 35.88,66.63 35.51,66.25 35.51,64.8 v1(35.41,64.7)
  L3 w0.102: v1(35.41,64.7) 33.65,64.7 32.17,63.22 32.17,60.57 28.96,57.36 28.96,54.73 28.86,54.62 28.86,54.61 28.47,54.23 27.81,54.23 25.83,52.26 25.83,50.22 v1(25.36,49.75)
  BOTTOM w0.102: Q6408.B 24.18,54.14 25.4,55.37 25.4,57.94 R6414.1 C6405.1 ; Q6408.B 23.42,51.82 22.7,52.54 20.97,52.54 20.21,51.78 18.24,51.78 17.51,51.05 17.51,50.55 17.05,50.09 D6403.A ; Q6408.B 24.67,51.33 v2(24.67,50.57) 24.67,50.44 v1(25.36,49.75)
EDP_AUX_CON_N: length 3.7
  BOTTOM w0.127: C5521.2 216.03,54.95 216.04,54.95 216.78,54.95 217.88,56.05 LCD1.3
EDP_AUX_CON_P: length 4
  BOTTOM w0.127: C5526.2 216.14,55.2 216.68,55.2 217.78,56.29 218.11,56.29 218.37,56.55 LCD1.2
EDP_AUX_CPU_N: length 181.2
  TOP w0.127: FC5501.1 214.35,55.02 v1(214.17,54.84)
  L3 w0.114: v1(214.17,54.84) 214.2,54.84 214.4,55.04 216.74,55.04 217.07,55.37 217.07,55.37 217.2,55.5 217.2,61.38 216.76,61.82 211.88,61.82 211.34,61.29 209.39,61.29 209.29,61.39 205.19,61.39 205.19,61.39 205.02,61.39 204.04,62.37 191.4,62.37 188.57,59.55 182.14,59.55 181.63,60.06 179.27,60.06 169.57,69.75 169.57,71.62 159.03,82.17 159.03,82.27 159.03,85.65 137.24,107.45 137.24,112.92 135.46,114.71 124.41,114.71 122.25,116.86 122.25,119.48 120.29,121.44 v1(117.55,121.44)
  BOTTOM w0.076: 94.56,107.29 94.5,107.24 94.5,107.19 94.21,106.9 94.21,106.2 93.88,105.87 93.88,105.58 93.9,105.49 CPU1.AH4
  BOTTOM w0.127: 100.73,113.87 100.73,118.89 102.61,120.77 104.17,120.77 105.24,121.83 108.41,121.83 112.8,121.83 113.29,121.35 117.45,121.35 v1(117.55,121.44) ; 100.73,113.87 v2(100.56,113.87) ; 100.73,113.87 100.73,113.47 99.73,112.47 99.13,112.47 96.14,109.49 96.14,108.88 94.56,107.29 ; v1(214.17,54.84) C5521.1
EDP_AUX_CPU_P: length 180.9
  TOP w0.127: FC5502.1 214.3,55.78 214.18,55.65 v1(214.18,55.47)
  L3 w0.114: v1(117.53,120.81) 117.78,120.55 117.96,120.55 118.05,120.64 118.05,121.12 118.14,121.21 120.19,121.21 122.02,119.38 122.02,116.77 124.32,114.48 135.36,114.48 137.01,112.83 137.01,107.35 158.8,85.56 158.8,82.37 158.8,82.07 169.34,71.53 169.34,69.66 179.17,59.83 181.54,59.83 182.05,59.32 188.67,59.32 191.49,62.14 203.95,62.14 204.93,61.16 205.09,61.16 205.09,61.16 209.2,61.16 209.29,61.06 211.44,61.06 211.97,61.6 216.67,61.6 216.98,61.29 216.98,55.6 216.65,55.27 214.84,55.27 214.71,55.4 214.71,55.7 214.58,55.83 214.3,55.83 214.18,55.7 v1(214.18,55.47)
  BOTTOM w0.076: 94.68,107.08 94.64,107.08 94.38,106.83 94.38,106.08 94.15,105.85 CPU1.AH3
  BOTTOM w0.127: v1(214.18,55.47) 214.29,55.59 214.36,55.6 214.47,55.71 C5526.1 ; 100.19,112.59 100.97,113.37 100.97,118.79 102.71,120.52 104.27,120.52 105.34,121.59 108.41,121.59 112.7,121.59 113.19,121.11 117.05,121.11 117.16,121 117.16,120.88 117.24,120.81 v1(117.53,120.81) ; 100.19,112.59 99.83,112.23 99.23,112.23 96.38,109.39 96.38,108.78 94.68,107.08 ; 100.19,112.59 v2(100.31,112.47)
EDP_DISP_UTIL: length 2.7
  TOP w0.102: TP401.1 95.74,101.8 96.27,101.8 96.6,102.13 96.6,102.47 96.98,102.85 v1(97.01,102.85)
  BOTTOM w0.102: v1(97.01,102.85) 97.01,102.84 CPU1.AM7
EDP_FHD_DET#: length 173.5
  TOP w0.102: R5565.2 R2068.2 225.05,42.43 225.05,43.26 225.33,43.54 225.33,46.15 225.15,46.33 225.15,50.4 223.37,52.17 v1(220.22,52.17) ; v1(167.06,36.98) 167.08,37.01 v2(167.64,37.01)
  L2SGND w0.102: v1(166.96,56.31) 167.42,56.31 173.18,50.55 175.3,50.55 176.05,49.8 176.05,42 174.64,40.59 170.64,40.59 167.06,37.01 v1(167.06,36.98)
  L3 w0.102: v1(167.06,36.98) 167.44,36.98 168.32,37.86 170.55,37.86 171.35,37.06 182.2,37.06 183.41,35.84 186.21,35.84 189.58,39.21 192.98,39.21 193.21,38.98 196.44,38.98 196.63,38.78 200.57,38.78 200.72,38.93 200.73,38.93 200.75,38.95 207.13,38.95 207.5,39.32 212.64,39.32 215.83,42.51 216.75,42.51 218.44,44.2 218.44,47.6 218.44,50.9 219.71,52.17 v1(220.22,52.17) ; v1(166.96,56.31) 166.52,56.31 165.92,56.92 165.92,57.84 165.15,58.6 164.57,58.6 158.83,64.34 158.83,64.73 158.22,65.34 158.22,66.04 147.98,76.28 141.76,76.28 141.05,76.99 141.05,78.21 140.11,79.15 139.92,79.15 138.35,80.71 138.35,80.85 138.2,81 133.61,81 133.51,81.1 127.79,81.1 125.25,83.64 124.42,83.64 123.98,84.08 121.26,84.08 120.92,83.73 v1(120.92,83.24)
  BOTTOM w0.102: v1(120.92,83.24) 120.87,83.24 120.27,83.84 CPU1.CL36
EDP_FHD_DET#_R: length 15.4
  TOP w0.102: v1(219.81,52.68) 219.84,52.71 223.42,52.71 225.48,50.65 225.48,46.41 225.71,46.18 225.71,43.38 225.5,43.18 R5565.1
  BOTTOM w0.102: LCD1.10 219.68,52.55 v1(219.81,52.68)
EDP_HPD: length 182.8
  TOP w0.089: v1(217.02,34.88) 217.45,34.45 217.9,34.45
  TOP w0.102: 217.9,34.45 218.28,34.82 221.21,34.82 221.77,35.38 RN5502.1 222.37,35.66 222.51,35.8 RN5503.4 ; v1(158.86,32.96) v2(158.25,32.96)
  L3 w0.102: v1(158.86,32.96) 159.12,33.22 169.73,33.22 170.55,34.04 175.47,34.04 176.63,32.88 187.28,32.88 187.82,33.43 203.22,33.43 203.45,33.66 204.7,33.66 205.39,34.34 206.85,34.34 209.62,37.11 212.85,37.11 213.74,36.22 215.08,36.22 215.16,36.3 215.85,36.3 217.02,35.13 v1(217.02,34.88)
  L4 w0.102: v1(158.86,32.96) 160.25,34.35 161.76,34.35 161.77,34.34 162.25,34.34 162.64,34.73 167.49,34.73 167.71,34.51 170.3,34.51 173.44,37.64 173.7,38.38 173.72,38.42 174.88,41.66 174.88,45.11 175.87,46.1 175.87,50.08 165.62,60.33 165.62,60.9 158.81,67.71 158.81,68.52 156.67,70.66 156.67,72.31 152.94,76.04 152.58,76.04 150.64,77.98 150.64,79.46 150.05,80.04 150.05,83.67 145.57,88.15 145.39,88.15 145.02,88.53 145.01,88.53 144.65,88.88 144.48,88.88 140.24,93.12 140.24,93.76 137.06,96.95 137.06,98.42 133.36,102.11 132.01,102.11 130.64,103.48 125.05,103.48 v1(124.42,102.86)
  BOTTOM w0.076: v1(124.42,102.86) 124.23,103.05 122.56,103.05 122.36,103.12 122.12,103.12 122.06,103.1 121.78,103.1 121.71,103.12 121.47,103.12 121.39,103.09 121.32,103.09 121.28,103.06 CPU1.CM7
EDP_HPD_CONN: length 9.3
  TOP w0.102: RN5503.5 223.73,35.8 223.6,35.93 223.6,37.81 223.33,38.08 222.48,38.08 222.01,38.55 221.04,38.55 AFTP5521.1 220.44,39.24 219.74,39.24 219.72,39.27 v1(219.71,39.27)
  BOTTOM w0.102: v1(219.71,39.27) 219.71,39.27 219.63,39.27 219.5,39.4 219.5,40.78 219.4,40.88 219.23,41.05 LCD1.33
EDP_RCOMP_CPU: length 15.1
  TOP w0.127: R401.2 93.02,91.97 v1(92.99,91.95) v2(93.33,91.47)
  L4 w0.127: v1(92.99,91.95) 92.99,92.3 93.42,92.72 93.42,96.11 95.68,98.37 95.68,99.6 96.12,100.04 96.12,101.64 96.6,102.13 96.6,102.66 96.59,102.67 96.59,103.14 96.98,103.53 v1(96.99,103.53)
  BOTTOM w0.127: CPU1.AM6 96.72,103.27 96.98,103.53 v1(96.99,103.53)
EDP_TX_CON_N0: length 3.8
  BOTTOM w0.127: C5525.2 215.85,53.65 216.71,53.65 217.74,54.68 218.15,54.68 218.28,54.55 LCD1.6
EDP_TX_CON_N1: length 3.8
  BOTTOM w0.127: C5523.2 215.8,52.07 216.67,52.07 217.78,53.18 218.15,53.18 218.28,53.05 LCD1.9
EDP_TX_CON_P0: length 3.9
  BOTTOM w0.127: LCD1.5 218.28,55.05 218.15,54.92 217.64,54.92 216.61,53.89 215.92,53.89 C5524.2
EDP_TX_CON_P1: length 3.9
  BOTTOM w0.127: C5522.2 215.97,52.32 216.57,52.32 217.68,53.42 218.15,53.42 218.28,53.55 LCD1.8
EDP_TX_CPU_N0: length 186
  TOP w0.127: FC5503.1 214.23,53.49 v1(214.17,53.43)
  L3 w0.114: v1(115.78,123.14) 115.96,122.96 116.61,122.96 117.44,122.12 120.95,122.12 122.96,120.11 122.96,117.01 124.66,115.32 135.72,115.32 137.93,113.11 137.93,107.66 159.72,85.87 159.72,82.56 159.72,82.34 170.18,71.88 170.18,70.01 176.55,63.64 180.63,63.64 183.57,60.71 188.87,60.71 191.14,62.98 204.29,62.98 205.28,62 205.44,62 205.44,62 209.54,62 209.64,61.9 210.89,61.9 211.48,62.49 216.99,62.49 217.83,61.65 217.83,55.1 216.17,53.43 v1(214.17,53.43)
  BOTTOM w0.076: 93.76,108.2 93.75,108.18 93.75,108.14 93.42,107.82 93.42,107.16 93.16,106.89 93.16,106.48 93.17,106.45 93.18,106.4 93.18,106.18 93.16,106.1 93.16,105.8 93.17,105.79 93.31,105.47 93.31,105.23 93.41,104.99 CPU1.AG4
  BOTTOM w0.127: 96.9,112.47 99.02,114.59 99.02,114.62 99.19,114.78 99.19,119.55 101.71,122.06 103.64,122.06 103.87,122.29 104.7,123.13 109.04,123.13 113.5,123.13 113.68,122.95 115.59,122.95 v1(115.78,123.14) ; 96.9,112.47 94.62,110.18 94.62,109.6 94.17,109.16 94.17,108.61 93.76,108.2 ; 96.9,112.47 v2(96.79,112.58) ; C5525.1 214.2,53.42 214.19,53.43 v1(214.17,53.43)
EDP_TX_CPU_N1: length 188.8
  TOP w0.127: FC5505.1 214.31,51.97 v1(214.14,51.8)
  L3 w0.114: v1(117.86,122.99) 118.28,122.73 122.79,122.73 123.47,123.42 125.09,123.42 125.68,122.83 125.68,120.59 126.31,119.97 126.31,116.69 127.05,115.95 136.77,115.95 139.11,113.61 139.11,109.39 141.77,106.73 141.77,104.78 160.4,86.14 160.4,82.77 170.79,72.38 170.79,70.26 176.72,64.33 180.81,64.33 183.82,61.32 188.6,61.32 190.87,63.59 204.55,63.59 205.49,62.65 208.98,62.65 209.48,63.15 217.2,63.15 218.44,61.9 218.44,61.89 218.44,54.57 215.68,51.8 v1(214.14,51.8)
  BOTTOM w0.076: 94.48,107.78 94.47,107.77 94.43,107.77 93.99,107.33 93.99,106.92 93.84,106.47 93.69,106.31 CPU1.AG2
  BOTTOM w0.127: v1(117.86,122.99) 117.86,122.4 117.25,121.79 113.51,121.79 113.06,122.24 108.68,122.24 105.07,122.24 104.76,121.92 104,121.17 102.24,121.17 100.19,119.13 100.19,114.3 98.93,113.04 ; v2(99.02,112.95) 98.93,113.04 ; 98.93,113.04 95.68,109.79 95.68,109.24 95.32,108.88 95.32,108.61 94.48,107.78 ; C5523.1 214.23,51.9 v1(214.14,51.8)
EDP_TX_CPU_P0: length 185.9
  TOP w0.127: FC5504.1 214.33,54.26 v1(214.16,54.09)
  L3 w0.114: v1(214.16,54.09) 214.16,54.18 214.45,54.46 214.51,54.46 214.65,54.33 214.65,53.88 214.86,53.66 216.07,53.66 217.6,55.2 217.6,61.55 216.9,62.26 211.57,62.26 210.99,61.67 209.55,61.67 209.45,61.77 205.35,61.77 205.35,61.77 205.18,61.77 204.2,62.75 191.23,62.75 188.96,60.48 183.47,60.48 180.54,63.41 176.45,63.41 169.95,69.91 169.95,71.78 159.49,82.25 159.49,82.65 159.49,85.77 137.7,107.57 137.7,113.01 135.62,115.09 124.57,115.09 122.74,116.92 122.74,120.01 120.85,121.9 117.34,121.9 116.51,122.73 116.3,122.73 116.22,122.65 116.22,122.22 116.09,122.09 115.84,122.09 115.76,122.17 v1(115.76,122.5)
  BOTTOM w0.076: CPU1.AG3 93.57,105.32 93.33,105.86 93.33,106.07 93.36,106.15 93.36,106.43 93.33,106.51 93.33,106.82 93.6,107.09 93.6,107.74 93.87,108.01 93.92,108.01 93.93,108.03
  BOTTOM w0.127: C5524.1 214.26,54.18 v1(214.16,54.09) ; 114.69,122.71 113.58,122.71 113.4,122.89 109.04,122.89 108.94,122.89 104.8,122.89 104.11,122.19 103.74,121.82 101.81,121.82 99.43,119.45 99.43,114.68 99.27,114.52 99.27,114.49 94.86,110.08 94.86,109.5 94.41,109.06 94.41,108.51 93.93,108.03 ; 114.69,122.71 v2(114.69,122.55) ; 114.69,122.71 115.55,122.71 v1(115.76,122.5)
EDP_TX_CPU_P1: length 188.7
  TOP w0.127: FC5506.1 214.32,52.73 v1(214.17,52.58)
  L3 w0.114: v1(117.22,122.98) 117.34,122.77 117.6,122.51 122.88,122.51 123.57,123.19 124.99,123.19 125.45,122.73 125.45,120.5 126.08,119.87 126.08,116.59 126.96,115.72 136.68,115.72 138.88,113.51 138.88,109.3 141.54,106.64 141.54,104.69 160.18,86.05 160.18,82.67 170.56,72.28 170.56,70.17 176.63,64.1 180.72,64.1 183.72,61.09 188.7,61.09 190.97,63.36 204.45,63.36 205.39,62.42 209.08,62.42 209.57,62.92 217.1,62.92 218.21,61.81 218.21,61.8 218.21,54.66 215.59,52.03 214.72,52.03 214.59,52.16 214.59,52.57 214.48,52.68 214.27,52.68 v1(214.17,52.58)
  BOTTOM w0.076: CPU1.AG1 93.82,106.97 93.82,107.41 94.3,107.89 94.3,107.94 94.31,107.95
  BOTTOM w0.127: 94.31,107.95 95.08,108.71 95.08,108.98 95.44,109.34 95.44,109.89 96.45,110.9 ; 96.45,110.9 v2(96.35,111) ; 96.45,110.9 99.95,114.4 99.95,119.23 102.14,121.41 103.9,121.41 104.52,122.02 104.97,122.48 108.78,122.48 113.16,122.48 113.61,122.04 117.15,122.04 117.61,122.5 117.61,122.58 v1(117.22,122.98) ; v1(214.17,52.58) 214.25,52.66 C5522.1
