# Allegro board 17938-1.1228WZS1107.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
20V_VCCPD_VBUS on L3: 7.17,126.09 6.66,126.09 6.43,125.86 6.43,124.82 6.72,124.54 7.7,124.54 8.28,125.12 9.55,125.12 10.68,123.99 13.58,123.99 14.99,125.4 16.01,125.4 17.4,124 26.67,124 28.07,125.4 28.07,127.31 27.56,127.81 22.86,127.81 20.98,129.69 13.8,129.69 12.75,128.65 9.73,128.65
20V_VCCPD_VBUS on L4: 7.17,126.09 6.66,126.09 6.38,125.81 6.38,124.87 6.71,124.54 7.37,124.54 8.09,125.26 9.54,125.26 12.32,122.48 12.83,122.48 14.1,123.75 14.1,124.51 14.99,125.4 16.01,125.4 17.4,124 26.67,124 28.07,125.4 28.07,127.31 27.56,127.81 22.86,127.81 20.98,129.69 13.8,129.69 12.75,128.65 9.73,128.65
+3V_1D8V_DVDD on TOP: 28.65,15.83 28.63,15.85 28.63,16.46 28.81,16.64 29.21,16.64 29.34,16.77 29.34,18.11 28.45,19 28.45,20.17 28.22,20.4 27.51,20.4 27.38,20.52 27.06,20.52 26.65,20.93 26.65,21.11 26.83,21.29 28.37,21.29 28.58,21.49 28.58,22.15 28.65,22.23 29.31,22.23 29.42,22.12 29.42,19.08 29.82,18.67 30,18.67 30.1,18.57 30.1,17.43 30.53,16.99 30.53,16.51 30.41,16.38 30.13,16.38 29.57,15.83 ; 2 cut-outs
+3VALW_EC on TOP: 57.92,27.66 57.69,27.89 57.69,28.93 57.94,29.19 76.18,29.19 76.38,29.39 76.38,29.92 75.97,30.33 75.97,34.44 75.21,35.21 75.21,36.4 75.29,36.48 75.61,36.48 76.95,35.13 76.95,30.87 77.27,30.56 77.27,28.7 76.23,27.66 ; 2 cut-outs
+3VALW_EC on TOP: 34.29,110.42 34.04,110.67 34.04,113.72 33.66,114.1 33.66,114.61 33.79,114.73 34.93,114.73 35.06,114.61 35.06,114.1 34.67,113.72 34.67,110.54 34.55,110.42
+5V_PVDD on TOP: 30.61,12.5 30.2,12.9 30.2,13.08 30.23,13.11 30.33,13.11 30.64,12.8 31.7,12.8 31.88,12.98 31.88,13.64 31.93,13.69 34.78,13.69 35.03,13.95 35.03,15.83 34.88,15.98 33.25,15.98 32.74,15.47 31.75,15.47 31.6,15.62 30.53,15.62 30.43,15.72 30.43,15.98 30.56,16.1 31.47,16.1 31.58,16.21 32.18,16.21 33.05,17.07 33.05,17.81 32.6,18.26 32.6,19.42 32.67,19.49 35.65,19.49 35.74,19.4 35.74,13.49 35.11,12.85 32.49,12.85 32.13,12.5 ; 4 cut-outs
GND on TOP: 50.1,126.61 49.91,126.8 49.91,129.97 49.66,130.23 48.39,130.23 48.26,130.35 48.26,130.99 48.39,131.12 51.44,131.12 52.07,130.48 52.07,129.59 51.82,129.34 51.18,129.34 51.06,129.21 51.06,127.81 51.21,127.66 53.39,127.66 53.48,127.57 53.48,127.04 53.43,126.99 51.48,126.99 51.1,126.62 51.05,126.62 51.05,126.61 ; 2 cut-outs
GND on TOP: 20.18,4.13 19.92,4.4 18.42,4.4 18.37,4.45 18.37,4.8 18.42,4.85 19.71,4.85 19.76,4.8 20.75,4.8 20.86,4.7 20.86,4.28 20.7,4.13
GND on TOP: 103.23,92.84 103.05,93.02 103.05,99.75 103.08,99.77 104.8,99.77 104.96,99.62 104.96,99.24 105.67,98.53 105.67,92.97 105.54,92.84 ; 10 cut-outs
GND on TOP: 109.63,119.69 109.5,119.81 109.5,120.3 109.58,120.37 109.58,124.03 109.68,124.13 110.11,124.13 110.34,123.9 110.34,120.55 109.93,120.14 109.93,119.79 109.83,119.69
GND on TOP: 38.56,104.24 38,104.8 37.57,104.8 37.47,104.9 37.47,108.51 37.85,108.89 39.04,108.89 39.17,109.02 39.17,111.81 39.2,111.84 41.99,111.84 41.99,109.02 41.96,108.99 39.68,108.99 39.5,108.81 39.5,108.26 39.37,108.13 38.61,108.13 38.36,107.88 38.36,105.61 38.92,105.06 40.6,105.06 40.96,104.69 41.48,104.69 41.6,104.82 41.6,106.28 41.86,106.54 41.86,106.97 41.96,107.06 42.55,107.06 42.88,106.73 42.88,105.23 41.89,104.24 ; 9 cut-outs
GND on TOP: 92.71,39.27 91.27,40.72 91.27,42.01 91.85,42.6 93.25,42.6 93.32,42.52 93.32,39.4 93.2,39.27 ; 4 cut-outs
GND on TOP: 18.6,111.23 16.52,113.3 16.52,117.65 18.14,119.27 18.14,123.46 18.21,123.54 18.75,123.54 19.1,123.19 19.61,123.19 19.84,123.42 19.84,124.23 19.94,124.32 20.47,124.32 20.73,124.05 20.73,122.73 20.74,122.72 20.74,121.03 21.57,120.2 21.57,120.19 24.08,120.19 24.23,120.04 24.23,118.09 25.05,117.27 25.05,113.23 23.04,111.23 ; 1 cut-out
GND on TOP: 73.79,34.14 73.64,34.29 73.64,34.67 73.03,35.28 73.03,35.36 73.56,35.89 74.88,35.89 75.09,35.69 75.09,34.57 74.65,34.14 ; 2 cut-outs
GND on TOP: 150.37,140.01 148.85,141.53 148.85,142.93 149.99,144.07 151.64,144.07 151.77,143.94 151.77,143.31 152.15,142.93 152.15,142.17 152.4,141.91 152.4,141.4 151.01,140.01 ; 4 cut-outs
GND on TOP: 123.98,127.1 123.88,127.2 123.88,129.79 123.44,130.23 123.44,135.73 122.86,136.32 121.29,136.32 120.91,136.7 120.91,137.59 121.78,138.46 124.77,138.46 124.86,138.36 124.86,137.47 125.08,137.26 125.81,137.26 126.24,136.82 126.24,127.64 125.71,127.1 ; 4 cut-outs
GND on TOP: 161.67,37.49 161.5,37.67 161.5,40.08 161.65,40.23 162.74,40.23 162.87,40.11 162.87,38.25 162.11,37.49 ; 3 cut-outs
GND on TOP: outline of 429 points within 0.53,22.24 226.39,152.49 ; 17 cut-outs
GND on TOP: 112.91,29.64 112.65,29.9 112.65,30.28 112.14,30.79 111.64,30.79 110.87,31.55 110.87,33.2 111.28,33.61 113.26,33.61 114.18,32.69 114.18,29.77 114.05,29.64 ; 3 cut-outs
GND on TOP: 96.85,92.79 96.75,92.89 96.75,99.57 96.83,99.65 99.34,99.65 99.44,99.54 99.44,93.02 99.22,92.79 ; 10 cut-outs
GND on TOP: outline of 104 points within 39.36,43.14 96.75,103.48 ; 62 cut-outs
GND on TOP: 140.36,81.61 140.13,81.84 140.13,82.55 140.29,82.7 140.44,82.7 140.47,82.73 140.78,82.73 140.78,82.73 141.56,82.73 141.72,82.56 141.72,81.62 141.71,81.61
GND on TOP: 44.68,106.15 44.58,106.25 44.58,108.13 44.96,108.51 44.96,108.89 45.22,109.15 46.23,109.15 46.74,109.65 47.76,109.65 47.88,109.53 48.14,109.53 48.43,109.23 48.43,108.29 48.39,108.26 46.23,108.26 46.1,108.13 46.1,107.62 45.98,107.49 45.47,107.49 45.34,107.37 45.34,106.99 45.16,106.81 45.16,106.2 45.11,106.15 ; 4 cut-outs
GND on TOP: 213.69,63.81 213.62,63.88 213.62,64.52 214.79,65.69 214.79,66.55 214.94,66.7 218.11,66.7 218.54,66.27 218.54,65.3 217.05,63.81 ; 1 cut-out
GND on TOP: 158.94,43.87 158.69,44.12 153.94,44.12 153.87,44.18 153.13,44.18 153.13,48.63 152.88,48.88 152.88,49.88 151.19,51.56 151.19,52.34 140.41,63.12 108.28,63.12 97.69,73.71 97.69,75.82 97.64,75.87 97.64,77.01 97.21,77.45 97.21,79.78 97.29,79.86 97.46,79.86 97.64,80.04 97.64,81.34 97.3,81.67 97.16,81.67 94.39,84.45 94.39,87.66 94.57,87.83 94.57,90.17 94.41,90.32 94.41,90.65 94.49,90.73 95.76,90.73 95.94,90.91 95.94,91.06 96.09,91.21 96.7,91.21 96.83,91.09 96.83,90.22 96.95,90.1 98.15,90.1 98.63,89.61 102.75,89.61 102.87,89.74 102.87,91.31 103,91.44 105.03,91.44 105.26,91.67 105.26,91.89 105.49,92.12 105.83,92.12 105.96,91.99 105.96,91.77 105.82,91.63 105.73,91.63 105.41,91.31 105.41,90.03 105.79,89.65 107.01,89.65 107.32,89.34 107.32,86.08 109.68,83.72 109.68,82.68 109.99,82.37 109.99,79.6 113.85,75.74 147.83,75.74 169.78,53.79 169.78,52.66 172.57,49.87 172.57,44.5 172.25,44.19 170.99,44.19 170.67,43.87 ; 38 cut-outs
GND on TOP: 98.35,141.73 98.25,141.83 98.25,141.91 97.21,142.95 97.21,143.82 97.31,143.92 97.56,143.92 97.77,143.71 99.49,143.71 99.49,143.08 99.11,142.7 99.11,141.83 99.01,141.73 ; 2 cut-outs
GND on TOP: 48.54,105.13 48.47,105.21 48.47,105.64 48.52,105.69 49.23,105.69 49.71,106.17 50.42,106.17 51.23,106.99 52.84,106.99 52.96,106.86 52.96,106.15 52.84,106.02 52.45,106.02 52.43,106 52.43,105.56 52.38,105.51 52.38,105.21 52.3,105.13 ; 6 cut-outs
GND on TOP: 86.95,91.8 86.79,91.95 86.79,92.69 86.92,92.81 91.24,92.81 91.47,93.04 91.47,96.11 91.24,96.34 84.33,96.34 83.9,95.91 83.09,95.91 82.98,96.01 82.98,96.75 83.24,97 83.24,98.93 83.39,99.09 87.61,99.09 87.79,98.91 87.79,98.4 87.99,98.2 91.21,98.2 91.42,97.99 91.42,97.41 91.65,97.18 92.76,97.18 93.17,96.77 93.17,92.81 93.32,92.66 93.32,91.95 93.17,91.8 ; 14 cut-outs
GND on TOP: 82.45,116.26 82.35,116.36 82.35,126.44 82.58,126.67 82.58,130.91 82.1,131.4 82.1,133.55 82.32,133.78 82.32,134.93 80.66,136.59 77.35,136.59 77.14,136.39 77.14,135.97 77.09,135.92 76.05,135.92 75.72,136.25 75.72,140.79 75.8,140.87 78.41,140.87 78.84,141.3 78.84,141.81 77.96,142.7 77.54,142.7 77.31,142.93 77.31,144.74 77.42,144.86 79.26,144.86 79.33,144.79 79.33,142.29 81.82,139.8 83.98,139.8 84.53,139.24 84.53,138.33 85.39,137.48 85.39,127.19 85.12,126.93 84.56,126.93 84.43,126.8 84.43,126.24 84.38,126.19 84.38,116.41 84.23,116.26 ; 22 cut-outs
GND on TOP: 179.86,44.28 179.75,44.4 179.75,47.05 180.23,47.53 181.51,47.53 181.89,47.15 181.89,44.41 181.76,44.28 ; 2 cut-outs
GND on TOP: 31.91,13.97 31.78,14.1 31.78,15.09 31.85,15.17 32.64,15.17 33.2,15.72 34.75,15.72 34.83,15.65 34.83,14.2 34.6,13.97 ; 2 cut-outs
GND on TOP: 189.36,45.77 189.11,46.03 189.11,46.92 190.38,48.19 191.01,48.19 191.29,47.91 191.29,47.47 191.34,47.42 194.44,47.42 194.69,47.17 194.69,46.28 194.19,45.77 ; 2 cut-outs
GND on TOP: outline of 186 points within 1.16,0.51 226.49,69.41 ; 18 cut-outs
GND on TOP: 138.74,42.57 138.64,42.67 138.64,42.93 138.79,43.08 142.93,43.08 143.16,43.31 143.16,43.92 143.87,44.63 144.48,44.63 145.04,44.07 145.44,44.07 145.7,44.32 147.15,44.32 147.17,44.3 147.17,43.75 147.13,43.71 145.71,43.71 145.67,43.76 144.88,43.76 144.63,44.01 144.03,44.01 143.79,43.77 143.79,43.38 142.98,42.57
GND on TOP: 133.19,34.05 132.97,34.27 132.97,37.24 133.58,37.85 137.67,37.85 137.75,37.77 137.75,37.42 137.65,37.31 135.74,37.31 135.59,37.47 134.9,37.47 134.75,37.31 134.75,34.34 134.46,34.05 ; 4 cut-outs
GND on TOP: 103.66,114.66 103.46,114.86 103.46,125.22 102.86,125.82 102.35,125.82 101.1,127.08 101.1,132.36 101.57,132.84 101.96,132.84 102.25,133.13 102.25,134.61 103.14,135.5 105.58,135.5 105.63,135.45 105.63,130.11 105.31,129.78 104.11,129.78 104.02,129.69 104.02,126.95 104.55,126.42 104.55,114.88 104.33,114.66 ; 8 cut-outs
GND on TOP: 108.28,92.91 107.62,93.57 107.62,99.04 108.59,100 108.59,100.2 108.72,100.33 109.02,100.33 109.27,100.08 109.27,99.87 109.91,99.24 109.91,99.04 109.81,98.93 109.15,98.93 108.82,98.6 108.82,93.78 109.2,93.4 109.2,92.97 109.15,92.91 ; 3 cut-outs
GND on TOP: 204.61,46.94 204.35,47.2 203.84,47.2 203.72,47.32 202.95,47.32 202.83,47.2 202.08,47.2 201.3,47.98 201.3,49.48 201.43,49.61 201.91,49.61 201.98,49.69 201.98,50.06 202.36,50.45 202.6,50.45 202.7,50.55 202.7,50.75 202.95,51.01 204.35,51.01 204.61,50.75 204.61,50.34 204.93,50.01 205.31,50.01 205.57,49.76 205.57,49.25 205.29,48.97 205.24,48.97 205.24,47.07 205.11,46.94 ; 8 cut-outs
GND on TOP: 220.09,35.46 219.66,35.89 219.66,37.01 220.22,37.58 221.15,37.58 221.16,37.56 221.16,35.59 221.03,35.46
GND on TOP: 16.64,21.92 15.57,22.99 15.57,25.6 15.95,25.99 16.82,25.99 16.89,25.91 16.89,23.14 17.1,22.94 18.06,22.94 18.24,22.76 18.24,22.02 18.14,21.92 ; 4 cut-outs
GND on TOP: 211.94,42.67 211.69,42.93 211.69,44.4 211.59,44.5 211.59,45.29 211.86,45.57 212.17,45.57 212.37,45.37 212.37,44.73 212.7,44.4 212.7,42.8 212.58,42.67 ; 2 cut-outs
GND on TOP: 91.32,133.15 91.19,133.28 91.19,135.76 91.01,135.94 87.13,135.94 86.49,136.58 86.49,137.47 87.63,138.61 88.14,138.61 88.78,139.24 89.56,139.24 89.78,139.03 89.78,138.75 90.58,137.95 93.7,137.95 93.73,137.97 96.02,137.97 96.65,138.61 102.24,138.61 102.49,138.36 102.49,136.2 102.11,135.82 95.13,135.82 94.75,136.2 94.75,136.7 94.62,136.83 93.98,136.83 93.83,136.68 93.83,136.17 93.63,135.97 92.93,135.97 92.79,135.83 92.79,133.28 92.66,133.15 ; 10 cut-outs
GND on TOP: 110.86,114.99 110.02,115.83 110.02,116.55 110.32,116.84 110.32,118.77 111.18,119.64 111.18,126.95 111.26,127.03 111.99,127.03 112.07,126.95 112.07,118.39 111.86,118.19 111.59,118.19 111.37,117.97 111.37,117.44 111.09,117.16 111.09,115.63 111.15,115.57 111.15,115.14 111,114.99 ; 6 cut-outs
GND on BOTTOM: 147.6,117.88 147.22,118.26 147.22,119.13 147.42,119.33 148.85,119.33 149.71,120.19 156.54,120.19 156.72,120.02 156.72,117.96 156.64,117.88 ; 1 cut-out
GND on BOTTOM: 81.92,30.91 81.33,31.5 77.98,31.5 77.4,32.08 77.4,35.89 77.47,35.97 77.83,35.97 77.85,35.94 77.85,34.72 79.45,33.13 91.95,33.13 92.08,32.99 92.08,32.58 92.38,32.28 94.7,32.28 94.87,32.11 94.87,31.5 94.73,31.36 92.27,31.36 91.82,30.91 ; 1 cut-out
GND on BOTTOM: 91.32,133.15 91.19,133.28 91.19,136.15 90.86,136.48 90.38,136.48 90.22,136.63 86.59,136.63 86.57,136.65 86.57,137.64 86.62,137.69 87.15,137.69 87.28,137.82 87.28,138.56 87.38,138.66 90.73,138.66 91.11,138.28 91.11,138.05 91.39,137.77 93.37,137.77 93.58,137.57 93.58,136.15 93.4,135.97 92.81,135.97 92.79,135.94 92.79,133.28 92.66,133.15 ; 4 cut-outs
GND on BOTTOM: 69.7,37.74 69.17,38.27 69.17,41.7 69.3,41.84 70.18,41.84 70.3,41.72 70.3,41.19 71.61,39.88 74.34,39.88 74.58,40.13 74.58,41.11 74.72,41.24 76.29,41.24 76.87,41.83 80.99,41.83 81.71,41.1 81.71,38.08 81.38,37.74 80.6,37.74 80.6,37.74 ; 9 cut-outs
GND on BOTTOM: 120.65,103.68 120.02,104.32 119.13,104.32 118.75,104.7 118.75,105.97 119,106.22 119.26,106.22 119.38,106.1 119.38,105.34 119.64,105.08 120.91,105.08 121.03,104.95 121.03,104.57 121.29,104.32 121.67,104.32 121.92,104.07 121.92,103.94 121.67,103.68
GND on BOTTOM: 101.27,123.19 101.15,123.32 101.15,127.74 100.79,128.09 100.79,129.19 101.15,129.54 101.15,132.79 99.51,134.42 99.51,136.13 98.96,136.68 95.3,136.68 95.28,136.7 95.28,137.64 95.33,137.69 95.9,137.69 96.02,137.81 96.02,138.62 96.12,138.71 102.06,138.71 104.03,136.74 104.03,135.06 104.03,135.06 104.03,133.61 104.97,132.67 104.97,130.15 104.72,129.9 104.4,129.9 104.03,129.53 104.03,129.46 104.03,129.46 104.03,123.48 103.74,123.19 ; 2 cut-outs
GND on BOTTOM: 34.7,30.43 34.29,30.84 34.29,31.4 35.69,31.4 35.79,31.5 35.79,33.1 35.94,33.25 38.08,33.25 38.18,33.15 38.18,30.48 38.13,30.43
GND on BOTTOM: 154.62,145.51 154.48,145.64 154.48,146.34 154.71,146.94 155.2,146.97 156.66,146.97 157.53,146.09 157.53,145.79 157.42,145.68 156.83,145.68 156.63,145.88 155.46,145.88 155.09,145.51 ; 1 cut-out
GND on BOTTOM: 84.25,119.91 84.13,120.04 84.13,121.24 82.25,123.12 82.25,125.71 83.01,126.47 83.01,128.3 83.49,128.78 83.49,134.8 82.83,135.46 80.67,135.46 79.58,136.55 75.97,136.55 75.9,136.63 75.9,137.54 75.95,137.59 76.56,137.59 76.65,137.68 76.65,138.52 76.71,138.58 76.71,138.58 80.37,138.58 80.75,138.2 84.97,138.2 85.35,137.82 85.35,129.06 85.36,129.05 85.36,126.63 86.46,125.53 86.46,122.99 84.89,121.41 84.89,120.04 84.76,119.91
GND on BOTTOM: 51.77,40.36 51.62,40.51 51.62,41.53 51.95,41.86 53.38,41.86 53.38,41.87 53.44,41.92 53.44,43.66 53.49,43.71 53.64,43.71 53.71,43.64 53.71,41.95 53.8,41.86 53.95,41.86 54.51,41.3 54.84,41.3 54.94,41.2 54.94,40.41 54.89,40.36 ; 2 cut-outs
GND on BOTTOM: 64.69,37.49 64.48,37.7 64.48,38.27 64.17,38.58 63.89,38.58 63.73,38.75 63.73,41.81 63.83,41.91 64.47,41.91 64.65,41.73 64.65,40.36 65.1,39.9 65.1,38.86 65.57,38.4 65.57,37.64 65.42,37.49 ; 1 cut-out
GND on BOTTOM: 58.4,126.59 58.3,126.7 58.3,131.75 58.65,132.11 59.82,132.11 60.71,132.11 60.76,132.06 60.76,131.42 60.6,131.26 59.88,131.26 59.82,131.19 59.06,131.19 58.8,130.94 58.8,129.85 59.26,129.39 59.26,126.65 59.21,126.59 ; 1 cut-out
GND on BOTTOM: outline of 186 points within 1.16,0.51 226.49,69.41 ; 16 cut-outs
GND on BOTTOM: 161.78,114.86 161.67,114.96 161.67,115.32 161.34,115.65 158.93,115.65 158.83,115.55 158.83,115.22 158.7,115.09 158.22,115.09 158.22,117.27 158.47,117.53 162.39,117.53 162.49,117.43 162.49,114.91 162.44,114.86 ; 4 cut-outs
GND on BOTTOM: 166.91,115.98 166.8,116.08 166.8,119.43 166.83,119.46 167.62,119.46 167.69,119.38 167.69,116.13 167.54,115.98
GND on BOTTOM: 93.3,140.74 93.22,140.82 93.22,141.25 93.02,141.45 92.54,141.45 92.33,141.66 92.33,142.8 92.34,142.8 92.34,143.08 92.52,143.27 93.16,143.27 93.98,142.45 93.98,140.9 93.83,140.74
GND on BOTTOM: 15.78,55.25 15.57,55.45 15.57,56.24 15.59,56.25 15.59,56.66 15.75,56.82 15.98,56.82 16.46,56.34 19.24,56.34 19.36,56.22 19.36,55.5 19.1,55.25 ; 1 cut-out
GND on BOTTOM: 25.34,41.5 23.77,43.07 23.77,45.07 23.5,45.35 23.46,45.31 23.16,45.31 22.98,45.49 22.98,45.65 23.22,45.89 23.48,45.89 23.67,46.08 23.67,48.6 23.83,48.76 27.02,48.76 27.61,49.35 29.29,49.35 29.29,49.31 29.65,48.95 29.65,48.41 29.33,48.1 27.71,48.1 27.18,47.56 27.18,42.55 26.13,41.5
GND on BOTTOM: 21.57,82.91 20.91,83.57 20.91,83.95 22.13,85.17 23.29,85.17 23.47,84.99 23.47,83.11 23.27,82.91
GND on BOTTOM: 98.33,141.76 98.02,142.06 97.44,142.06 97.23,142.27 96.81,142.27 96.58,142.5 96.58,143.59 96.1,144.07 96.1,144.68 96.18,144.76 98.56,144.76 98.93,144.39 98.93,142.91 99.16,142.67 99.16,141.89 99.04,141.76 ; 4 cut-outs
GND on BOTTOM: 120.53,105.72 120.15,106.1 120.15,106.48 120.91,107.24 120.91,107.49 121.16,107.75 122.05,107.75 122.18,107.88 123.7,107.88 123.96,107.62 123.96,106.73 122.94,105.72
GND on BOTTOM: 116.51,99.37 116,99.87 113.97,99.87 113.85,99.75 112.07,99.75 111.81,100 111.81,100.38 111.94,100.51 115.6,100.51 116.29,101.2 117.12,101.2 117.52,100.8 117.52,100.59 117.43,100.5 117.05,100.5 116.76,100.21 116.76,99.48 116.64,99.37
GND on BOTTOM: 123.62,129.11 123.52,129.21 123.52,136.02 123.62,136.12 124.64,136.12 126.14,134.62 126.14,130.13 125.12,129.11 ; 6 cut-outs
GND on BOTTOM: 119.89,35.99 119.64,36.25 119.64,37.95 119.75,38.06 121.48,38.06 121.78,37.77 121.9,37.77 122.66,37.01 123.02,37.01 123.07,36.96 123.07,36.04 123.02,35.99 ; 1 cut-out
GND on BOTTOM: 15.98,30.35 15.5,30.83 15.5,35.13 15.78,35.41 17.22,35.41 17.33,35.31 17.33,33.66 17.76,33.22 19.08,33.22 19.1,33.2 19.1,31.3 18.15,30.35 ; 3 cut-outs
GND on BOTTOM: 121.1,136.51 120.86,136.74 120.86,137.21 120.58,137.49 118.27,137.49 118.21,137.54 118.21,138.18 118.24,138.2 121.08,138.2 121.31,138.43 123.31,138.43 123.31,138.43 124.4,138.43 124.51,138.55 124.51,140.03 124.42,140.12 123.68,140.12 123.65,140.16 123.65,143.35 123.68,143.38 124.16,143.38 124.36,143.58 124.36,144.1 124.41,144.15 126.3,144.15 126.39,144.06 126.39,143.55 125.31,142.47 125.31,137.17 124.65,136.51 ; 4 cut-outs
GND on BOTTOM: 15.14,127.27 15.08,127.33 15.08,127.67 15.25,127.84 15.25,129.66 15.38,129.79 16.31,129.79 16.46,129.64 16.46,127.91 15.82,127.27
GND on BOTTOM: 192.28,32.31 191.65,32.95 191.65,36.37 191.76,36.49 192.5,36.49 192.63,36.36 193.82,36.36 194.44,35.74 195.71,35.74 195.96,35.49 195.96,33 195.28,32.31
GND on BOTTOM: 77.58,141.94 77.41,142.11 77.41,142.66 77.17,142.9 77.17,143.82 76.85,144.15 76.46,144.15 76.23,144.37 76.23,144.42 76.86,145.05 76.86,145.21 77.02,145.37 80.62,145.37 80.72,145.26 80.72,144.94 80.6,144.82 79.47,144.82 79.06,144.41 79.06,142.01 78.99,141.94 ; 5 cut-outs
GND on BOTTOM: 188.67,52.58 188.55,52.71 188.55,55.6 188.57,55.63 190.05,55.63 190.07,55.6 190.07,52.88 189.77,52.58
GND on BOTTOM: 95.76,56.59 95.56,56.8 95.56,61.16 95.74,61.34 107.8,61.34 108.08,61.06 108.08,56.92 107.75,56.59
GND on BOTTOM: 25.43,13.44 25.15,13.72 25.15,16.28 23.35,18.09 23.35,18.49 22.61,19.23 21.72,19.23 21.47,19.48 21.47,20.25 21.09,20.63 19.69,20.63 18.93,21.39 17.28,21.39 16.26,22.4 4.19,22.4 4.19,23.42 4.32,23.55 9.4,23.55 9.86,23.09 10.87,23.09 10.95,23.17 11.05,23.17 11.43,23.55 11.43,26.47 13.08,28.12 13.72,28.12 16.51,25.33 16.51,24.31 18.04,22.79 21.59,22.79 22.23,22.15 27.94,22.15 29.85,20.25 32.67,20.25 33.05,19.86 33.05,16.97 32.72,16.64 29.82,16.64 29.49,16.31 28.96,16.31 28.55,15.89 28.55,13.75 28.24,13.44
GND on BOTTOM: 38.66,34.14 38.51,34.29 37.78,34.29 37.47,34.6 36.99,34.6 35.93,35.65 35.93,37.59 36.14,37.8 36.14,38.65 36.22,38.72 37.68,38.72 37.76,38.64 37.76,38.34 38.01,38.09 38.31,38.09 38.87,37.54 38.87,36.37 38.99,36.25 40.48,36.25 40.53,36.3 40.53,36.62 40.62,36.7 41.7,36.7 41.8,36.61 41.8,35.54 41.74,35.48 38.76,35.48 38.62,35.34 38.62,35.03 38.87,34.77 39.09,34.77 39.22,34.65 39.22,34.24 39.12,34.14 ; 1 cut-out
GND on BOTTOM: 153.66,33.88 152.96,34.57 152.96,39.12 152.15,39.93 149.28,39.93 148.9,40.3 145.98,40.3 145.08,41.2 142.04,41.2 141.94,41.1 141.94,40.23 141.84,40.13 140.97,40.13 140.8,40.3 137.26,40.3 137.04,40.08 137.04,37.9 136.91,37.77 133.8,37.77 133.65,37.92 133.65,40.63 133.65,40.64 133.65,40.71 134.55,41.61 134.62,41.61 134.82,41.81 151.13,41.81 154.4,38.55 154.4,36.06 154.82,35.64 155.78,35.64 156.7,36.55 160.07,36.55 160.43,36.2 164.26,36.2 165.51,37.44 165.51,39.47 165.59,39.55 167.26,39.55 168.74,38.08 168.74,36.06 168.75,36.05 168.75,35.55 169.29,35 169.29,33.95 169.22,33.88 ; 3 cut-outs
GND on BOTTOM: 189.23,45.65 189.11,45.77 189.11,46.28 189.36,46.53 191.09,46.53 191.39,46.84 191.39,47.3 191.52,47.42 192.81,47.42 192.89,47.5 192.89,48.21 192.99,48.31 194.57,48.31 194.64,48.24 194.64,47.42 194.82,47.25 194.82,46.74 194.74,46.66 194.16,46.66 193.81,46.31 193.81,45.9 193.55,45.65 193.17,45.65 192.92,45.9 192.92,46.28 192.79,46.41 191.7,46.41 191.65,46.36 191.65,45.77 191.52,45.65
GND on BOTTOM: 67.92,135.54 67.92,136.6 67.87,136.65 67.87,138.56 67.64,138.79 67.64,140.29 67.68,140.32 68.24,140.32 68.39,140.47 68.39,140.71 68.57,140.89 70.45,140.89 70.53,140.81 70.53,140.39 70.26,140.12 70.26,138.18 70.13,138.05 69.5,138.05 69.37,138.18 68.84,138.18 68.58,137.92 68.58,136.73 68.71,136.6 68.96,136.6 68.99,136.58 68.99,135.54 ; 3 cut-outs
GND on BOTTOM: 121.47,119.05 121.21,119.31 120.25,119.31 120.09,119.46 120.09,120.73 121.42,122.05 122.56,122.05 123.17,121.44 123.17,119.38 123.09,119.31 122.3,119.31 122.05,119.05 ; 2 cut-outs
GND on BOTTOM: 108.79,138.69 108.6,138.88 108.6,139.36 108.11,139.85 108.11,142.9 108.36,143.16 108.36,143.64 108.41,143.69 109.17,143.69 109.54,143.32 109.54,141.49 109.97,141.06 110.53,141.06 110.73,140.86 111.27,140.86 111.41,140.72 111.41,139.85 110.95,139.4 110.95,138.81 110.82,138.69 ; 1 cut-out
GND on BOTTOM: 113.62,29.31 113.46,29.47 112.3,29.47 111.88,29.88 111.88,30.29 110.87,31.29 110.87,31.95 111.59,32.67 111.59,37.36 111.74,37.52 112.27,37.52 112.65,37.14 112.65,33.68 114.23,32.11 114.23,29.36 114.18,29.31 ; 1 cut-out
GND on BOTTOM: 162.49,128.06 162.16,128.38 162.16,130.69 162.16,130.7 162.16,139.47 162.57,139.88 162.57,141.16 162.17,141.56 162.17,142.35 162.87,143.04 162.87,145.64 162.96,145.73 163.3,145.73 163.39,145.65 163.39,140.65 163.13,140.39 163.13,139.23 163.14,139.23 163.28,139.1 163.28,135.96 163.27,135.96 163.27,129.06 163.26,129.04 163.26,128.19 163.13,128.06 ; 9 cut-outs
GND on BOTTOM: 108.97,39.8 108.46,40.31 108.46,41.07 108.64,41.25 112.3,41.25 112.37,41.17 112.37,40.54 112.27,40.44 110.24,40.44 109.6,39.8
GND on BOTTOM: 42.93,87.58 42.8,87.71 42.8,90.12 43.05,90.37 47.26,90.37 47.87,89.75 47.87,87.75 47.7,87.58
GND on BOTTOM: 20.27,103.4 20.2,103.48 20.2,103.91 20.55,104.27 20.55,105.69 20.37,105.87 19.87,105.87 19.76,105.97 19.76,107.29 19.87,107.39 20.48,107.39 20.7,107.62 21.54,107.62 21.64,107.72 21.64,107.95 21.87,108.18 22.36,108.18 22.43,108.1 22.43,107.85 22.58,107.7 23.17,107.7 23.29,107.57 23.29,106.15 23.6,105.84 23.6,104.88 23.4,104.67 23.4,104.19 23.29,104.09 23.29,103.68 23.02,103.4 ; 11 cut-outs
GND on BOTTOM: 146.36,142.98 145.39,143.94 145.39,144.45 143.18,146.66 143.18,146.99 143.31,147.12 150.88,147.12 151.21,146.79 151.21,146.13 150.93,145.85 147.81,145.85 147.6,145.64 147.6,145.42 147.45,145.26 146.87,145.26 146.54,144.93 146.54,144.04 146.92,143.66 148.59,143.66 148.69,143.56 148.69,143.41 148.59,143.31 147.91,143.31 147.58,142.98 ; 10 cut-outs
GND on BOTTOM: 155.68,38.1 155.4,38.38 155.4,40.23 155.63,40.46 157.43,40.46 157.81,40.08 157.81,38.15 157.76,38.1
GND on BOTTOM: 47.42,78.64 47.36,78.7 47.36,80.17 47.69,80.49 47.69,81.24 47.51,81.42 46.37,81.42 46.31,81.36 45.42,81.36 45.24,81.18 45.24,80.72 45.01,80.49 44.68,80.49 44.53,80.65 44.53,83.75 44.4,83.87 44.4,83.9 44.33,83.97 44.07,83.97 43.97,84.08 43.97,84.56 44.1,84.68 44.45,84.68 44.47,84.7 45.81,84.7 46.33,85.22 46.59,85.22 46.69,85.32 46.69,85.85 46.79,85.95 46.94,85.95 47.09,86.11 47.09,86.49 47.25,86.64 47.81,86.64 47.91,86.54 47.91,86.06 48.09,85.88 48.09,82.86 48.16,82.78 48.49,82.78 48.64,82.63 48.64,82.09 49.47,81.27 49.47,79.24 48.88,78.64 ; 15 cut-outs
GND on BOTTOM: 178.11,42.57 178.06,42.62 178.06,45.01 178.31,45.26 178.31,46.41 178.65,46.74 181.71,46.74 181.99,46.46 181.99,44.43 181.84,44.27 180.34,44.27 179.76,43.69 179.76,42.65 179.68,42.57
GND on BOTTOM: 92.87,90.12 91.82,91.16 91.82,92.38 92.23,92.79 94.03,92.79 94.12,92.7 94.12,92.01 94.97,91.16 94.97,90.6 94.49,90.12
GND on BOTTOM: outline of 444 points within 0.53,35.17 226.39,152.49 ; 19 cut-outs
GND on BOTTOM: 48.01,116.64 47.25,117.4 47.25,119.94 47.37,120.07 51.31,120.07 51.95,119.43 52.89,119.43 53.22,119.76 53.76,119.76 53.87,119.65 53.87,117.76 53.78,117.67 53.31,117.67 53.31,117.66 53.09,117.66 52.9,117.84 51.36,117.84 50.99,117.47 50.99,116.8 50.82,116.64 ; 5 cut-outs
GND on BOTTOM: 52.4,31.55 51.41,32.54 51.41,33.86 51.64,34.09 51.64,36.6 51.9,36.86 53.95,36.86 54.11,37.01 54.99,37.01 55.3,36.7 55.78,36.7 55.86,36.63 55.86,36.17 55.81,36.12 54.16,36.12 54,35.97 54,31.8 53.75,31.55 ; 6 cut-outs
GND on L2SGND: outline of 688 points within 0.53,0.53 226.47,152.49 ; 10 cut-outs
GND on L2SGND: 46,28.65 45.65,28.65 44.88,27.89 37.39,27.89 36.22,26.72 35.98,26.72 34.95,27.75 34.92,27.75 34.88,27.71 34.88,19 35.77,18.11 36.71,19.05 36.71,19.25 36.96,20.32 37.34,21.34 37.95,22.56 38.38,23.17 39.09,24.03 39.7,24.56 40.44,25.12 41.46,25.71 42.27,26.04 42.98,26.24 44.15,26.49 44.91,26.54 45.82,26.54 46.28,26.75 46.36,28.12 46.18,28.6
GND on L3: 146.75,146.75 150.1,146.75 150.41,146.43 150.41,145.16 152.55,143.02 152.55,141.64 151.01,140.11 149.46,140.11 148.01,141.56 148.01,142.23 147.33,142.91 147.33,143.15 144.66,145.82 144.66,146.31 144.78,146.44 145.28,146.44 145.62,146.09 146.1,146.09
GND on L3: 76.2,140.13 79.38,140.13 80.14,139.37 80.14,136.07 79.12,135.05 76.2,135.05 75.31,135.94 75.31,139.24
GND on L3: 102.49,138.36 102.24,138.61 90.2,138.61 89.56,139.24 88.78,139.24 88.76,139.23 88.13,139.23 88.12,139.22 88.04,139.29 88.04,139.86 87.74,140.16 85.53,140.16 84.37,138.99 84.37,135.52 83.64,134.79 83.64,131.76 82.87,131 82.87,127.54 83.45,126.96 85.16,126.96 85.5,127.29 85.5,131.44 87.2,133.15 98.78,133.15 101.4,135.76 102.06,135.76 102.49,136.2
GND on L3: outline of 495 points within 0.52,0.51 226.49,152.49 ; 7 cut-outs
GND on L3: 149.85,135.82 147.39,135.82 145.51,133.94 145.51,131.3 146.07,130.74 146.07,124.58 147.06,123.59 149.37,123.59 150.16,124.37 150.16,135.51
GND on L3: 43.23,90.43 47.07,90.43 47.27,90.22 47.27,87.76 47.02,87.5 43.21,87.5 42.88,87.83 42.88,90.07
GND on L3: 75.44,96.29 66.08,96.29 57.41,87.62 57.41,76.23 38.94,57.76 36.81,57.76 31.98,52.93 31.98,52.6 29.24,49.86 29.24,47.52 29.49,47.27 29.49,44.65 30.04,44.1 30.1,44.1 30.48,43.71 50.69,43.71 52.54,45.56 54.02,45.56 55.87,43.71 90,43.71 90.38,44.1 96.14,44.1 97.56,45.52 98.17,45.52 100,47.34 102.73,47.34 103.41,46.66 105.54,46.66 105.57,46.64 106.28,46.64 106.71,46.2 107.09,46.2 107.83,46.94 122.56,46.94 124.61,44.9 128.11,44.9 130.08,42.93 166.36,42.93 167.74,44.3 168.15,44.3 168.55,43.91 172.63,43.91 173.46,44.73 173.46,50.19 167.66,56 166.69,56 165.62,57.06 165.62,57.76 165.03,58.36 164.25,58.36 156.44,66.17 156.44,67.21 147.88,75.77 126.75,75.77 122.4,80.12 113.19,80.12 110.9,82.41 110.9,83.75 109.47,85.18 109.47,87.43 109.77,87.73 110.04,87.73 110.12,87.81 110.12,88.19 109.53,88.78 109.53,89.22 109.02,89.72 91.39,89.72 90.91,90.2 84.92,90.2 83.67,91.44 83.67,92.94 82.83,93.78 78.64,93.78 77.55,94.87 76.86,94.87
GND on L3: 17.02,103.18 16.77,103.43 16.77,107.24 19.21,109.68 21.82,109.68 23.24,108.26 23.24,104.32 22.36,103.43 19.82,103.43 19.56,103.68 18.8,103.68 18.29,103.18
GND on L4: 43.18,90.48 47.12,90.48 47.5,90.1 47.5,87.66 47.4,87.56 42.93,87.56 42.8,87.68 42.8,90.1
GND on L4: outline of 497 points within 0.53,0.51 226.49,152.49 ; 10 cut-outs
GND on L4: 75.95,138.48 84.46,138.48 85.47,137.47 85.47,127.05 85.09,126.67 83.7,126.67 83.32,127.05 83.32,130.86 83.44,130.99 83.44,135.05 82.55,135.94 75.95,135.94 75.57,136.32 75.57,138.1
GND on L4: 200.31,45.26 201.07,44.5 201.07,41.84 200.43,41.2 198.22,41.2 197.84,40.82 194.87,40.82 194.74,40.95 192.03,40.95 188.37,37.29 188.37,36.3 185.93,33.86 185.88,33.86 185.42,33.4 183.62,33.4 182.65,32.44 175.35,32.44 174.15,33.64 174.15,35.49 183.92,45.26
GND on L4: 102.49,138.36 102.24,138.61 96.65,138.61 96.02,137.97 90.55,137.97 89.79,138.74 89.79,139.02 89.56,139.24 88.78,139.24 88.76,139.23 88.13,139.23 88.12,139.22 88.04,139.29 88.04,140.13 88.01,140.16 86.52,140.16 86.06,139.7 86.06,134.29 87.2,133.15 98.78,133.15 101.4,135.76 102.06,135.76 102.49,136.2
GND on L5SGND: 165.74,40.06 165.74,38.28 165.61,38.15 162.56,38.15 162.44,38.28 162.44,40.06 162.56,40.18 165.61,40.18
GND on L5SGND: outline of 328 points within 0.52,0.51 221.93,152.49 ; 3 cut-outs
VCC3PD on TOP: 52.94,125.48 52.84,125.58 52.84,126.8 52.91,126.87 53.57,126.87 53.67,126.98 53.67,127.66 53.8,127.79 54.74,127.79 55.15,127.38 55.15,125.6 55.02,125.48 ; 2 cut-outs
VDDD on TOP: 38.74,105.59 38.61,105.72 38.61,107.88 38.74,108 39.5,108 39.63,108.13 39.63,108.76 39.68,108.81 39.96,108.81 40.01,108.76 40.01,105.72 39.88,105.59 ; 2 cut-outs
VDDIO on TOP: 40.94,104.86 40.53,105.27 40.17,105.27 40.14,105.31 40.14,108.76 40.19,108.81 40.47,108.81 40.52,108.76 40.52,107.49 41.28,106.73 41.28,106.71 41.37,106.62 41.37,104.91 41.32,104.86 ; 2 cut-outs
0D6V_PWR on TOP: 92.33,27.61 92.08,27.87 92.08,28.63 92.35,28.9 92.35,31.37 92.87,31.89 92.87,33.12 94.32,34.57 94.32,37.92 94.31,37.92 94.31,39.07 94.41,39.17 96.24,39.17 96.4,39.02 96.4,38 96.27,37.87 96.27,34.48 94.47,32.69 94.47,31.69 93.66,30.88 93.66,27.8 93.48,27.61
0D6V_PWR on BOTTOM: 118.65,28.17 118.37,28.45 118.37,28.78 118.29,28.86 117.53,28.86 117.48,28.91 117.48,29.19 117.53,29.24 118.27,29.24 118.32,29.29 118.32,29.62 118.29,29.64 117.63,29.64 117.5,29.77 117.5,29.92 117.55,29.97 118.33,29.97 118.47,29.83 118.89,29.83 119.08,29.64 119.08,29.34 119.18,29.24 120.17,29.24 120.37,29.44 120.37,29.8 120.81,30.23 121.03,30.23 121.54,29.72 121.54,28.8 120.91,28.17 ; 2 cut-outs
0D6V_PWR on L5SGND: 109.39,28.18 116.27,28.18 118.17,29.45 119.97,29.45 120.73,30.21 121.46,30.21 121.61,30.07 121.61,28.45 120.45,27.3 118.06,27.3 117.92,27.17 110.43,27.17 110.11,26.85 92.48,26.85 91.85,27.48 91.85,28.02 92.21,28.37 92.59,28.37 93.32,27.64 108.84,27.64
0D6V_S0 on TOP: 170.66,43.39 170.58,43.47 170.58,43.84 170.71,43.97 172.24,43.97 172.88,44.61 173.15,44.61 173.29,44.46 173.29,44.2 172.48,43.39
0D6V_S0 on TOP: 93.75,39.3 93.58,39.47 93.58,42.57 93.68,42.67 95.38,42.67 96.17,41.89 96.17,41.68 96.27,41.58 96.27,39.55 96.14,39.42 94.44,39.42 94.31,39.3 ; 4 cut-outs
1D0V_S5 on TOP: 112.64,93.26 112.2,93.7 109.52,93.7 109.1,94.12 109.1,98.47 109.33,98.71 109.93,98.71 110.11,98.88 110.11,99.28 110.24,99.41 111.31,99.41 111.77,99.87 111.77,104.09 111.89,104.22 111.89,114.28 112.58,114.96 112.58,115.27 112.53,115.32 112.4,115.32 112.35,115.37 112.35,127.69 111.64,128.4 111.64,129.44 112.04,129.85 123.45,129.85 123.7,129.59 123.7,125.4 122.25,123.95 122.25,117.1 122.4,116.95 123.61,116.95 124.54,117.88 125.58,117.88 126.39,117.07 126.39,109.19 130.78,104.8 130.78,104.79 131.3,104.27 131.3,98.76 130.86,98.32 128.01,98.32 127.64,98.7 127.64,100.64 125.86,102.41 125.86,102.87 122.76,105.97 122.76,106.4 122.75,106.41 122.75,107.42 122.71,107.42 122.48,107.65 122.41,107.65 122.25,107.49 122.25,106 121.47,105.21 121.47,104.8 122.25,104.01 122.25,100.37 122.73,99.88 122.73,99.59 122.59,99.45 122.59,99.05 120.75,97.21 118.15,97.21 117.8,96.86 117.8,94.53 116.94,93.67 115.34,93.67 114.93,93.26 ; 25 cut-outs
1D0V_S5 on BOTTOM: 122.08,114.68 121.95,114.81 121.95,117.73 121.44,118.24 121.44,118.64 121.54,118.75 123.09,118.75 123.22,118.62 123.22,118.21 123.52,117.91 125.1,117.91 125.48,118.29 126.01,118.29 126.06,118.24 126.06,116.41 125.76,116.1 123.88,116.1 123.7,115.93 123.7,114.78 123.6,114.68 ; 3 cut-outs
1D0V_S5 on BOTTOM: 111.56,93.19 110.87,93.88 110.52,93.88 110.16,93.52 109.91,93.52 109.78,93.65 109.78,94.54 109.91,94.67 110.54,94.67 110.9,95.02 110.9,97.23 110.8,97.33 110.8,97.59 110.29,98.1 110.04,98.1 109.78,98.35 109.78,98.73 110.16,99.11 110.16,99.37 110.54,99.75 111.94,99.75 112.19,99.49 112.19,98.91 112.58,98.53 114.13,98.53 114.18,98.58 114.18,98.83 114.05,98.96 114.05,99.34 114.4,99.7 116,99.7 116.46,99.24 116.46,99.01 116.34,98.88 116.11,98.88 116.06,98.93 115.7,98.93 115.6,98.83 115.6,97.87 115.04,97.31 115.04,96.88 115.14,96.78 115.14,96.47 114.96,96.29 114.96,95.35 115.22,95.1 115.22,94.84 114.73,94.36 114.05,94.36 113.9,94.21 113.9,93.93 113.69,93.73 113.69,93.5 113.39,93.19
1D0V_S5 on BOTTOM: 115.42,124.72 115.4,124.74 115.4,127.15 114.96,127.59 112.09,127.59 111.86,127.81 111.86,128.78 112.42,129.34 116.41,129.34 116.55,129.2 116.55,128.72 116.64,128.63 118.57,128.63 118.7,128.5 118.7,126.75 118.06,126.11 117.17,126.11 117.1,126.04 117.1,124.77 117.05,124.72
1D0V_S5 on L2SGND: 128.83,100.31 122.66,100.31 122.18,99.82 114.94,99.82 114.2,100.56 113.29,100.56 112.78,101.07 112.04,101.07 111.28,100.31 111,100.31 110.11,99.42 110.11,98.99 110.8,98.3 110.8,96.98 110.19,96.37 110.19,93.98 110.28,93.89 112.23,93.89 114.68,91.44 120.07,91.44 124.92,96.29 128.43,96.29 131.04,98.91 131.04,100.41 130.81,100.64 129.16,100.64
1D0V_S5 on L4: 109.78,100.64 109.15,100 109.15,97.79 109.45,97.49 110.14,97.49 110.77,96.85 110.77,96.42 110.49,96.14 109.45,96.14 109.15,95.84 109.15,93.17 109.5,92.81 114.73,92.81 114.75,92.83 115.87,92.83 115.95,92.91 115.95,95.15 115.29,95.81 115.29,97.79 115.57,98.07 116.31,98.07 116.51,98.27 116.51,99.42 116.39,99.54 114.56,99.54 112.86,101.25 112.02,101.25 111.41,100.64
1D0V_VCCPRIM_MPHY on TOP: 112.88,97.02 112.7,97.2 112.7,97.64 112.37,97.97 112.37,98.91 112.88,99.42 113.74,99.42 113.9,99.26 113.9,99.04 114.33,98.6 114.33,97.94 114.15,97.77 113.92,97.77 113.92,97.53 113.42,97.02 ; 1 cut-out
1D2V_S3 on TOP: 110.61,42.47 109.84,43.24 107.33,43.24 106.57,44.01 106.01,44.01 103.36,46.66 100.03,46.66 98.48,48.21 98.48,49.41 97.35,50.54 97.35,52.36 96.67,53.04 96.67,55.06 84.66,67.07 84.66,80.9 84.51,81.05 84.51,83.9 85.35,84.74 85.35,86.82 85.37,86.82 85.6,87.05 85.6,88.14 85.75,88.29 85.75,90.15 85.5,90.4 85.5,92.56 85.65,92.71 86.46,92.71 86.54,92.64 86.54,91.77 86.76,91.55 93.86,91.55 94.23,91.18 94.23,90.27 94.48,90.02 94.48,88.38 94.49,88.37 94.49,87.91 94.26,87.68 94.26,84.44 97.12,81.58 97.25,81.58 97.47,81.37 97.47,81.21 97.11,80.84 97.11,76.99 97.54,76.56 97.54,73.64 108.23,62.94 140.44,62.94 151,52.39 151,51.56 152.84,49.71 152.84,44.87 152.66,44.68 150.52,44.68 150.02,45.19 149.43,45.19 147.93,43.69 147.53,43.69 147.5,43.71 147.5,44.43 147.48,44.45 145.63,44.45 145.41,44.23 145.03,44.23 144.53,44.73 143.72,44.73 143.06,44.07 143.06,43.31 142.9,43.16 119.54,43.16 118.85,42.47 ; 58 cut-outs
1D2V_S3 on TOP: 53.83,43.4 53.72,43.51 53.72,45.17 56.98,48.43 56.98,49.16 58.04,50.22 68.58,50.22 70.87,47.93 70.87,46.28 72.39,44.76 72.39,44.4 71.96,43.97 71.96,43.69 71.85,43.58 69.16,43.58 68.59,44.16 56.98,44.16 56.22,43.4 ; 16 cut-outs
1D2V_S3 on TOP: 133.28,78.69 133.05,78.92 132.49,78.92 132.38,79.03 132.38,79.42 132.77,79.82 132.77,81.42 133.82,82.48 138.31,82.48 138.61,82.78 138.61,85.75 138.64,85.78 140.26,85.78 140.29,85.75 140.29,84.48 140.39,84.38 141.2,84.38 141.28,84.3 141.28,83.34 140.92,82.98 140.47,82.98 140.01,82.53 140.01,81.71 139.63,81.33 134.06,81.33 133.86,81.13 133.86,79.02 133.53,78.69 ; 2 cut-outs
1D2V_S3 on BOTTOM: 71.68,40.08 71.07,40.69 71.07,41.5 71.35,41.78 75.87,41.78 76.05,41.61 76.05,41.3 74.69,41.3 74.52,41.12 74.52,40.45 74.15,40.08 ; 1 cut-out
1D2V_S3 on BOTTOM: 97.55,49.82 97.16,50.22 97.16,51.87 96.65,52.38 45.34,52.38 45.09,52.63 45.09,52.69 45.3,52.91 56.01,52.91 58.1,54.99 99.22,54.99 100.26,53.95 100.26,50.1 99.98,49.82
1D2V_S3 on L2SGND: 58.07,50.37 57.25,49.56 57.25,47.45 56.77,46.97 56.77,45.39 57.51,44.65 60.4,44.65 60.76,44.3 60.76,44.27 61.09,43.94 72.44,43.94 72.8,44.3 72.8,45.92 71.71,47.02 71.71,47.4 68.74,50.37
1D2V_S3 on L4: 133.07,49.81 133.07,45.24 133.68,44.63 137.49,44.63 137.98,44.15 148.64,44.15 148.69,44.2 148.69,46.61 148.26,47.04 148.14,47.04 147.42,47.75 147.42,48.24 147.2,48.46 146.33,48.46 145.65,49.15 142.6,49.15 141.79,49.96 140.59,49.96 139.63,50.93 134.19,50.93
1D2V_S3 on L4: 84.1,51.35 76.53,51.35 74.65,49.48 74.65,49.03 74.22,48.59 74.22,47.15 73.63,46.57 72.85,46.57 72.75,46.67 72.75,47.04 73.25,47.55 73.29,47.55 73.29,47.87 73.1,48.07 72.09,48.07 71.34,47.32 71.05,47.32 70.87,47.13 70.87,46.89 71.19,46.57 71.19,45.7 70.77,45.28 70.04,45.28 69.46,44.7 68.59,44.7 67.84,45.45 67.84,46.95 67.51,47.28 66.73,47.28 66.59,47.13 66.59,44.2 66.96,43.83 76.2,43.83 76.65,44.28 96.59,44.28 97.82,45.52 97.82,49.05 92.61,54.26 87,54.26
1D2V_S3 on L4: 105.48,87.79 105.38,87.69 105.38,85.27 106.93,83.73 106.93,83.36 106.75,83.18 105.21,83.18 104.64,83.75 102.64,83.75 101.92,83.03 101.2,83.03 100.45,83.77 98.61,83.77 97.44,82.6 96.62,82.6 96.57,82.65 96.57,84.25 93.87,86.96 93.87,87.39 93.1,88.16 93.1,89.38 92.76,89.71 92.26,89.71 92.13,89.84 92.13,90.86 92.25,90.97 104.08,90.97 104.88,90.17 104.88,89.74 104.85,89.71 104.96,89.61 104.96,88.44 105.08,88.32 105.35,88.32 105.48,88.19
1D2V_VCCSFR_OC on TOP: 132.85,82.73 132.72,82.86 132.72,83.75 132.85,83.87 135.51,83.87 135.77,84.13 136.66,84.13 137.57,85.04 138.38,85.04 138.38,83.31 137.01,83.31 136.78,83.08 135.74,83.08 135.39,82.73 ; 2 cut-outs
1D2V_VCCSFR_OC on L4: 108.36,90.22 109.45,90.22 109.83,89.84 109.83,86.39 112.53,83.69 113.44,83.69 115.04,82.09 119.51,82.09 119.74,81.87 120.98,81.87 121.16,81.69 121.16,81.03 121.01,80.87 113.57,80.87 111.79,82.65 111.79,83.21 109.73,85.27 109.5,85.27 108.94,85.83 108.94,87.61 108.31,88.24 108.31,89.79 108.16,89.94 108.16,90.02
1D05V_PWR on TOP: 113.31,130.15 113.13,130.33 113.13,131.6 114.94,133.4 122.18,133.4 122.69,132.89 122.69,130.28 122.56,130.15
1D05V_PWR on BOTTOM: 116.77,128.86 116.67,128.96 116.67,129.39 116.46,129.59 114.33,129.59 114.2,129.72 114.2,132.79 114.73,133.33 121.03,133.33 121.72,134.01 121.72,135.84 121.97,136.09 123.02,136.09 123.19,135.92 123.19,129.16 122.89,128.86 ; 7 cut-outs
1D8V_S0 on BOTTOM: 61.24,38.51 61.21,38.54 61.21,40.21 61.51,40.51 61.75,40.51 61.75,40.51 62.36,40.51 62.55,40.7 62.55,41.77 62.69,41.91 63.33,41.91 63.5,41.73 63.5,38.89 63.25,38.64 62.01,38.64 61.88,38.51 ; 3 cut-outs
1D8V_S5 on TOP: 56.82,38.67 56.73,38.77 56.73,39.69 56.71,39.7 56.71,41.63 58.49,43.4 66.57,43.4 67.47,42.51 67.47,40.79 67.32,40.65 66.14,40.65 65.98,40.81 65.98,41.47 65.31,42.14 61.05,42.14 57.59,38.67
1D8V_S5 on BOTTOM: 59.03,38.53 58.88,38.69 58.88,40.68 58.77,40.8 58.57,40.8 58.49,40.87 58.49,41.63 58.6,41.74 59.87,41.74 60.26,41.34 60.26,40.13 59.84,39.7 59.84,38.67 59.83,38.67 59.83,38.55 59.82,38.53
1D8V_VCCPRIM on TOP: 66.08,38.73 65.85,38.96 65.85,40.21 65.95,40.32 66.66,40.32 66.72,40.25 66.72,38.94 66.51,38.73
1D8V_VCCPRIM on TOP: 122.48,87.01 122.44,87.05 121.69,87.05 120.91,87.83 120.36,87.83 120.12,88.07 119.09,88.07 118.93,88.23 118.65,88.23 118.43,88.45 118.43,88.84 118.28,88.99 116.88,88.99 116.88,88.99 116.64,88.99 116.59,89.05 116.59,89.51 116.67,89.59 117.31,89.59 117.37,89.65 117.77,89.65 117.81,89.6 117.81,89.59 117.87,89.54 118.27,89.54 118.47,89.74 118.47,89.99 118.67,90.2 121.34,90.2 122.41,89.13 124.97,89.13 125.09,89.24 125.09,90.44 125.35,90.71 126.04,90.71 127.87,92.53 127.87,94.24 126.44,95.66 126.44,95.94 126.34,96.04 124.54,96.04 124.44,96.14 123.65,96.14 123.57,96.22 123.4,96.22 123.19,96.42 123.19,96.95 123.5,97.26 125.61,97.26 125.78,97.44 125.78,97.79 125.91,97.92 126.5,97.92 127.33,97.08 129.8,97.08 131.02,95.86 131.02,93.7 131.52,93.2 132.43,93.2 132.49,93.26 135.94,93.26 135.95,93.25 135.95,92.95 135.89,92.89 135.55,92.89 134.74,92.08 130.29,92.08 125.22,87.01 ; 9 cut-outs
1D8V_VCCPRIM on BOTTOM: 128.91,92.33 128.83,92.41 128.83,92.76 128.2,93.4 128.2,93.55 128.37,93.73 130.12,93.73 130.31,93.54 130.31,92.54 130.1,92.33 ; 1 cut-out
1D8V_VCCPRIM on BOTTOM: 115.88,95.05 115.75,95.18 115.75,95.56 115.88,95.68 115.88,95.94 115.75,96.06 115.75,96.19 115.76,96.2 115.76,96.33 115.9,96.47 115.9,96.72 116.08,96.9 116.08,97.21 115.9,97.38 115.9,97.56 115.75,97.72 115.75,98.22 115.88,98.35 116.77,98.35 117.15,97.97 117.15,95.18 117.02,95.05
1D8V_VCCPRIM on L4: 116.13,97.84 117.53,97.84 117.54,97.83 122.87,97.83 125.42,95.29 130.47,95.29 130.69,95.07 130.69,93.42 130.31,93.04 124.03,93.04 123.5,92.51 122.99,92.51 120.1,95.4 117.34,95.4 117.12,95.19 116.5,95.19 115.88,95.81 115.88,97.59
1D24V_VCCDPHY on TOP: 114.14,91.25 114,91.39 114,91.59 113.35,92.24 113.35,92.39 113.59,92.64 115.34,92.64 115.49,92.49 115.49,91.62 115.12,91.25
2D5V_S3 on BOTTOM: 172.72,49.2 172.34,49.58 172.34,52.3 172.13,52.51 170.11,52.51 169.98,52.64 169.98,53.2 170.14,53.36 173.11,53.36 173.49,52.99 173.49,51.72 173.84,51.36 173.84,49.49 173.55,49.2
2D5V_S3 on BOTTOM: 161.62,118.04 161.52,118.14 161.52,119.23 161.57,119.28 162.08,119.28 162.7,119.9 163.24,119.9 163.3,119.97 164.01,119.97 164.11,119.86 164.11,118.64 164.06,118.59 163.63,118.59 163.62,118.58 162.96,118.58 162.41,118.04
3D3V_CAMERA on BOTTOM: 212.86,42.65 212.63,42.88 212.63,43.64 212.68,43.69 213.26,43.69 213.64,43.31 213.79,43.31 213.9,43.21 213.9,42.77 213.77,42.65
3D3V_EMMC on L3: 154.26,117.76 153.47,116.97 153.47,114.25 154.31,113.41 156.9,113.41 157.41,113.92 157.41,117.45 157.1,117.76
3D3V_LAN_S5 on TOP: 47.76,84.41 47.73,84.43 47.73,84.63 47.76,84.66 48.39,84.66 49.1,85.37 49.53,85.37 49.66,85.5 49.66,87.3 50.83,88.47 50.83,88.95 50.63,89.16 48.59,89.16 47.93,89.82 47.93,90.15 47.12,90.96 47.12,91.97 46.87,92.23 42.73,92.23 42.52,92.03 42.52,87.25 43.67,86.11 43.92,86.11 44.2,86.39 44.5,86.39 44.81,86.08 44.81,85.22 44.78,85.19 43.89,85.19 43.44,85.65 43.06,85.65 41.66,87.05 41.66,92.13 42.47,92.94 47.09,92.94 47.6,92.43 47.63,92.43 48.26,91.8 48.26,90.96 49.3,89.92 50.88,89.92 51.69,89.1 51.69,88.14 50.27,86.72 50.27,84.76 50.12,84.61 49.61,84.61 49.48,84.74 49.13,84.74 48.8,84.41
3D3V_LAN_S5 on L3: 44.66,86.39 44.2,86.39 43.45,85.63 43.45,81.98 45.14,80.29 45.75,80.29 45.82,80.37 45.82,81.2 44.84,82.18 44.84,86.2
3D3V_LAN_S5_R on TOP: 45.55,90.81 45.39,90.96 45.39,91.31 45.67,91.59 46.05,91.59 46.05,91.8 46.36,92.1 46.74,92.1 46.89,91.95 46.89,90.93 46.76,90.81
3D3V_LAN_S5_R on BOTTOM: 57.43,126.65 57.33,126.75 56.75,126.75 56.57,126.93 56.57,127.23 56.75,127.41 57,127.41 57.15,127.26 58.07,127.26 58.12,127.2 58.12,126.72 58.04,126.65
3D3V_LAN_S5_R on L4: 55.07,127.31 53.95,127.31 51.11,124.46 51.11,123.27 50.52,122.68 50.52,120.8 48.49,118.77 48.49,113.11 47.37,111.99 47.37,106.12 45.27,104.01 45.27,92.74 46.18,91.82 46.18,91.52 46.28,91.42 47.02,91.42 47.12,91.52 47.12,92.74 46.41,93.45 46.41,102.67 50.5,106.76 50.5,118.92 51.96,120.38 51.96,122.72 55.76,126.52 55.81,126.52 56.11,126.82 57.03,126.82 57.23,127.03 57.23,127.59 56.95,127.86 55.63,127.86
3D3V_LCDVDD_S0 on TOP: 218.27,36.55 218.14,36.68 218.14,37.44 217.96,37.62 217.6,37.62 217.53,37.69 217.53,37.82 217.3,38.05 216.79,38.05 216.74,38.1 216.74,39.4 217.12,39.78 217.17,39.78 217.94,40.54 217.94,40.79 217.73,41 217.73,41.48 217.83,41.58 218.47,41.58 218.7,41.35 218.95,41.35 219.08,41.23 219.08,38.95 218.72,38.59 218.72,37.78 219.08,37.42 219.08,36.76 218.87,36.55 ; 5 cut-outs
3D3V_LCDVDD_S0 on BOTTOM: 218.14,38.86 217.71,39.3 217.71,40.16 217.86,40.31 218.21,40.31 218.29,40.23 219.31,40.23 219.38,40.16 219.38,38.94 219.31,38.86
3D3V_RTC_AUX_S5 on TOP: 134.84,88.43 134.4,88.87 134.4,90.12 135.26,90.97 136.25,90.97 136.36,90.86 136.36,90.51 136.38,90.5 136.38,89.51 136.66,89.23 136.66,88.62 136.47,88.43
3D3V_S0 on TOP: 191.38,32.18 191.24,32.31 191.24,32.72 191.05,32.9 191.05,33.96 191.27,34.17 191.27,35.33 192.08,36.15 192.48,36.15 192.54,36.09 192.54,33.38 191.99,32.83 191.99,32.38 191.79,32.18
3D3V_S0 on TOP: 55.07,92.64 54.75,92.96 54.75,97.91 56.2,99.36 56.2,100.57 56.26,100.64 56.26,101.02 56.37,101.12 57.46,101.12 57.56,101.22 57.56,102.03 57.28,102.31 56.87,102.31 56.77,102.41 56.77,108.92 61.93,114.07 61.93,122.63 58.71,125.85 58.71,126.32 58.31,126.72 57,126.72 56.29,127.43 56.29,128.78 55.07,130 55.07,131.07 55.32,131.32 59.85,131.32 60.53,130.63 60.53,127.43 62.49,125.48 62.56,125.48 64.52,123.52 64.52,113.56 59.21,108.26 59.21,104.65 59.41,104.46 59.41,99.94 56.4,96.93 56.4,93.36 55.68,92.64 ; 2 cut-outs
3D3V_S0 on TOP: 27.41,21.72 27.31,21.82 27.31,22.68 27.77,23.14 27.77,23.65 29.82,25.71 29.82,26.97 29.63,27.16 28.44,27.16 28.36,27.24 28.36,27.65 28.41,27.7 29.55,27.7 31,29.15 31,32.65 33.28,34.93 35.59,34.93 36.3,34.22 41.29,34.22 43.03,32.48 43.03,31.24 43.31,30.96 49.41,30.96 51.54,33.1 51.54,36.93 52.84,38.23 52.84,39.52 53.22,39.9 53.22,41.07 53.32,41.17 53.95,41.17 54.74,41.96 56.39,41.96 56.65,41.71 56.65,32.44 55.32,31.12 55.15,31.12 52.3,28.27 41.51,28.27 41.05,28.73 41.05,31.12 40.11,32.06 33.73,32.06 32.52,30.84 32.52,28.8 31.58,27.87 31.58,22 31.52,21.95 30.97,21.95 30.94,21.97 30.94,22.91 30.71,23.14 29.7,23.14 29.39,22.84 29.39,22.51 29.31,22.43 28.48,22.43 28.35,22.3 28.35,21.85 28.22,21.72 ; 4 cut-outs
3D3V_S0 on TOP: 202.01,33.81 201.65,34.17 201.65,34.84 201.46,35.03 200.45,35.03 198.42,37.05 196.17,37.05 195.55,37.67 195.55,38.18 195.79,38.42 195.79,39.93 195.91,40.06 196.93,40.06 197.06,39.93 197.06,39.6 197.36,39.3 200.38,39.3 200.38,39.29 200.54,39.29 202.01,37.82 203.43,37.82 203.79,37.47 203.79,34.38 203.22,33.81 ; 2 cut-outs
3D3V_S0 on BOTTOM: 42.34,27.69 42.24,27.79 42.24,28.8 42.09,28.96 42.09,30.81 42.14,30.86 43.43,30.86 44.91,29.39 44.91,28.45 44.83,28.37 44.12,28.37 44.02,28.27 44.02,27.8 43.92,27.69 ; 4 cut-outs
3D3V_S0 on BOTTOM: 177.68,70.71 175.02,73.37 174.77,73.37 169.09,79.05 169.09,79.27 167.03,81.33 167.03,92.05 167.34,92.36 168.02,92.36 168.35,92.03 168.35,82.25 169.65,80.95 169.9,80.95 175.51,75.35 178.15,73.6 179.86,72.37 179.86,72.36 179.86,70.94 179.63,70.71 ; 1 cut-out
3D3V_S0 on BOTTOM: 43.95,112.7 42.42,114.23 42.42,120.83 42.8,121.21 45.72,121.21 46.99,119.94 46.99,117.15 47.63,116.51 50.99,116.51 50.99,116.53 51.15,116.7 51.15,117.39 51.51,117.74 52.79,117.74 53.06,117.46 53.82,117.46 54,117.64 54,119.77 53.88,119.89 53.88,123.36 53.11,124.13 53.11,128.15 53.39,128.43 53.39,130.05 54.14,130.81 56.8,130.81 57.31,131.32 57.97,131.32 58.14,131.14 58.14,128.7 58.07,128.63 57.38,128.63 57.23,128.78 55.45,128.78 54.99,128.32 54.99,127 56.11,125.88 56.11,124.03 57.28,122.86 57.28,122.15 57.18,122.05 57.18,119.42 56.14,118.38 56.14,115.82 55.44,115.12 54.18,115.12 53.98,115.32 53.98,115.5 53.72,115.75 53.69,115.75 53.53,115.58 52.32,115.58 51.6,114.86 49.41,114.86 49.41,113.84 48.9,113.34 45.72,113.34 45.09,112.7 ; 5 cut-outs
3D3V_S0 on BOTTOM: 137.97,108.82 137.87,108.92 137.87,109.18 138.02,109.33 138.07,109.33 138.12,109.38 138.12,111.67 138.18,111.72 138.99,111.72 139.18,111.53 139.18,111.51 139.32,111.37 139.32,109.23 139.04,108.95 138.4,108.95 138.28,108.82
3D3V_S0 on BOTTOM: 209.96,42.65 209.91,42.7 209.91,43.18 210.16,43.18 210.67,43.69 211.23,43.69 211.28,43.64 211.28,42.95 210.98,42.65
3D3V_S0 on L2SGND: 57.43,134.01 56.67,134.01 55.4,132.74 55.4,129.11 55.71,128.8 57.28,128.8 57.86,129.39 57.86,133.58
3D3V_S0 on L2SGND: outline of 86 points within 37.72,41.28 176.38,94.57
3D3V_S0 on L2SGND: 179.89,71.61 180.02,71.54 180.02,70.86 182.81,68.07 186.49,68.07 188.57,65.99 208.92,65.99 209.73,66.8 221.95,66.8 222.56,66.19 222.56,65.74 224.18,64.11 224.18,35.32 223.07,34.2 215.46,34.2 212.37,31.11 191.52,31.11 191.29,31.33 191.29,32.63 191.37,32.71 191.81,32.71 191.85,32.67 191.85,32.21 192,32.06 200.66,32.06 202.19,33.58 202.72,33.58 202.89,33.75 202.89,34.27 204.33,35.7 206.57,35.7 208.42,37.55 213.76,37.55 214.2,37.11 214.81,37.11 216.12,38.42 216.98,38.42 218.37,39.8 220.86,39.8 221.54,40.49 221.54,61.22 219.34,63.41 207.46,63.41 206.78,64.09 205.39,64.09 205.26,63.96 190.63,63.96 188.46,61.79 183.73,61.79 180.42,65.1 179.4,65.1 176.79,67.72 176.79,71.2 178.11,72.52 178.98,72.52
3D3V_S0 on L2SGND: 167.87,124.89 166.25,124.89 165.97,124.61 165.97,121.01 166.3,120.68 167.74,120.68 168.05,120.98 168.05,124.72
3D3V_S0 on L3: 163.76,94.79 167.26,94.79 168.47,93.59 168.47,82.59 169.75,81.31 169.93,81.31 170.03,81.21 170.03,81.19 170.36,80.86 170.37,80.86 179.32,71.91 179.32,71.45 179.14,71.26 177.33,71.26 166.43,82.16 166.43,84.03 165.84,84.62 165.84,89.64 157.62,97.86 157.62,98.01 157.51,98.12 157.51,103.23 163.02,108.74 165.64,108.74 165.92,109.02 165.92,111.71 165.13,112.5 165.13,120.07 165.51,120.45 165.51,124.28 166.09,124.87 168.25,124.87 168.48,124.64 168.48,112.45 168.13,112.09 168.13,106.55 167.21,105.64 162.99,105.64 159.69,102.34 159.69,98.86
3D3V_S5 on TOP: 216.2,45.39 216.03,45.55 216.03,46.47 215.95,46.55 215.95,46.56 215.42,46.56 215.15,46.29 215.15,46.09 214.94,45.87 214.3,45.87 214.25,45.92 214.25,46.33 214.51,46.58 214.51,46.84 214.91,47.25 216.21,47.25 216.88,46.58 216.89,46.58 217.13,46.82 217.13,48.06 217.28,48.21 218.13,48.21 218.24,48.33 218.24,48.75 218.52,49.02 218.85,49.02 219.36,49.53 224.77,49.53 224.89,49.4 224.89,47.89 224.69,47.69 219.89,47.69 219.89,47.63 219.47,47.2 219.47,46.98 218.92,46.43 218.92,46.17 218.14,45.39 ; 1 cut-out
3D3V_S5 on TOP: 54.77,103.91 53.85,104.83 52.68,104.83 52.56,104.95 52.56,105.82 52.68,105.94 53.08,105.94 53.23,106.1 53.23,106.9 53.55,107.21 53.55,107.39 53.72,107.57 53.72,107.8 54.54,108.61 54.54,109.4 60.07,114.94 60.07,121.72 59.46,122.33 59.34,122.33 56.7,124.97 55.78,124.97 55.38,125.38 55.38,126.39 55.78,126.8 56.24,126.8 56.57,126.47 58.42,126.47 58.6,126.28 58.6,125.71 61.7,122.61 61.7,114.2 56.44,108.94 56.44,104.25 56.1,103.91 ; 7 cut-outs
3D3V_S5 on TOP: 147.96,143.69 147.83,143.82 147.83,144.32 148.09,144.58 149.38,144.58 149.89,145.09 149.89,145.37 150.12,145.59 150.5,145.59 151.26,146.36 152.91,146.36 153.17,146.61 153.17,146.99 153.42,147.25 154,147.25 154.28,146.97 154.28,145.06 153.93,144.71 152.4,144.71 151.9,144.2 149.86,144.2 149.36,143.69 ; 2 cut-outs
3D3V_S5 on TOP: 41.43,68.76 41.33,68.86 41.33,69.37 40.9,69.8 40.9,70.16 40.76,70.29 40.16,70.29 40.11,70.35 40.11,70.8 40.19,70.88 42.01,70.88 42.11,70.79 42.11,69.85 42.58,69.38 42.58,68.89 42.45,68.76 ; 1 cut-out
3D3V_S5 on TOP: 219.46,66.96 219.23,67.18 219.23,67.72 220.27,68.76 220.68,68.76 220.88,68.56 220.88,67.54 220.3,66.96
3D3V_S5 on TOP: 20.88,72.95 20.74,73.1 20.74,73.25 20.58,73.41 20.09,73.41 20.02,73.48 20.02,73.89 20.09,73.97 20.58,73.97 21.58,74.97 22.1,74.97 22.28,74.78 22.28,74.54 22.12,74.38 21.97,74.38 21.95,74.37 21.76,74.37 21.52,74.12 21.52,73.05 21.42,72.95
3D3V_S5 on TOP: 181.51,69.06 180.06,70.51 180.06,71.05 180.27,71.25 181.56,71.25 182.38,70.44 182.38,69.37 182.07,69.06
3D3V_S5 on TOP: 79,30.15 77.09,32.06 77.09,35.1 75.95,36.25 75.95,36.63 76.58,37.26 77.47,37.26 78.49,36.25 78.49,33.58 80.39,31.68 80.39,30.41 80.14,30.15
3D3V_S5 on TOP: 152.89,138.63 152.68,138.84 152.68,139.22 152.53,139.37 152.05,139.37 151.97,139.45 151.97,140.01 152.05,140.08 153.24,140.08 153.52,139.8 153.52,138.84 153.32,138.63
